# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_GT: length 125.4
  TOP w0.127: v1(116.8,102.86) 116.8,102.81 v2(117.07,102.54) 116.8,102.26 v1(116.8,102.21) ; v1(116.8,102.86) 116.43,103.22 ; v1(116.8,102.86) 116.73,102.86 116.44,102.57 ; v1(119.29,101.57) 119.53,101.32 v1(119.53,101.25) 119.58,101.2 119.76,101.2 v1(120.07,101.01) 120.07,100.93 120.56,100.54 v1(120.63,100.55) 120.63,100.57 120.68,100.62 121.23,100.62 121.28,100.57 v1(121.28,100.55) 121.35,100.55 121.44,100.64 121.83,100.64 v1(121.92,100.55) 121.99,100.55 122.1,100.67 122.45,100.67 v1(122.56,100.55) ; v1(119.29,101.57) v10(119.04,101.89) v1(118.79,102.21) ; v1(119.29,101.57) 119.29,101.64 v1(119.53,101.89) 119.53,101.97 v2(119.29,102.21) ; v1(118.3,104.15) 118.3,104.24 118.52,104.47 v1(118.55,104.47) ; v1(119.04,103.82) 119.04,103.75 v1(119.29,103.5) v1(119.53,103.82) 119.53,103.9 v2(119.29,104.15) ; v1(119.04,103.82) 118.79,103.58 v1(118.79,103.5) 118.55,103.75 v1(118.55,103.82) ; v1(119.04,103.82) 119.04,103.9 v2(119.29,104.15) ; v1(119.53,103.18) v1(119.29,102.86) ; v1(119.29,102.86) v1(119.53,102.54) v2(119.29,102.21) ; v1(119.29,102.86) 119.04,102.61 v2(119.04,102.54) ; v1(118.79,102.21) 118.55,102.46 v2(118.55,102.54) ; v1(118.79,102.21) 118.55,101.97 v1(118.55,101.89) 118.3,102.14 v2(118.3,102.21) 118.3,102.29 v2(118.55,102.54) ; v1(118.79,102.21) 118.79,102.29 v2(119.04,102.54) ; 116.44,102.57 v1(116.8,102.21) ; v1(116.8,102.21) 116.79,102.21 116.45,101.87 ; v1(116.8,102.21) 116.8,102.16 v1(117.07,101.89) ; v2(116.8,104.15) 116.6,104.34 116.4,104.34 ; v2(116.8,104.15) 116.8,104.2 v1(117.07,104.47) ; v2(116.8,104.15) 116.57,103.92 116.38,103.92 v1(116.8,103.5) ; v2(116.8,104.15) 116.8,104.1 v1(117.07,103.82) 117.07,103.77 v1(116.8,103.5) ; v2(118.55,102.54) 118.55,102.61 v1(118.79,102.86) 118.79,102.78 v2(119.04,102.54) ; v2(118.55,102.54) 118.52,102.54 118.3,102.76 v1(118.3,102.86) ; v2(119.29,102.21) 119.04,102.46 v2(119.04,102.54) ; 116.52,103.22 v1(116.8,103.5) ; v2(119.29,104.15) 119.29,104.22 v1(119.53,104.47) ; v1(119.04,104.47) 118.79,104.22 v2(118.79,104.15)
  TOP w0.229: v1(120.07,101.57) v10(120.56,101.57) ; v1(120.07,101.57) v1(120.07,101.01) ; v1(120.07,101.57) v1(119.53,101.89) ; v10(120.07,107.15) v2(120.56,107.15) ; v1(123.04,108.27) v10(122.54,108.27) v1(122.05,108.27) v10(121.55,108.27) v1(121.06,108.27) v1(120.56,108.27) v10(120.07,108.27) ; v2(120.56,104.92) v1(120.07,104.92) ; v1(120.07,104.92) v2(119.53,105.11) ; v1(120.07,104.92) v1(119.53,104.47) ; v2(120.56,103.8) v1(120.07,103.8) v1(119.53,103.82) ; v1(119.53,102.54) v1(120.07,102.68) ; v1(120.07,102.68) v1(119.53,103.18) ; v1(120.07,102.68) v2(120.56,102.68) ; v2(119.53,105.76) v1(120.07,106.04) v2(120.56,106.04)
  TOP w0.254: PR920.2 v2(69.89,117.58) ; PL902.2 89.96,120.05 89.61,120.4 89.61,121.77 91.09,123.25 v1(91.09,123.3) ; v2(69.88,115.67) 69.89,115.65 PR907.2 ; v7(88.91,124.8) 89.26,124.44 PR906.2
  TOP w0.381: v2(120.56,102.68) v1(121.06,102.68) v2(121.55,102.68) v1(122.05,102.68) v10(122.54,102.68) v1(123.04,102.68) ; v1(123.04,104.92) v10(122.54,104.92) v1(122.05,104.92) v2(121.55,104.92) v1(121.06,104.92) v2(120.56,104.92) ; v2(120.56,103.8) v1(121.06,103.8) v2(121.55,103.8) v1(122.05,103.8) v10(122.54,103.8) v1(123.04,103.8) ; v1(123.04,107.15) v10(122.54,107.15) v1(122.05,107.15) v2(121.55,107.15) v1(121.06,107.15) v2(120.56,107.15) ; v1(123.04,101.57) v10(122.54,101.57) v1(122.05,101.57) v10(121.55,101.57) v1(121.06,101.57) v10(120.56,101.57) ; v1(123.04,106.04) v10(122.54,106.04) v1(122.05,106.04) v2(121.55,106.04) v1(121.06,106.04) v2(120.56,106.04)
  IN1 w0.254: v7(88.91,124.8) 90.4,123.3 v1(91.09,123.3) ; v1(119.53,103.82) 120.04,103.82 v1(120.07,103.8) v2(120.56,103.8) v1(121.06,103.8) v2(121.55,103.8) v1(122.05,103.8) v10(122.54,103.8) ; v2(119.53,105.11) 119.87,105.11 v1(120.07,104.92) v2(120.56,104.92) v1(121.06,104.92) v2(121.55,104.92) v1(122.05,104.92) v10(122.54,104.92) ; v1(120.07,101.57) v10(120.56,101.57) v1(121.06,101.57) v10(121.55,101.57) v1(122.05,101.57) v10(122.54,101.57) v1(123.04,101.57) ; v1(119.53,102.54) 119.68,102.68 v1(120.07,102.68) v2(120.56,102.68) v1(121.06,102.68) v2(121.55,102.68) v1(122.05,102.68) v10(122.54,102.68) ; v1(121.28,100.55) 121.23,100.6 120.68,100.6 v1(120.63,100.55) 120.18,101.01 v1(120.07,101.01) ; v1(119.29,102.86) 119.29,102.93 v1(119.53,103.18) 119.53,103.26 v1(119.29,103.5) ; v10(122.54,107.15) v1(122.05,107.15) 122.05,107.15 v2(121.55,107.15) v1(121.06,107.15) v2(120.56,107.15) v10(120.07,107.15) ; v10(120.07,108.27) v1(120.56,108.27) v1(121.06,108.27) v10(121.55,108.27) v1(122.05,108.27) v10(122.54,108.27) ; v2(121.55,106.04) v1(121.06,106.04) v2(120.56,106.04) v1(120.07,106.04)
  GND1 w0.254: v2(118.3,102.21) 118.19,102.11 117.91,102.11 v4(117.81,102.21) 117.81,102.29 v2(118.05,102.54) ; v10(120.07,107.15) v2(120.56,107.15) 120.88,107.15 v4(120.99,107.26) 121.1,107.15 v2(121.55,107.15) ; v10(120.07,108.27) 120.97,108.27 v4(120.99,108.29) 121.53,108.29 v10(121.55,108.27) v1(122.05,108.27) v4(122.06,108.29) 122.52,108.29 v10(122.54,108.27) ; v10(122.54,107.15) 122.22,107.15 v4(122.1,107.27) ; v4(121.54,100.52) 121.54,100.47 120.73,100.47 v4(120.68,100.52) ; v10(122.54,104.92) 122.41,104.78 v4(122.08,104.78) 121.69,104.78 v2(121.55,104.92) 121.37,104.73 120.99,104.73 v4(120.96,104.76) 120.72,104.76 v2(120.56,104.92) ; v4(119.84,106.05) 119.55,105.76 v2(119.53,105.76) ; v10(117.31,103.5) v4(117.63,103.06) ; v10(122.54,103.8) 122.41,103.67 v4(122.13,103.67) 121.99,103.8 v2(121.55,103.8) 121.15,103.8 v4(121.01,103.67) 120.7,103.67 v2(120.56,103.8) 120.56,103.79 120.46,103.69 v4(119.89,103.69) ; v10(122.54,106.04) 122.1,106.04 v4(122.08,106.05) 121.57,106.05 v2(121.55,106.04) 120.98,106.04 v4(120.96,106.05)
  IN2 w0.254: v2(69.89,117.58) 69.42,117.11 69.42,116.12 v2(69.88,115.67) 70.03,115.82 70.03,116.87 71.99,118.83 78.21,118.83 79.36,119.97 79.36,124.34 81.06,126.04 84.21,126.04 84.99,125.26 87.05,125.26 87.51,124.8 v7(88.91,124.8)
  GND4 w0.254: v16(107.6,103.49) v4(107.19,103.49) 107.19,103.16 v16(107.35,103.01) ; v16(109.91,103.06) 109.91,103.23 v4(109.68,103.46) 109.51,103.28 v16(109.51,103.06) ; v16(108.62,103.06) 108.62,103.31 v4(108.44,103.49) 108.21,103.26 v16(108.21,103.06)
  vias: v1(117.31,104.15) v1(117.31,102.86) v1(117.56,104.47) v1(117.56,103.82) v1(117.56,102.54) v1(117.56,101.89) v1(117.81,103.5) v1(117.81,102.86) v1(117.81,102.21) v1(118.05,104.47) v1(118.05,103.82) v1(118.05,101.89) v2(117.31,102.21) v2(117.81,104.15) v4(116.79,102.22) v4(118.78,102.19) v4(119.84,104.76) v4(119.89,102.75) v4(119.89,101.63) v4(121.01,102.75) v4(121.06,101.63) v4(122.13,102.78) v4(122.22,101.63) v6(117.3,101.99) v6(117.96,101.8) v7(88.68,116.82) v7(88.7,116.24) v7(89.24,116.82) v7(89.26,116.26) v7(89.26,115.71) v7(89.8,116.82) v7(89.82,116.24) v7(89.82,115.68) v7(90.38,116.82) v7(90.38,116.26) v7(90.38,115.68) v7(90.94,116.82) v7(90.94,116.26) v7(90.94,115.68) v7(91.5,116.82) v7(91.5,116.26) v7(91.5,115.68) v7(92.06,116.82) v7(92.06,116.26) v7(92.06,115.68) v7(92.61,116.82) v7(92.61,116.26) v7(92.61,115.68) v7(93.17,116.82) v7(93.17,116.26) v7(93.17,115.68) v7(93.76,116.82) v7(93.76,116.24) v7(93.76,115.68) v7(94.32,116.82) v7(94.32,116.24) v7(94.33,115.68) v7(102.08,107.49) v7(102.08,106.82) v7(102.6,107.07) v7(108.49,104.63) v7(108.87,102.36) v7(109.23,104.63) v7(109.44,102.36) v7(110,102.36) v7(110.56,102.36) v7(112.29,103.34) v7(113.14,103.79) v7(113.28,102.32) v7(113.77,103.79) v7(113.85,102.34) v7(114.41,102.32) v7(114.53,103.79) v7(114.98,102.34) v7(115.27,104.07) v7(115.3,103.46) v7(115.8,102.87) v7(115.91,104.07) v7(115.88,103.46) v9(118.42,104.75) v9(119.01,106.05) v9(118.98,104.77) v9(119.06,101.54) v9(119.51,106.04) v9(119.51,104.75) v9(119.56,103.55) v9(119.56,102.84) v9(119.56,101.6) v9(120.22,108.29) v9(120.17,106.05) v9(120.17,104.76) v9(120.22,103.56) v9(120.22,102.85) v9(120.22,101.61) v9(120.25,100.57) v9(120.63,108.29) v9(120.63,106.04) v9(120.63,104.75) v9(120.66,107.25) v9(120.68,103.53) v9(120.68,102.84) v9(120.73,101.6) v9(121.07,100.57) v9(121.32,107.26) v9(121.29,106.05) v9(121.29,104.76) v9(121.34,103.54) v9(121.34,102.85) v9(121.42,108.29) v9(121.39,101.61) v9(121.72,108.29) v9(121.75,106.04) v9(121.75,104.75) v9(121.77,107.26) v9(121.8,103.53) v9(121.8,102.87) v9(121.89,101.6) v9(121.92,100.57) v9(122.42,108.29) v9(122.43,107.27) v9(122.41,106.05) v9(122.41,104.76) v9(122.46,103.54) v9(122.46,102.88) v9(122.55,101.61) v10(110.85,103.98) v10(111.16,103.97) v10(111.74,103.94) v10(112.3,103.93) v10(118.3,103.5) v14(111.84,105.27) v17(118.45,107.26) v17(118.42,106.05) v17(118.45,103.55) v17(118.47,102.84) v17(119.01,107.26) v17(119.03,103.55) v17(119.06,102.84) v17(119.56,107.25) v17(120.15,107.25) v17(122.94,107.27) v17(122.92,106.05) v17(122.92,104.76) v17(122.97,103.54) v17(122.97,102.85)
+VCC_SA: length 80.8
  TOP w0.127: v1(127.07,100.06) v1(126.75,100.31) v1(127.07,100.55) 127.5,100.97 UC1.R29
  TOP w0.254: RC167.1 109.58,109.3 v10(109.05,109.84) ; v1(81.21,93.89) 81.79,94.47 81.79,95.53 82.59,96.33 82.59,98.2 82.85,98.46 PL1001.2 ; v7(78.7,95.77) 78.53,95.6 PR1005.2 78.47,94.72 78.04,94.72 77.73,94.42 v1(77.73,93.61) ; 104.86,96.99 v7(104.91,96.93)
  TOP w0.381: v1(127.5,107.71) v10(127.5,107.15) ; v10(127.5,107.15) v1(127,107.15) ; v10(127.5,107.15) v1(127.5,106.59) v10(127.5,106.04) ; v1(127,102.68) v10(127.5,102.68) ; v10(127.5,102.68) v1(127.5,103.24) v10(127.5,103.8) ; v10(127.5,102.68) v1(127.5,102.12) v10(127.5,101.57) ; v10(127.5,106.04) v1(127,106.04) ; v10(127.5,106.04) v1(127.5,105.48) v10(127.5,104.92) ; v10(127.5,103.8) v1(127.5,104.36) v10(127.5,104.92) ; v10(127.5,103.8) v1(127,103.8) ; v10(127.5,104.92) v1(127,104.92) ; v10(127.5,101.57) v1(127,101.57) ; v10(127.5,101.57) UC1.R29
  TOP w0.508: PR1007.2 68.1,105.55 PC1004.2
  IN1 w0.254: v7(104.91,96.93) 104.55,96.93 104.26,96.64 103.51,96.64 103.24,96.91 103.24,97.65 103.61,98.01 104.39,98.01 104.63,98.26 105.04,98.26 105.87,99.09 105.87,99.68 105.63,99.92 104.77,99.92 104.16,100.53 103.1,100.53 101.17,102.46 v5(101.17,104.76) ; v1(81.21,93.89) 78.01,93.89 v1(77.73,93.61)
  GND1 w0.119: v4(127.47,101.07) 127.39,100.99 v3(127.39,100.74) ; v4(127.13,107.11) 127.13,107.12 127.19,107.17 127.48,107.17 v10(127.5,107.15) ; v10(127.5,104.92) v4(127.13,104.92) ; v10(127.5,103.8) v4(127.13,103.8) ; v10(127.5,106.04) 127.44,105.98 v4(127.13,105.98) ; v10(127.5,102.68) v4(127.13,102.68) ; v4(127.13,101.57) v10(127.5,101.57)
  GND1 w0.254: v4(100.69,105.09) 100.72,105.11 100.82,105.11 v5(101.17,104.76) ; v10(109.05,109.84) 109.05,109.66 v4(108.74,109.36)
  IN2 w0.254: v7(78.7,95.77) 78.29,95.77 77.25,96.81 77.25,97.65 75.65,99.25 73.11,99.25 68.61,103.74 68.61,105.03 v2(68.21,105.43)
  GND4 w0.254: v9(100.13,104.91) 100.51,104.91 v4(100.69,105.09) ; v16(127.63,101.66) 127.52,101.56 127.14,101.56 v4(127.13,101.57) ; v4(127.13,102.68) 127.17,102.65 v16(127.51,102.65) ; v9(127.88,101.33) 127.62,101.07 v4(127.47,101.07) ; v16(127.49,103.79) 127.14,103.79 v4(127.13,103.8) ; v4(108.74,109.36) v9(108.31,109.36)
  BOTTOM w0.254: 127.74,100.87 127.66,100.79 127.65,100.79 127.65,100.15 128.23,99.58 128.23,98.48 128.02,98.28 127.41,98.28 127.13,98.56 RC149.1 ; v9(108.31,109.36) 107.47,108.52 101.45,108.52 100.12,107.18 100.12,104.92 v9(100.13,104.91)
  vias: v4(126.94,94.76) v4(133.57,90.99) v4(134.02,91) v7(83.67,96.43) v7(83.95,95.79) v7(84.44,96.43) v7(84.66,95.79) v7(85.07,96.43) v7(85.35,95.79) v7(85.83,96.43) v7(86.09,95.77) v7(86.47,96.43) v7(86.7,95.79) v7(87.1,101.25) v7(87.1,100.62) v7(87.1,99.98) v7(87.1,99.35) v7(87.1,98.71) v7(87.1,98.08) v7(87.1,97.44) v7(87.1,96.43) v7(87.43,96.93) v7(105.47,96.93) v7(106.03,96.93) v9(127.83,105.08) v9(127.92,106.23) v9(127.88,101.91) v9(127.97,107.35) v10(127.11,94.39) v10(127.11,94.09) v10(133.42,90.58) v10(133.44,90.28) v10(133.73,90.59) v14(101.99,90.89) v16(127.03,95.16) v16(127.31,94.48) v16(127.54,107.15) v16(127.51,106.05) v16(127.49,104.94) v16(127.62,94.48) v16(132.95,90.87) v16(133.19,91.05) v17(101.58,89.44) v17(101.58,89.06) v17(101.96,89.44) v17(101.96,89.06) v17(102.34,89.44) v17(102.34,89.06) v17(127.91,106.87) v17(127.91,105.6) v17(127.88,104.4) v17(127.88,103.13)
+VCCCLK: length 93.6
  TOP w0.229: v2(130.47,101.01) v1(130.47,101.57) ; v2(129.97,101.01) v2(129.48,101.01)
  TOP w0.254: RH32.2 138.27,101.25 139.99,101.25 140.1,101.14 140.35,101.14 v1(140.72,100.77)
  TOP w0.381: v10(129.48,102.12) v1(129.48,102.68) ; v2(130.47,102.68) UC1.V19 v1(130.47,101.57) ; v1(130.96,102.12) v2(130.96,102.68) ; v1(129.97,102.12) v2(129.97,102.68)
  TOP w0.508: v7(145.62,92.49) 145.24,92.87 RC159.2 143.81,92.87 CC51.1 143.74,92.69 v7(143.17,92.12)
  IN1 w0.254: v5(146.89,99.5) 146.84,99.45 146.84,98.6 147.38,98.06 147.38,97.76 146.85,97.24 143.07,97.24 142.78,97.53 142.78,98.59 141.65,99.72 141.65,99.84 v1(140.72,100.77)
  IN1 w0.381: v2(129.48,101.01) v2(129.97,101.01)
  GND1 w0.254: v4(147.28,99.42) 147.19,99.51 146.9,99.51 v5(146.89,99.5) ; v4(130.98,101.2) 130.78,101.01 v2(130.47,101.01) v2(129.97,101.01) v2(129.48,101.01) ; v2(130.47,102.68) 130.47,102.4 130.64,102.07 v4(130.64,102.05)
  IN2 w0.254: v2(130.47,101.01) 130.78,101.01 v4(130.98,101.2) ; v2(129.97,102.68) 129.3,102.68 v4(129.27,102.71) ; v2(130.47,102.68) 130.47,102.22 v4(130.64,102.05) ; v2(130.96,102.68) 131.29,102.68 v4(131.32,102.71)
  GND2 w0.381: v4(130.98,101.2) 130.99,101.2 131.73,100.47 132.52,100.47 133.23,99.75 133.23,99.02 133.69,98.56 134.12,98.56 134.52,98.15 134.52,97.19 135.24,96.48 136.12,96.48 137.19,95.41 138.72,95.41 140.29,93.84 144.28,93.84 v7(145.62,92.49) ; v4(131.32,102.71) 131.72,102.71 134.27,100.16 135.52,100.16 136.07,99.6 136.58,99.6 137.52,98.66 138.59,98.66 138.64,98.71 141.31,98.71 142.09,97.93 143.47,97.93 143.74,98.2 145.75,98.2 146.95,99.4 147.25,99.4 v4(147.28,99.42) ; v7(143.17,92.12) 143.17,92.13 142.66,92.13 141.81,92.97 138.79,92.97 137.27,94.5 135.36,94.5 132.98,96.88 131.29,96.88 130.58,97.59 130.58,99.94 130.46,100.06 130.46,101.57 v4(129.97,102.05)
  IN3 w0.254: v4(147.28,99.42) 147.61,99.42 148.23,98.8 v6(148.23,98.56)
  GND4 w0.254: v9(130.71,102.57) 131.18,102.57 v4(131.32,102.71) ; v9(130.13,102.6) 130.13,102.21 v4(129.97,102.05)
  BOTTOM w0.254: v6(148.23,98.56) 148.23,95.32 145.62,92.72 v7(145.62,92.49)
  vias: v5(129.48,102.4) v5(131.07,102.45) v8(129.97,102.41)
+VCCCOREG0: length 7.8
  TOP w0.229: UC1.R35 v10(125.51,101.57) ; UC1.R38 v10(124.52,101.57)
  TOP w0.381: v10(124.52,101.57) v1(124.52,102.12) v10(124.52,102.68) v1(124.52,103.24) v10(124.52,103.8) ; v10(125.51,101.57) v1(125.51,102.12) v10(125.51,102.68) v1(125.51,103.24) v10(125.51,103.8)
  GND1 w0.119: v4(124.16,103.8) v10(124.52,103.8) ; v4(125.15,103.8) v10(125.51,103.8)
  GND1 w0.254: v4(125.15,102.68) v10(125.51,102.68) ; v4(124.16,102.68) v10(124.52,102.68) ; v4(124.16,101.57) v10(124.52,101.57) ; v4(125.15,101.57) v10(125.51,101.57)
  vias: v9(124.85,101.38) v9(124.87,103.01) v9(125.48,103.97) v9(125.48,102.85) v9(125.46,101.74) v16(124.59,102.65) v16(124.75,103.84) v17(124.83,102.52) v17(124.84,100.78) v17(125.5,103.44) v17(125.5,102.35) v17(125.5,101.23) v17(125.5,100.08)
+VCCCOREG1: length 9.5
  TOP w0.381: v10(124.52,104.92) v1(124.52,105.48) v10(124.52,106.04) v1(124.52,106.59) v10(124.52,107.15) v1(124.52,107.71) ; v1(125.51,107.71) v10(125.51,107.15) v1(125.51,106.59) v10(125.51,106.04) v1(125.51,105.48) v10(125.51,104.92)
  GND1 w0.254: v4(125.15,106.04) 125.15,106.03 125.16,106.04 v10(125.51,106.04) ; v4(125.15,104.92) v10(125.51,104.92) ; v10(124.52,106.04) 124.17,106.04 124.16,106.03 v4(124.16,106.04) ; v10(125.51,107.15) 125.16,107.15 125.15,107.14 v4(125.15,107.15) ; v4(124.16,104.92) v10(124.52,104.92) ; v4(124.16,107.15) v10(124.52,107.15)
  GND4 w0.254: v16(124.5,104.82) 124.26,104.82 v4(124.16,104.92) ; v9(125.48,105.06) 125.28,105.06 125.15,104.94 v4(125.15,104.92) ; v4(124.16,106.04) 124.37,105.82 v16(124.57,105.82) ; v4(124.16,107.15) 124.32,107.31 v16(124.49,107.31)
  vias: v9(125.5,107.3) v9(125.5,106.18) v9(125.56,108.52) v16(124.9,106.33) v16(125.06,106.79) v17(124.82,107.74) v17(124.82,106.61) v17(124.82,106.03) v17(124.82,104.82) v17(125.51,107.93) v17(125.51,106.82) v17(125.51,105.7) v17(125.5,104.58)
+VCCPRIM_1P0: length 18.6
  TOP w0.203: v2(132.44,105.44) 131.99,105.44 v2(131.95,105.48)
  TOP w0.229: v1(129.97,108.27) v10(129.97,107.71)
  TOP w0.381: v10(130.47,105.48) v1(130.96,105.48) v10(130.96,106.04) v1(130.96,106.59) ; CC34.1 v10(136.96,102.52) 136.94,102.55 135.72,102.55
  TOP w0.508: RC160.2 150.65,103.04 CC37.1 150.09,102.14 v10(150.04,102.19)
  IN1 w0.254: v10(131.46,103.24) v2(131.95,103.24)
  IN1 w0.305: v1(129.97,108.27) v10(129.97,107.71)
  IN1 w0.381: v1(130.96,105.48) v10(130.47,105.48)
  GND1 w0.254: v10(136.96,102.52) 136.76,102.52 v4(136.61,102.67) ; v10(129.97,107.71) 129.97,108.15 v4(130.06,108.24) ; v2(131.95,103.24) 132,103.24 v4(132.26,103.5)
  GND1 w0.508: v10(150.04,102.19) 149.85,102.38 149.85,103.08 v4(149.84,103.09)
  IN2 w0.06: 130.79,107.61 130.79,107.63 130.6,107.82 ; 130.24,107.73 130.17,107.66 130.17,107.36 130.28,107.25 ; 131.27,107.98 131.27,108.01 131.04,108.24
  GND2 w0.203: v4(132.26,103.5) 132.28,103.49 136.37,103.49 136.61,103.25 v4(136.61,102.67)
  GND4 w0.254: v9(131.93,103.2) 131.96,103.2 v4(132.26,103.5) ; v16(131.28,105.44) 131.07,105.65 v4(130.85,105.65) ; v9(130.13,107.86) 130,107.99 130,108.2 130.07,108.27 130.07,108.25 v4(130.06,108.24)
  BOTTOM w0.254: v9(130.13,107.86) 130.13,107.74 130.32,107.55 CC32.1
  vias: v4(132.04,105.93) v5(130.95,106.34) v9(149.79,103.49) v16(150.13,102.75) v17(131.81,105.82) v17(132.53,105.7)
+VCCPRIM_3P3: length 10
  TOP w0.381: v1(129.97,105.48) v10(129.97,106.04) ; v1(130.47,106.59) v10(130.47,106.04)
  IN1 w0.381: v1(129.97,105.48) v10(129.97,106.04)
  GND1 w0.119: v4(130.01,105.65) 130,105.74
  GND1 w0.254: 130,105.74 129.97,105.76 v10(129.97,106.04)
  IN2 w0.381: v4(136.49,104.18) 136.76,103.92 v2(136.79,103.92)
  GND2 w0.508: v4(136.49,104.18) 136.48,104.2 134.5,104.2 133.59,105.11 132.62,105.11 132.34,105.39 131.76,105.39 131.45,105.7 131.45,105.95 130.71,106.69 v4(130.71,106.9)
  VCC w0.254: v16(130.41,106.69) 130.51,106.59 v9(130.51,106.37)
  vias: v5(130.47,106.32) v9(130.45,105.72) v9(130.36,105.32)
+VCCPRIM_CORE: length 3.5
  TOP w0.229: v1(131.46,108.27) v10(131.46,107.71)
  TOP w0.508: RC162.2 150.4,101 150.3,100.9 150.3,100.19 v7(150.43,100.06)
  IN2 w0.254: v2(130.96,104.36) 130.72,104.6 v4(130.72,104.64)
  GND4 w0.254: v9(132.4,107.98) 132.06,107.98 131.8,108.25 131.46,108.25 131.42,108.29 v4(131.42,108.3)
  GND4 w0.508: v4(130.72,104.64) 130.46,104.38 v9(130.46,104.38)
  vias: v5(131.46,107.97) v10(130.47,104.92) v10(130.47,104.36) v10(130.96,104.92)
+VDDQ_CPU_CLK: length 107.4
  TOP w0.254: v10(111.61,105.06) 111.82,105.06 RH61.2 ; CC16.1 132.04,93.58 RC102.2 132.04,92.78 v1(132.45,92.36) ; v1(131.91,83.08) 131.49,82.66 128.96,82.66 128.37,83.26 128.37,83.99 128.14,84.22 126.23,84.22 125.41,85.04 v1(125.41,85.94)
  IN1 w0.254: v1(125.41,85.94) 125.16,85.68 122.75,85.68 122.28,85.22 114.04,85.22 113.55,85.71 109.21,85.71 107.91,87.01 105.44,87.01 104.6,87.85 102.6,87.85 102.17,88.28 101.68,88.28 98.84,91.12 98.61,91.12 v5(97.9,91.83) ; v1(132.45,92.36) 132.45,91.38 133.07,90.77 133.07,84.37 131.91,83.21 v1(131.91,83.08)
  GND1 w0.254: v10(111.61,105.06) 111.59,105.06 v4(111.26,104.73) ; v5(97.9,91.83) 97.56,91.83 v4(97.44,91.95)
  IN2 w0.152: v4(124.51,109.45) 124.51,109.44 124.5,109.42 v2(124.17,109.42)
  IN3 w0.254: v6(103.18,109) 105.12,107.06 109.11,107.06 111.26,104.91 v4(111.26,104.73)
  GND4 w0.254: v9(124.52,110.27) 124.51,110.26 v4(124.51,109.45) ; v9(97.36,92.39) 97.36,92.03 v4(97.44,91.95)
  BOTTOM w0.254: v9(124.52,110.27) 124.29,110.27 123.12,111.44 118.78,111.44 117.1,109.76 106.42,109.76 v14(106.03,109.37) 105.66,109 v6(103.18,109) 101.33,109 98.23,105.9 98.23,94.69 97.36,93.82 v9(97.36,92.39)
AGND: length 25.1
  TOP w0.203: UA1.20 24.7,19.43 24.59,19.54 24.05,19.54 23.92,19.41 CA30.2 ; UA1.30 27.31,14.84 26.88,14.41 v7(26.88,14.46) ; CA34.2 32.49,13.11 32.49,14.54 32.11,14.92 UA1.42
  TOP w0.254: v7(35.41,13.84) CA26.2 ; CA4.2 34.84,15.74 v7(35.01,15.58) ; CA30.2 24.42,19.06 v7(24.44,19.08)
  TOP w0.305: JHP1.9 v7(23.21,4.95) ; v7(23.15,16.65) CA2.2
  TOP w0.33: v7(24.47,15.32) 24.39,15.32 23.92,14.85 23.92,14.51 CA5.2
  TOP w0.381: v7(19.26,3.28) 19.24,3.3 JHP1.11 ; QA1.1 18.46,13.25 v7(18.35,13.37) 18.09,13.62 18.09,13.9 17.44,14.55 QA1.4 ; v7(20,14.54) 20.05,14.59 JPA2.2 19.73,15.12 19.35,15.5 RA19.2 ; CA31.2 22.26,18.85 v7(22.66,19.26) ; v7(24.72,4.22) 24.71,4.22 JHP1.12 ; CA2.2 CA28.2
  TOP w0.508: CA29.2 22.97,16.47 v7(23.15,16.65) ; v7(25.91,9.84) 25.89,9.86 RA4.2 CA11.2 ; v7(33.1,13.9) 33.1,13.22 CA34.2 ; Q68.3 v7(16.98,10.99) ; v1(20.19,10.96) CA17.2
  vias: v2(21.96,16.3) v2(24.11,12.76) v2(25,12.76) v7(24.75,7.07) v7(37.7,14) v7(38.08,16.42) v7(38.08,15.15) v7(38.21,18.45) v7(38.21,17.69) v10(26.78,12.66) v10(27.67,12.66) v14(27.41,12.68) v14(35.41,11.6)
AGND_CAM: length 21.9
  TOP w0.119: v1(129.89,132.5) 129.89,132.96 129.64,133.21 J3.1 ; v1(114.42,130.15) 114.2,129.93 114.2,128.47 113.57,127.83 JPA4.2
  IN1 w0.089: v1(129.89,132.5) 129.37,131.98 127.39,131.98 127,132.37 126.21,132.37 126.05,132.22 124.9,132.22 123.95,133.17 121.5,133.17 120.69,132.35 116.61,132.35 114.59,130.34 114.59,130.32 v1(114.42,130.15)
DV12S: length 7.8
  TOP w0.203: UR1.14 27.18,82.07 26.62,82.62 26.62,82.94
  TOP w0.381: CR5.1 27.18,83.82 27.18,83.37 v7(27.24,83.32)
  TOP w0.508: v7(25.94,83.05) 26,83.12 26,83.31 26.38,83.69 CR6.1 26.62,83.45 26.62,82.94
  IN2 w0.508: v7(29.79,83.14) 27.41,83.14 v7(27.24,83.32) 26.2,83.32 v7(25.94,83.05)
DV33_18: length 1.7
  TOP w0.203: 24.97,80.59 24.99,80.57 UR1.18
  TOP w0.381: 24.97,80.59 CR1.2
GND: length 6221.2
  TOP w0.06: v10(125.14,98.58) UC1.E34 v10(126.43,98.58) ; v10(132.87,112.13) UC1.BM14 v10(131.58,112.13) UC1.BM18 ; v10(119.34,111.15) UC1.BH52 v10(120.63,111.15) ; 129.25,108.93 v1(129.01,108.69) ; 129.25,108.93 v10(129.01,109.18) ; 129.25,108.93 UC1.AW23 ; v10(118.45,99.88) 118.51,99.81 v10(119.02,99.81) UC1.K53 v10(120.31,99.81) UC1.K49 v10(121.6,99.81) UC1.K45 v10(122.89,99.81) v10(123.53,99.81) v10(124.17,99.81) v10(124.82,99.81) UC1.K35 v10(126.11,99.81) v10(126.75,99.81) UC1.K29 UC1.K27 v10(128.68,99.81) v10(129.33,99.81) v10(129.97,99.81) v10(130.62,99.81) v10(131.26,99.81) v10(131.9,99.81)
  TOP w0.102: v10(160.38,125.13) 160.56,125.13 160.84,124.85 160.84,123.71 160.77,123.63 160.77,123.18 160.48,122.89 160.48,122.26 160.59,122.16 160.59,121.85 PC500.2 ; R1408.2 27.94,27.79 27.94,28.91 27.59,29.25 27.59,29.34 v10(27.5,29.43) ; v10(22.94,48.95) 22.85,49.04 22.85,49.23 22.75,49.33 U719.L1 ; v10(159.49,121.06) 159.21,121.06 158.55,121.72 158.55,124.26 159.07,124.79 v10(159.62,124.79) ; v10(27.45,26.73) 27.79,26.39 28.28,26.39 28.38,26.49 28.38,27.74 28.36,27.75 28.36,29.05 28.21,29.2 v10(28.21,29.33) ; v10(136.14,100.47) 136.56,100.47 137,100.02 137.41,100.02 137.71,99.72 138.64,99.72 138.97,99.39 140.38,99.39 140.46,99.46 141.24,99.46 141.37,99.59 142.08,99.59 142.18,99.49 142.18,99.33 142.46,99.06 142.74,99.06 142.81,99.13 142.81,100.38 142.88,100.45 146.69,100.45 146.74,100.4 146.74,97.32 146.63,97.2 142.58,97.2 CH3.2 141.48,96.52 141.24,96.76 141.08,96.76 v10(140.98,96.87) 141.31,97.2 141.31,97.43 141,97.73 140.44,97.73 139.68,98.5 138.55,98.5 138.2,98.85 137.12,98.85 136.33,99.64 v10(136.29,99.64)
  TOP w0.107: v10(132.44,101.57) 132.35,101.66 132.35,102.13 v10(132.44,102.22) 132.44,102.27 132.28,102.42 132.22,102.55 ; 132.22,102.55 UC1.Y15 132.13,102.86 v10(132.44,102.86) ; 132.22,102.55 132.35,102.61 132.44,102.69 v10(132.44,102.86) ; v10(132.44,102.86) 132.37,102.93 132.37,103.44 132.44,103.5 UC1.AB13 132.41,103.53 132.41,104.12 132.44,104.15 UC1.AD13 132.39,104.19 132.39,104.75 v10(132.44,104.79)
  TOP w0.127: v10(142.78,134.68) 142.71,134.61 JP1.2 ; v1(116.8,104.79) v10(117.31,104.79) v10(117.81,104.79) v10(118.3,104.79) v10(118.79,104.79) v10(119.29,104.79) ; JP1.26 v10(147.51,134.73) ; v10(117.07,103.18) v1(117.56,103.18) v10(118.05,103.18) v10(118.55,103.18) v1(119.04,103.18) ; v10(132.23,100.55) 132.07,100.71 131.74,100.71 v10(131.58,100.55) 131.46,100.67 131.19,100.67 131.07,100.55 v1(130.94,100.55) 130.75,100.55 130.67,100.64 130.38,100.64 v10(130.29,100.55) 130.25,100.6 129.7,100.6 v1(129.65,100.55) 129.59,100.62 129.07,100.62 v1(129.01,100.55) ; v10(118.45,99.88) 118.13,99.88 v10(118.05,99.96) v10(117.56,99.96) 117.56,99.88 v10(117.31,99.64) ; v1(119.29,100.92) 119.29,101 v10(119.04,101.25) 119.04,101.32 v10(118.79,101.57) v1(118.3,101.57) v10(117.81,101.57) v1(117.31,101.57) v10(116.8,101.57) ; UT1.J23 23.87,40.88 23.97,40.97 23.97,41.68 v7(23.82,41.83) ; PU500.C13 v10(169.99,125.2) ; 128.99,100.56 128.95,100.61 128.42,100.61 v1(128.36,100.55)
  TOP w0.152: UT1.L23 24.79,41.08 v7(24.86,41.14) ; 20.67,33.5 21.01,33.84 v10(21.01,33.9) ; UC1.BL8 133.71,111.79 134.13,112.21 v10(134.13,112.22) ; CC16.2 131.27,93.66 131.55,93.38 v10(131.55,93.2) ; v10(118.7,111.15) UC1.BK56
  TOP w0.178: v10(24.33,30.74) 24.33,30.75 24.65,31.07 24.93,31.07 v10(25.25,30.74) ; v10(24.33,30.74) UT1.K1 24.33,29.86 v7(24.48,29.71) ; v10(24.33,30.74) 24,31.08 23.75,31.08 v10(23.41,30.74) ; UT1.H8 23.31,33.39 v7(23.63,33.07) 23.95,33.39 UT1.J8 ; UT1.H8 UT1.F9 22.33,34.36 ; UT1.H8 23.3,33.38 v10(22.94,33.02) 22.66,32.74 UT1.F6 22.36,32.44 v10(22.27,32.44) ; UT1.D13 v7(21.68,35.66) UT1.D12 UT1.B12 UT1.A12 19.66,35.34 19.27,34.95 v7(18.9,34.95) ; UT1.D13 21.36,35.99 v7(21.68,36.32) ; UT1.D13 21.08,36.26 UT1.B14 UT1.A14 19.93,36.26 19.67,36 19.37,36 19.22,35.85 v7(18.89,35.85) ; v10(27.2,32.09) v7(27.53,32.41) ; v10(27.2,32.09) v10(26.55,32.09) ; v10(27.2,32.09) 27.47,31.82 v10(27.49,31.82) 27.59,31.82 UT1.V5 v7(28.18,32.41) ; v7(27.53,32.41) UT1.T6 27.2,32.78 27.37,32.95 27.37,33.22 v10(27.2,33.39) ; v7(27.53,32.41) UT1.V6 v7(28.18,32.41) ; UT1.J22 23.95,39.86 UT1.J20 ; UT1.J22 23.87,39.81 UT1.H20 23.3,39.59 UT1.G22 ; UT1.J22 UT1.J23 ; 22.33,38.92 21.03,38.92 21,38.9 ; 22.33,38.92 22.65,39.24 v10(22.65,39.24) ; 22.33,38.92 v7(22.33,37.63) ; UT1.L15 v7(24.28,36.31) ; v7(24.28,36.31) UT1.L13 v7(24.28,35.66) ; v7(24.28,36.31) 24.28,36.31 UT1.J13 ; v7(24.28,36.31) UT1.J15 v7(23.63,36.31) ; v10(21.68,32.32) 21.9,32.09 v10(22,32.09) ; v10(21.68,32.32) 21.68,32.41 UT1.E6 ; v10(21.68,32.32) 21.45,32.09 UT1.D5 ; v10(30.31,30.28) UT1.AC2 ; UT1.T18 27.53,38.26 v7(28.18,38.26) ; UT1.T18 UT1.V16 ; UT1.T18 27.2,37.94 v7(26.88,38.26) ; UT1.T18 v7(26.88,37.61) ; UT1.AB16 29.52,36.85 29.52,36.61 29.57,36.56 29.57,36.28 29.59,36.26 ; UT1.AB16 29.83,37.18 29.39,37.62 ; UT1.AB16 UT1.AC16 ; v1(130.96,101.01) 130.96,100.58 v1(130.94,100.55) ; v7(20.3,41.38) 20.61,41.08 20.61,41.03 21.11,40.52 UT1.C23 UT1.C22 UT1.B22 ; UC1.G14 UC1.E14 UC1.C14 UC1.A14 ; v7(19.23,37.84) 19.49,38.1 UT1.A18 v10(20.65,38.1) ; UT1.G22 UT1.G23 ; UT1.G22 22.95,39.54 v10(22.65,39.24) ; UT1.AB20 29.63,39.24 v10(29.15,39.24) ; UT1.AB20 29.52,38.69 29.52,38.41 29.83,38.1 29.85,38.1 29.85,38.1 ; UT1.AB20 UT1.AC20 ; v10(22.27,32.44) 22.62,32.09 UT1.F5 22.81,32.25 23.1,32.25 23.26,32.09 v10(23.3,32.09) 23.39,32.18 23.87,32.18 UT1.J5 UT1.L5 v7(24.93,32.41) v10(25.25,32.09) 25.42,32.26 25.73,32.26 UT1.N5 v10(26.55,32.09) ; v10(22.27,32.44) 22,32.71 UT1.E6 ; v10(22.27,32.44) 22.27,32.36 v10(22,32.09) ; 21.35,35.31 UT1.D11 ; UT1.D11 21.35,34.66 v10(21.11,34.41) 21.1,34.42 UT1.B10 UT1.A10 ; UT1.D11 v7(21.68,34.36) ; v10(118.3,109.3) 118.3,109.37 v10(118.05,109.62) ; v10(27.85,34.04) v7(28.18,33.71) ; v10(27.85,34.04) 27.85,34.11 28.18,34.44 28.18,35.01 v7(28.18,35.01) v7(28.18,35.66) UT1.W13 28.71,35.79 28.95,35.79 UT1.Y13 ; v10(27.85,34.04) v10(27.2,34.04) 27.41,33.84 27.41,33.59 v10(27.2,33.39) ; v7(28.18,33.71) v10(27.85,33.39) v10(27.2,33.39) ; v7(28.18,33.71) v10(28.5,33.39) ; v7(28.18,33.71) v10(28.5,34.04) ; UT1.E11 22.33,34.36 ; 22.33,34.36 UT1.E9 ; v7(19.32,39.04) 19.33,39.03 20.18,39.03 UT1.A20 v10(20.65,39.02) ; v10(20.65,38.1) 21.19,38.1 UT1.D18 21.35,37.94 v7(21.68,37.61) UT1.D16 ; v10(20.65,38.1) 21.04,38.49 21.04,38.86 21,38.9 ; UT1.E6 v7(21.68,33.06) ; v7(24.28,35.66) UT1.J12 v7(23.63,35.66) ; v7(24.28,35.66) 24.93,35.66 UT1.M12 ; v7(24.28,35.66) UT1.J13 ; UT1.AA22 UT1.AA23 29.39,40.65 29.71,40.96 v7(29.71,40.96) ; UT1.AA22 29.39,39.48 v10(29.15,39.24) ; UT1.AA22 UT1.AB22 UT1.AC22 ; v7(26.88,38.26) 26.56,37.94 UT1.R18 v7(26.88,37.61) ; v7(26.88,38.26) 26.55,38.59 UT1.R19 26.23,38.91 v7(26.23,38.91) UT1.N20 ; v7(28.18,32.41) UT1.W5 ; v7(28.18,32.41) UT1.W6 28.83,33.07 29.32,33.07 29.81,32.58 UT1.AB6 UT1.AC6 ; v7(23.63,36.31) UT1.H15 UT1.H16 23.14,37.13 22.82,37.13 UT1.F16 22.65,37.3 v7(22.33,37.63) ; v7(23.63,36.31) UT1.H13 v7(23.63,35.66) ; v7(23.63,36.31) UT1.J13 ; UT1.H1 v10(23.41,30.74) ; v10(23.41,30.74) 23.41,30.75 23.09,31.07 22.37,31.07 UT1.E4 ; v10(22.65,39.24) 22.65,39.29 v10(22.33,39.61) 22.03,39.91 UT1.E22 UT1.E23 22.03,40.49 21.88,40.65 21.88,41.31 v7(21.52,41.66) ; v10(118.7,111.15) v10(118.7,110.66) v10(118.7,110.16) ; UT1.E15 v7(21.68,36.96) ; v7(21.68,36.96) UT1.D16 ; v7(21.68,36.96) UT1.D15 ; 26.71,31.1 26.73,31.1 v10(27.09,30.74) UT1.T1 ; 26.71,31.1 26.88,31.27 26.88,31.76 v10(26.55,32.09) ; 26.71,31.1 26.43,31.1 26.17,30.85 v10(26.17,30.74) ; v10(123.85,109.18) v1(123.85,109.67) ; UT1.D16 21.35,37.31 v10(21.03,37.63) ; UT1.D16 21.24,37.18 UT1.B16 UT1.A16 19.86,37.18 19.48,36.8 v7(19.28,36.8) ; UT1.AB1 v2(29.85,30.74) ; v10(29.15,39.24) 29.15,39.24 v7(28.83,38.91) 28.83,38.27 UT1.W18 ; v7(28.18,38.92) 28.5,39.24 v10(28.5,39.24) ; v7(28.18,38.92) 27.85,39.24 v10(27.85,39.24) 27.55,39.54 UT1.U22 UT1.U23 27.55,40.84 v7(27.64,40.93) ; v7(28.18,38.92) 28.18,38.91 v7(28.18,38.26) ; v7(26.88,37.61) UT1.T16 27.53,36.96 ; UT1.B22 21,39.6 21,39.36 v10(20.65,39.02) ; UT1.B22 UT1.A22 20.02,39.94 19.28,40.67 v7(19.06,40.67) ; UT1.AC10 UT1.AB10 29.53,34.42 v10(29.15,34.04) 29.31,34.04 UT1.AB8 UT1.AC8 ; v10(25.25,30.74) UT1.M1 v7(25.25,29.69) ; v10(25.25,30.74) 25.25,30.87 25.48,31.1 25.81,31.1 v10(26.17,30.74) ; UT1.E16 22,37.3 v7(22.33,37.63) ; 29.85,38.1 UT1.AB18 UT1.AC18 ; 29.85,38.1 29.83,38.1 29.39,37.66 29.39,37.62 ; UC1.AY38 UC1.BB38 v10(124.5,110.16) v10(124.5,110.66) v10(124.5,111.15) v10(124.5,111.64) UC1.BM38 UC1.BP38 ; v10(26.55,32.09) 26.22,32.42 26.22,33.06 25.9,33.38 UT1.N8 v7(26.23,33.71) UT1.N9 25.8,34.14 25.8,34.59 UT1.N11 v7(25.58,35.01) ; v10(127.4,111.4) UC1.BL29 UC1.BN29 127.45,112.38 UC1.BP28 ; v7(25.58,35.01) UT1.N12 UT1.N13 ; v7(25.58,35.01) UT1.M12 ; v7(25.58,35.01) UT1.M11 ; 21,38.9 20.78,38.9 v10(20.65,39.02) ; UT1.N13 25.98,35.99 26.3,35.67 26.88,35.67 UT1.T13 v7(27.53,36.31) UT1.T15 27.53,36.96 ; UT1.N13 v7(25.58,36.31) UT1.N15 ; UT1.N13 UT1.M12 ; v10(127.4,109.92) v10(127.4,110.41) v10(127.4,110.9) ; UT1.V16 UT1.W18 ; UT1.V16 27.53,36.96 ; v7(28.18,38.26) UT1.W18 ; UT1.W18 28.83,37.62 29.39,37.62 ; v1(122.56,109.18) v1(122.56,109.67) ; UT1.L22 UT1.L23 ; v10(119.04,108.33) v10(118.55,108.33) v10(118.05,108.33) v10(117.56,108.33) UC1.AU63 ; v10(119.04,108.33) 119.04,108.26 v10(119.29,108.01) 119.53,108.26 v10(119.53,108.33) 119.53,108.41 v10(119.29,108.65) 119.04,108.41 v10(119.04,108.33) ; v7(26.18,29.73) 26.18,30.28 UT1.P1 v10(26.17,30.74) ; v7(21.68,34.36) UT1.D9 UT1.D8 ; v7(21.68,34.36) UT1.E9 ; 29.59,36.26 UT1.AB14 UT1.AC14 ; 29.59,36.26 29.32,35.99 UT1.Y13 ; UT1.V15 27.53,36.96 ; v7(21.68,33.06) UT1.E8 UT1.E9 ; v7(21.68,33.06) UT1.D8 ; v7(21.68,33.06) UT1.D6 21.28,32.82 v10(20.99,32.82) 20.75,32.58 UT1.B6 UT1.A6 ; UT1.H12 v7(23.63,35.66) ; v7(23.63,35.66) UT1.J13 ; v10(127.07,109.67) v1(127.07,109.18) ; UT1.D8 21.24,33.5 20.69,33.5 ; v1(128.68,108.93) 128.61,108.93 v1(128.36,109.18) v1(128.36,109.67) ; v1(128.68,108.93) 128.76,108.93 v10(129.01,109.18) v10(129.01,109.67) ; v1(128.68,108.93) 128.93,108.69 v1(129.01,108.69) ; v10(132.23,100.55) v10(132.23,100.06) 132.15,100.06 v10(131.9,99.81) 132.15,99.57 UC1.J14 ; UT1.J18 23.97,37.94 v7(24.29,38.26) 23.96,38.59 UT1.J19 24.08,38.71 24.08,39.12 UT1.J20 ; UT1.B8 UT1.A8 19.9,33.5 19.18,32.79 v7(19.18,32.74) ; v10(25.25,39.24) 25.04,39.02 v10(24.95,39.02) 24.95,38.89 UT1.M19 ; UT1.Y13 29.8,35.34 UT1.AB12 UT1.AC12 ; UT1.E4 21.91,31.44 v10(21.68,31.21) ; UT1.E4 v10(22,32.09) ; UT1.R23 UT1.R22 ; v10(28.85,39.55) 28.47,39.93 UT1.W22 UT1.W23 ; v10(117.23,98.43) v10(117.23,98.86) ; UT1.J20 UT1.L20 ; UC1.BM20 UC1.BK20 v10(130.29,111.15) v10(130.29,110.66) v10(130.29,110.16) v10(130.29,109.67) ; v10(125.78,109.67) v10(125.78,109.18) ; v10(123.21,109.67) v1(123.21,109.18) ; UC1.AY46 v10(121.92,109.67) ; UT1.N22 UT1.N23
  TOP w0.203: QT21.1 128,83.82 128,83.54 v10(127.84,83.38) ; v10(134.13,98.43) UC1.D8 133.29,98.43 v10(133.19,98.34) ; v10(130.62,108.93) 130.37,108.69 v10(130.29,108.69) UC1.AW21 ; v10(119.7,86.93) JPOGO.61 ; v10(57.97,94.59) 57.96,94.59 57.82,94.45 57.82,93.87 U23.2 ; U20.18 v10(225.68,113.39) ; v10(28.5,39.24) v10(28.85,39.55) v10(29.15,39.24) ; v10(28.5,39.24) v10(28.11,39.55) ; v10(28.5,39.24) v7(28.83,38.91) ; v10(27.2,39.24) v10(27.53,38.92) v10(27.85,39.24) v10(28.11,39.55) ; v10(27.2,39.24) 26.89,38.92 ; v10(27.2,39.24) v10(26.86,39.54) ; v10(27.2,39.24) 27.55,39.54 ; 26.89,38.92 UT1.R19 ; 26.89,38.92 v10(26.55,39.24) ; v10(110.13,113.95) U3.B4 U3.C4 v10(109.63,114.95) ; v10(119.29,106.72) 119.53,106.48 v10(119.53,106.4) 119.53,106.32 v10(119.29,106.08) ; v10(111.14,113.95) U3.A2 ; UC1.J14 UC1.G14 ; JPOGO.58 v10(118.9,82.25) ; v10(196.4,124.9) 196.38,124.92 U37.11 ; DA1.2 23.09,12.58 23.93,13.42 v7(23.93,13.44) ; v10(28.11,39.55) UT1.W22 ; U40.11 v10(152.81,94.57) ; 145.11,134.1 JP1.14 145.11,133.53 v10(145.21,133.43) ; v10(120.1,86.93) 120.1,86.92 JPOGO.63 ; v10(121.28,111.15) 121.35,111.15 v10(121.6,111.4) UC1.BL47 ; JPOGO.7 v10(108.9,87.02) ; 125.24,136.74 v10(125.24,137.35) ; UC1.J3 UC1.J5 v10(133.91,99.64) UC1.J9 ; U21.6 v10(70.5,149.16) ; v10(26.86,39.54) UT1.R22 ; v10(26.86,39.54) v10(26.55,39.24) ; JPOGO.20 111.3,82.52 111.12,82.34 v10(111.12,82.28) ; v10(26.55,39.24) v7(26.23,38.91) ; v10(26.55,39.24) v10(26.21,39.53) UT1.N20 ; v10(117.99,86.98) 118.1,86.87 JPOGO.53 ; JPOGO.56 v10(118.5,82.24) ; U21.19 70.1,144.64 v7(70.44,144.31) 70.5,144.37 U21.20 ; JPOGO.74 v10(122.1,82.25) ; v10(118.9,86.93) JPOGO.57 ; 134.9,109.3 135.42,109.3 v10(135.42,109.3) ; 134.9,109.3 UC1.BA3 ; 134.9,109.3 134.41,109.3 UC1.BA5 v10(133.91,109.3) ; JPOGO.26 112.5,82.28 v10(112.53,82.25) 112.59,82.25 112.9,82.56 JPOGO.28 ; UC1.BP46 v10(121.92,113.06) ; v1(126.43,109.18) v1(126.43,109.67) ; JPOGO.32 113.7,82.33 v10(113.76,82.27) ; v10(200.86,123.06) 200.94,122.97 UA2.15 ; v10(122.17,86.92) 122.17,86.79 122.1,86.72 JPOGO.73 ; v10(118.5,86.93) JPOGO.55 ; v10(132.44,104.79) 132.08,104.79 UC1.AF15 ; JPOGO.54 v10(118.1,82.24) ; UT1.D12 21.35,35.31 ; UT1.D12 21.02,35 v10(21.02,34.95) ; UT1.D12 v10(21.02,35.76) UT1.D13 ; UA2.47 208.05,123.37 208.32,123.64 v10(208.32,123.68) ; U20.20 v10(224.82,113.39) ; v10(119.3,86.93) JPOGO.59 ; U23.11 v10(54.23,94.65) ; UA2.16 200.66,122.57 v7(200.54,122.69) ; v10(20.99,36.6) UT1.D15 v7(21.68,36.32) ; UC1.AD13 132.3,104.15 v10(131.95,103.8) 132.25,103.51 UC1.AB13 ; v10(120.9,86.92) JPOGO.67 ; UC1.BP36 125.07,112.73 124.57,112.73 UC1.BP38 ; JPOGO.68 v10(120.9,82.25) ; UT1.N20 v10(25.59,38.95) ; UT1.N20 UT1.N22 v10(25.48,39.53) v10(25.25,39.24) ; UC1.R2 UC1.R4 v10(134.16,101.25) v10(133.67,101.25) v10(133.17,101.25) ; U34.11 v10(191.62,102.9) ; UT1.B8 20.69,33.5 ; v1(120.63,109.67) v1(120.63,109.18) ; U3.A4 v10(110.13,113.45) ; UT1.B6 21.05,32.36 UT1.D5 ; v10(25.59,38.95) UT1.M19 ; v10(25.59,38.95) v10(25.25,39.24) ; QT21.4 127.29,83.14 127.1,83.33 v10(127.1,83.44) ; v10(27.17,65.71) U36.11 ; v10(24.94,39.53) v10(25.25,39.24) ; v10(24.94,39.53) UT1.L20 ; v10(24.94,39.53) UT1.L22 ; UT1.D8 v10(21.02,33.18) v10(20.99,32.82) ; v10(237.45,135.37) 237.44,135.36 U30.11 ; v10(146.31,133.5) JP1.20 146.31,134.1 ; v10(137.52,105.23) 137.37,105.23 137.14,105 137.14,104.78 136.73,104.38 135.74,104.38 135.65,104.47 UC1.AE2 UC1.AE4 ; U41.11 v10(140.53,124.75) ; v10(110.22,81.85) 110.1,81.96 JPOGO.14 ; v10(132.55,110.41) v10(132.55,110.9) ; JPOGO.60 v10(119.3,82.26) ; U21.18 v7(69.7,144.31) ; UC1.AR2 UC1.AR4 v10(134.16,107.69) v10(133.67,107.69) v10(133.17,107.69) v10(132.68,107.69) 131.98,107.69 UC1.AR15 ; U20.16 v10(229.32,108.3) ; v10(34.27,91.85) U32.11 ; PC205.1 79.1,129.21 78.23,128.33 PC219.2 ; Q342.4 215.42,138.91 v10(215.42,139.3) ; JPOGO.62 v10(119.7,82.25) ; U20.17 v10(229.32,108.73) ; U33.11 U33.15 ; U20.14 229.18,107.44 v10(229.32,107.58) ; UA2.38 208.07,119.77 v2(208.25,119.59) ; v10(229.32,107.92) 229.22,107.92 229.17,107.87 U20.15 ; v10(50.98,95.21) 50.98,94.55 51.03,94.5 U23.19 ; v10(122.56,113.05) UC1.BP44 ; Q342.1 216.62,138.11 v10(216.68,138.06) ; v10(133.67,110.91) UC1.BG6 UC1.BG4 v10(135.15,110.91) ; v10(123.3,86.92) JPOGO.79 ; v10(24.95,39.02) UT1.L20 ; UT1.L20 v10(24.31,39.54) ; JPOGO.19 111.3,87.16 v10(111.3,87.17) ; JPOGO.8 v10(108.9,82.15) ; UA2.20 v7(200.74,120.97) ; v10(21.03,37.63) UT1.D18 ; v1(125.14,109.18) v10(125.14,109.67) ; v10(133.67,104.47) v10(133.17,104.47) ; U20.19 v10(225.25,113.39) ; UT1.D9 v10(21.01,33.9) ; UC1.Y1 UC1.Y3 UC1.Y5 v10(133.91,102.86) v10(133.42,102.86) v10(132.93,102.86) 132.44,102.86 v10(132.44,102.86) ; v1(131.95,106.04) 132,106.08 v10(132.44,106.08) 132.44,106.08 UC1.AK11 UC1.AK9 v10(133.91,106.08) UC1.AK5 UC1.AK3 UC1.AK1 ; U23.52 v10(59.67,89.98) ; JPOGO.13 v10(110.1,87.09) ; QT20.4 129.21,80.42 129.06,80.56 v10(129.06,80.89) 128.84,81.12 QT20.1
  TOP w0.229: v10(123.04,101.01) UC1.R44 v10(122.05,101.01) v1(121.55,101.01) v1(121.06,101.01) UC1.R50 ; v1(120.07,106.59) v1(120.56,106.59) ; v1(120.07,102.12) v1(120.56,102.12) ; v10(246.06,138.22) 246.05,138.22 Q341.4 ; v1(128.98,101.57) v1(128.98,101.01) 129,100.99 129,100.74 v1(129.01,100.55) 128.99,100.56 ; v1(120.07,103.24) v10(120.56,103.24) ; v1(120.07,107.71) v10(120.56,107.71) ; v1(120.07,104.36) v1(120.56,104.36) ; Q341.1 v10(246.75,138.2) ; v1(131.46,103.8) v10(131.95,103.8) ; v1(120.07,105.48) v1(120.56,105.48) ; UC1.AF16 UC1.AF15 ; v10(127.99,107.71) v10(127.99,108.27) ; UC1.T36 v10(125.02,101.01) ; v1(124.03,101.57) v10(124.03,101.01) ; v1(126.01,101.57) v10(126.01,101.01)
  TOP w0.254: CR15.2 22.55,83.66 v10(22.42,83.79) ; v7(195.7,129.6) 195.7,129.01 C252.2 ; v10(169.19,124) v10(169.19,123.6) ; PU901.9 84.29,116.57 PU901.6 ; UC1.BP52 119.99,113.07 v10(119.88,113.18) ; U4.F13 v10(128.74,125.42) U4.E12 ; UC1.AV16 131.51,108.69 131.51,108.69 UC1.AW17 131.26,108.94 131.5,109.18 v10(131.58,109.18) ; v10(127.39,112.92) 127.34,112.92 UC1.BP30 ; v10(165.99,122) v10(165.59,122) v10(165.59,121.6) v10(165.59,121.2) v10(165.99,121.2) v10(165.99,121.6) ; U4.E12 U4.D12 ; U4.E12 v10(128.24,124.92) ; C235.2 193.66,102.5 v10(193.17,102.98) ; RC152.1 114.51,92.87 v10(114.43,92.79) ; UC1.BP54 119.34,112.88 v10(119.06,113.16) ; v10(126.24,125.42) 125.53,125.42 125.33,125.62 125.33,126.07 125.68,126.42 U4.A14 ; UC1.BP22 129.65,112.78 v10(129.91,113.04) ; D417.2 v10(15.64,14.61) ; UC1.BP60 117.71,112.81 v10(117.35,113.17) 117.25,113.07 UC1.BP62 ; v10(139.08,117.87) 138.79,117.58 138.79,117.08 139.12,116.75 139.83,116.75 CH5.1 ; PU500.C13 PU500.C14 PU500.B14 PU500.B13 v10(169.99,126) v10(169.99,126.4) v10(170.39,126.4) v10(170.79,126.4) ; C283.2 v10(94.57,127.54) ; D423.1 191.66,96.12 v10(191.61,96.07) ; U4.A2 v10(126.24,120.92) ; PC205.1 79.1,129.73 v10(79.08,129.75) ; v10(141.01,88.22) 140.77,87.98 U710.5 ; v10(116.41,106.72) 116.41,106.72 UC1.AM64 ; v10(165.51,117.1) 165.08,116.67 PC644.2 ; v10(168.84,107.04) 169.2,107.4 PU300.4 ; RH178.2 155.35,99.6 v10(154.92,100.03) ; CH7.2 139.01,120.63 C27.2 v10(137.98,121.53) ; v10(242.93,130.95) 242.6,131.28 U715.2 ; R5.2 127.32,116.96 v10(127.03,117.26) ; v10(116.15,107.37) UC1.AP64 ; v10(192.82,106.26) 192.62,106.26 192.22,106.66 C237.2 C236.2 ; MC1.1 145.35,119.12 v10(144.93,119.54) ; PC630.2 161.42,131.58 161.79,131.58 v10(162.09,131.28) ; JLVDS1.2 192.15,94.51 192,94.65 v10(192,94.83) ; v10(118.33,89.56) 118.6,89.56 118.8,89.36 118.8,88.66 CC161.1 ; v10(197.63,136.37) U15.32 ; C240.2 189.93,100.53 v10(189.63,100.22) ; v10(139.77,122.06) 139.77,122.16 139.29,122.65 CH50.2 ; RC45.2 113.48,109.04 v10(113.6,109.15) ; CA138.2 199.33,121.42 199.27,121.42 CA104.2 ; v10(193.07,144.36) 193.33,144.1 U16.H7 ; DI5.1 189.27,96.2 v10(189,96.48) ; RC151.2 118.34,93.05 v10(118.64,92.76) ; U15.23 202.67,134.37 v7(202.71,134.4) ; PC300.2 167.98,104.02 v10(168.36,104.4) ; v10(94.6,128.6) 94.76,128.43 C280.2 ; v10(138.07,101.89) CC34.2 ; v10(111.14,114.45) U3.C2 ; v10(65.77,121.22) 65.79,121.24 PC217.2 ; UC1.Y15 v1(131.46,102.68) ; D424.2 v10(16.44,37.92) ; C210.2 v2(195.56,132.8) ; PC134.2 29.32,69.52 v10(29.29,69.49) ; PU300.6 167.72,106.9 v10(167.82,106.99) ; v10(176.36,108.92) 176.6,109.16 PR704.1 ; PC549.2 174.77,119.02 174.25,118.5 v10(174.25,117.93) ; U3.H5 v10(109.13,117.45) ; v10(80.78,138.03) 81.04,137.77 U24.2 ; v7(38.31,23.33) 38.3,23.31 CA12.2 ; C49.2 184.52,101.13 184.66,100.99 v10(184.66,100.43) ; PU801.9 84.94,105.44 PU801.6 ; C249.2 154.08,96.45 v10(154.77,96.45) ; v10(107.63,115.45) U3.E7 U3.E6 U3.E5 v10(109.13,115.95) ; U4.U13 v10(134.25,125.42) ; U15.9 197.63,130.23 197.91,129.95 v7(197.91,129.64) ; U721.5 v10(91.15,99.03) ; JUSBC1.B1 7.51,27.77 8.13,27.77 8.15,27.76 JUSBC1.A12 ; JLVDS1.27 v10(179.65,95.15) ; C232.1 197.08,128.9 v7(197.08,129.56) ; PC715.2 176.09,117.07 v10(175.7,117.46) ; RH46.2 146.7,110.31 v10(147.05,109.96) ; C1388.2 v10(93.73,98.64) ; v7(8.66,55.06) 9.09,55.06 U717.A1 ; D418.1 v10(14.93,14.61) ; QR1.3 30.91,73.58 v10(30.54,73.21) ; U719.A1 v7(22.27,54.48) ; v10(233.31,124.87) U27.F4 ; v10(112.43,90.46) RC24.2 ; C200.2 196.15,107.06 196.16,107.07 196.16,107.84 v10(196.19,107.87)
  TOP w0.305: v10(32.52,96.39) 32.63,96.27 C222.2 R238.1 ; CA108.2 210.5,122.88 v10(210.74,123.12) ; v10(38.31,105.63) C71.2 ; v10(186.26,107.02) v10(186.95,106.33) 187.31,105.98 C1223.2 187.76,105.74 C233.2 ; RH1.1 139.72,94.01 v10(139.72,94.52) ; C1271.1 v10(33.69,38.67) ; CA114.2 199.59,125.73 CA113.2 ; v7(65.26,128) 65.6,127.66 PC228.2 ; v10(120.1,116.57) 119.87,116.57 119.54,116.24 119.54,115.58 119.49,115.53 CC82.1 CC87.1 ; R13.2 104.44,109.66 104.04,109.66 v10(103.97,109.74) 103.87,109.63 R3.2 ; JDEG1.10 v10(207.23,145.12) ; CC77.1 125.74,115.51 126.03,115.81 v10(126.17,115.81) ; JUSBC2.B1 7.53,13.79 8.17,13.79 8.2,13.76 JUSBC2.A12 ; U712.3 194.66,105.07 v10(194.47,105.25) 194.16,105.56 C238.2 ; v10(138.61,109.57) 138.44,109.75 CC164.2 ; DA8.2 23.09,9.74 23.58,9.25 v7(23.83,9.25) ; R389.1 101.43,89.52 101.81,89.9 102.17,89.9 C241.2 ; PU208.2 v10(67.93,121.05) ; v10(124.73,95.41) RC23.2 ; RC14.2 137.39,115.88 137.83,115.88 v10(138.03,115.68) ; v10(113.52,116.98) 113.58,116.91 R2.2 ; CR2.2 27.9,84.03 28.23,83.7 CR3.2 ; C253.1 35.69,87.54 v10(35.77,87.61) 35.92,87.77 C248.2 ; v10(127.67,115.96) 127.67,115.88 127.87,115.68 CC74.1 ; RR6.1 30.11,84.6 v10(29.94,84.44) ; v10(120.1,116.16) 120.17,116.16 120.38,115.96 CC88.1 ; C1227.2 157.39,95.03 157.66,95.3 C1233.2 ; DA3.2 20.63,9.94 v7(20.66,9.96) ; v10(31.97,27.95) R1403.2 ; CC84.1 129,115.51 128.69,115.82 v10(128.69,115.83) ; CC81.1 CC80.1 124.44,115.81 v10(124.57,115.93) ; v10(105.9,111.79) 105.9,110.55 C24.2 ; R203.1 v10(59.16,96.99) ; v10(23.92,21.39) CA44.2 ; C250.2 33.42,88.49 33.89,88.96 v10(33.89,89.95)
  TOP w0.33: v10(142.31,86.97) 141.96,86.61 C1236.2 ; C1242.2 v10(105.11,82.43)
  TOP w0.356: v1(126.01,103.8) v10(126.01,103.24) v1(126.01,102.68) v10(126.01,102.12) v1(126.01,101.57) ; UC1.AL44 v10(123.04,106.59) ; v1(124.03,101.57) v10(124.03,102.12) v1(124.03,102.68) v10(124.03,103.24) v1(124.03,103.8) ; v1(130.96,107.15) v1(130.96,107.71) ; v10(127.99,105.48) v1(127.99,106.04) v10(127.99,106.59) v1(127.99,107.15) v10(127.99,107.71) ; v10(124.03,107.71) v1(124.03,107.15) v10(124.03,106.59) v1(124.03,106.04) v10(124.03,105.48) v1(124.03,104.92) ; v10(126.01,107.71) v1(126.01,107.15) v10(126.01,106.59) v1(126.01,106.04) v10(126.01,105.48) v1(126.01,104.92) ; v10(92.77,95.74) 92.26,95.23 PU202.2 ; v10(127.99,103.8) v10(127.99,103.24) v1(127.99,102.68) v10(127.99,102.12) ; UC1.AE44 v10(123.04,104.36) ; PR252.2 v10(89.66,94.78) ; UC1.AF16 v10(131.46,104.92) v10(131.46,105.48) v10(131.46,106.04) v1(131.46,106.59) v10(131.46,107.15) ; MD6.3 142.23,88.33 v10(141.79,88.77) ; UC1.AC36 v10(125.02,103.24) UC1.Y36 v10(125.02,102.12) UC1.T36 ; v10(129.97,101.57) v10(129.48,101.57) v1(128.98,101.57) v1(128.98,102.12) v1(128.98,102.68) v1(128.98,103.24) ; v10(130.47,103.8) v10(129.97,103.8) v1(129.97,104.36) v1(129.97,104.92) v10(129.48,104.92) v10(129.48,105.48) v10(128.98,105.48) v1(128.98,106.04) v10(128.98,106.59) v1(128.98,107.15) ; v10(10.2,25.6) 10.2,26.12 C1362.1 ; UC1.AF36 v10(125.02,105.48) UC1.AK36 v10(125.02,106.59) UC1.AN36 v10(125.02,107.71) ; UC1.AH44 v10(123.04,105.48) ; v10(129.97,106.59) v1(129.97,107.15) v1(130.47,107.15) ; UC1.AA44 v10(123.04,103.24) ; UC1.V44 v10(123.04,102.12) ; UC1.AR44 v10(123.04,107.71)
  TOP w0.381: PR745.2 184.51,138.06 v7(183.93,138.64) ; C69.2 v7(248.08,130.7) ; U713.4 87.21,126.31 v10(87.2,126.3) ; v10(198.62,147.15) 198.29,146.82 C1411.1 ; UC1.AL44 v10(122.05,106.59) v1(121.55,106.59) UC1.AL49 v1(120.56,106.59) ; DA4.2 21.18,9.63 v7(20.81,9.25) ; v10(114.64,116.04) 114.99,115.68 C3.2 ; C1390.2 v10(94.3,102.5) ; v10(99.75,128.94) 99.76,128.93 C129.2 ; v10(122.66,120.94) 122.71,120.89 C28.2 ; v10(105.2,88.65) 105.2,88.63 104.62,88.05 MD4.3 ; UC1.AE44 v10(122.05,104.36) v1(121.55,104.36) UC1.AE49 v1(120.56,104.36) ; C246.2 v7(22.51,64.8) 22.65,64.94 R232.1 ; C256.2 139.01,130.08 v10(139.16,130.23) ; UC1.V44 v10(122.05,102.12) v1(121.55,102.12) UC1.V49 v1(120.56,102.12) ; C1417.1 189.75,147.01 C1418.1 189.53,147.02 189.14,147.41 v10(189.14,147.61) ; v10(141.56,101.28) 141.56,101.29 141.28,101.57 RC91.2 ; C53.2 v10(243.47,130.04) ; UC1.AR44 v10(122.05,107.71) v1(121.55,107.71) UC1.AR49 v10(120.56,107.71) ; UC1.AA44 v10(122.05,103.24) v1(121.55,103.24) UC1.AA49 v10(120.56,103.24) ; CC21.2 145.83,96.69 CC163.2 ; C32.2 121.13,126.3 120.78,126.64 v10(120.78,127.15) ; C219.2 232.61,137.47 v10(232.44,137.64) ; v1(131.46,103.8) v10(130.96,103.8) v10(130.47,103.8) ; R1056.2 v7(225.7,120.73) ; R1076.2 86.1,128.54 v10(85.87,128.77) ; v10(131.46,107.15) v1(130.96,107.15) v1(130.47,107.15) ; v1(120.56,105.48) UC1.AH49 v1(121.55,105.48) v10(122.05,105.48) UC1.AH44 ; C1398.2 102,129.03 v10(102.52,129.03) ; CR5.2 v10(27.15,84.97) ; R1408.2 v10(27.45,26.73) ; C1415.1 v10(189.95,142.55)
  TOP w0.406: v10(40.03,94.55) 40.42,94.16 PQ120.4 ; v10(42.25,96.17) 41.99,96.17 41.72,95.9 PQ120.1
  TOP w0.457: v10(76.47,122.99) 76.62,123.15 PQ214.1 ; C67.2 v7(243.62,108.16)
  TOP w0.508: C225.2 v10(196.45,123.27) ; v10(110.22,110.22) 110.45,110.45 CC61.2 ; PC133.2 31.53,67.29 PU102.2 ; 33.29,72.47 33,72.47 v10(32.54,72.02) ; PC619.2 v10(158.87,125.67) ; C15.2 v10(99.45,112.15) ; PC1173.2 v7(92.77,114.16) ; v10(114.33,122.66) 114.15,122.49 C12.2 ; C81.2 v10(23.78,68.75) ; C65.2 244.58,110.03 v7(245.1,110.55) ; C1421.2 v10(114.66,88.39) ; PC406.2 53.61,121.14 v7(53.61,121.86) ; U18.4 206.71,129.93 206.55,129.76 206.55,129.51 v10(206.67,129.38) ; v10(195.51,145.58) 195.51,146.5 C98.2 ; v10(41.27,139.61) 41.29,139.59 PC103.2 ; C68.2 v7(249.26,132.61) ; v10(114.81,114.64) 114.71,114.54 C20.2 ; PC107.2 v7(78.59,88.81) ; v10(27.72,85) 27.72,84.84 27.9,84.67 CR2.2 ; PC1003.2 v7(86.44,102.14) ; DI6.1 20.45,55.74 v7(20.89,56.17) ; PC1245.2 77.02,110.98 77.37,110.98 v7(77.69,110.66) ; JCR1.15 v7(4.53,85.58) ; C23.2 102.11,110.73 v10(102.5,111.11) ; C104.2 v10(199.33,147.14) ; v10(122.61,122.59) 122.66,122.59 122.99,122.92 C29.2 123.3,123.05 R11.2 ; CR6.2 26.38,85.05 v10(26.44,85.1) ; v10(99.5,114.1) 99.55,114.05 C17.2 ; C257.2 v10(143.76,125.27) ; C288.2 15.83,48.08 v10(15.83,47.6) ; v7(73.72,149.31) 73.65,149.38 D95.2 ; PC231.2 72.26,126.78 v10(72.18,126.86) ; v7(87.78,114.97) 87.78,114.94 88.51,114.21 PC806.2 ; JAPS2.19 226.87,145.24 v7(226.73,145.09) ; PC400.2 55.73,121.87 v7(54.78,121.87) ; CA104.2 198.08,120.81 v7(198.05,120.79) ; v7(244.04,144.08) 243.67,143.71 JRTC1.3 ; C227.2 C239.2 v10(101.43,82.4) ; PC900.2 86.32,115.68 v7(86.34,115.65) ; DI7.1 v10(38.56,40.01) ; PC537.2 167.05,136.69 PC530.2 ; v7(93.71,114.16) 93.71,113.77 PC912.2 ; v7(109.02,126.27) 109.02,124.87 C33.2 ; PC648.2 156.93,110.13 v10(156.93,109.66) ; C5.2 128.94,116.7 v10(129.24,116.39) ; RH145.1 v10(159.32,99.6) ; CC117.2 117.85,117.71 CC118.2 v10(118.22,118.63) ; v10(122.59,118.45) 122.92,118.12 C16.2 123.48,117.81 C34.2 ; CA109.2 v7(213.91,121.57) ; v10(19.46,47.15) 19.46,46.95 19.46,46.94 19.46,46.74 19.77,46.44 C1351.2 ; CA113.2 v10(199.17,126.8) ; C19.2 113.67,120 v10(113.62,119.95) ; v10(125.03,117.18) 125.46,116.75 C21.2 ; v10(160.67,131.07) 160.07,130.46 PC716.2 ; v10(173.44,136.89) 173.97,136.36 PC610.2 ; v10(134.37,117.89) 134.14,117.66 C13.2 ; PR258.2 PC203.2 95.3,97.14 v10(95.38,97.05) ; v7(50.78,121.12) 50.79,121.13 PC403.2 ; v10(99.89,81.69) 100.12,81.47 C1420.2 C1422.2 101.99,81.47 v10(102.22,81.69) ; v7(213.88,120.32) 213.29,120.32 CA106.2 ; JCR1.11 v1(15.17,78.52) ; CH49.2 v10(145.66,125.29) ; v7(188,148.65) 188.16,148.5 C110.2 ; v10(165.72,114.56) 165.74,114.56 166.35,113.95 PC614.2 ; PC603.2 PC649.2 ; v10(136.89,125.76) 137.14,125.51 C31.2 ; C36.2 v10(57.51,97.16) ; v2(5.91,49.89) 5.91,50.15 6.37,50.6 C1338.2 ; v10(45.98,136.33) 46.11,136.2 PC120.2 ; C14.2 v10(138.16,125.2) ; C126.2 82.77,129.13 v10(82.32,128.67) ; PC218.2 69.17,120 v10(69.17,120.16) ; v10(19.87,17.43) R33.2 ; C47.2 175.46,101.06 v10(175.88,100.64) ; JRTC1.2 v7(240.12,146.97) ; v7(25.44,6.36) DH5.2 ; v10(196.5,121.7) CA105.2 ; C2.2 v10(99.55,115.96) ; v10(109.84,128.74) 110.29,128.74 C153.2 ; PC604.2 v10(169.65,129.62) ; C70.2 v7(248.65,131.52) ; PC1177.2 100.29,102.94 v7(99.87,102.52) ; PC803.2 v7(87.2,103.21) ; JNGFF2.77 v10(205.81,105.39) ; JCR1.18 v7(4.62,88.31)
  IN1 w0.06: 170.88,120.59 170.87,120.61 170.41,120.61 170.26,120.76 170.06,120.76 v5(169.97,120.67) ; v1(194.57,143.3) 194.57,143.27 194.39,143.1 193.6,143.1 193.44,142.93 v5(193.07,142.93)
  IN1 w0.076: v10(167.09,119.39) 167.02,119.32 167.02,117 166.87,116.85 166.87,116.15 v5(166.78,116.06)
  IN1 w0.102: v8(174.07,115.68) 174.07,115.96 173.77,116.26 173.77,118.25 172.07,119.95 171.62,119.95 170.97,120.59 170.88,120.59 ; v5(134.28,115.06) 135.79,115.06 137.24,116.51 137.24,118.3 ; 165.7,128.33 166.24,128.33 166.4,128.16 166.4,127.47 166.41,127.47 167.59,126.29 v10(167.59,126) ; 108.03,80.82 81.44,80.82 ; 51.41,87.1 50.36,88.15 46.95,88.15 46.77,88.32 46.77,88.66 47.87,89.76 47.87,91.08 46.95,92.01 46.17,92.01 45.75,91.59 45.75,88.35 46.56,87.54 49.99,87.54 50.85,86.68 51.11,86.43 55.98,86.43 56.35,86.06 60.31,86.06 v10(60.66,85.71) ; v10(167.09,119.39) 167.09,119.52 167.33,119.77 167.33,120.57 167.52,120.76 167.83,120.76 168.24,120.34 168.24,119.57 168.49,119.32 168.49,115.41 ; v10(119.29,106.08) v10(119.29,105.43) ; v5(35.67,76.18) 35.67,76.05 34.61,75 34.61,65.29 35.93,63.97 35.93,56.14 37.65,54.43 37.65,37.56 37.07,36.98 37.07,27.51 v5(36.96,27.39) ; v8(168.79,120.63) 168.88,120.54 168.88,120.33 169.7,119.51 170.64,119.51 171.54,118.61 172.4,118.61 172.44,118.64 ; 173.23,117.24 173.23,116.1 173.04,115.91 173.04,113.31 173.34,113.02 v10(173.34,112.99) ; v3(177.44,120.28) 177.44,120.56 177.33,120.67 175.63,120.67 174.8,121.5 174.8,122.55 173.39,123.95 172.8,123.95 172.47,124.28 171.72,124.28 171.46,124.02 171.14,124.02 v8(171.08,124.09) ; 60.56,84.11 60.41,84.11 58.91,85.61 58.73,85.61 ; v5(169.97,120.67) 169.96,120.66 169.96,120.31 170.2,120.07 170.87,120.07 171.76,119.18 171.94,119.18 172.19,118.93 v5(172.42,118.93) 172.44,118.95 ; 38.7,109.44 39,109.44 40.96,111.41 42.87,111.41 43.54,112.09 ; 99.93,129.79 v5(99.97,129.75) 100.23,129.49 101.2,129.49 101.69,129.98 101.69,130.72 v10(101.57,130.84) 101.48,130.84 101.08,130.43 100.14,130.43 99.93,130.22 99.93,129.79 ; 94.68,133.86 94.68,133.23 v7(94.44,132.99) 93.29,132.99 91.28,130.98 v10(91.28,130.7) 90.51,129.93 87.45,129.93 86.58,129.07 84.97,129.07 84.63,128.73 84.04,128.73 83.83,128.94 v5(83.83,129.04) 83.83,129.3 84.41,129.88 86.23,129.88 87.17,130.82 89.9,130.82 93.56,134.48 94.55,134.48 94.72,134.3 94.72,133.9 94.68,133.86
  IN1 w0.127: v10(127.72,109.18) v1(127.07,109.18) v1(126.43,109.18) v10(125.78,109.18) v1(125.14,109.18) v10(123.85,109.18) v1(123.21,109.18) v1(122.56,109.18) v10(121.28,109.18) 121.26,109.19 120.64,109.19 v1(120.63,109.18) v10(119.99,109.18) ; 90.56,90.65 90.56,91.45 93.46,94.34 93.46,97.76 93.73,98.04 v10(93.73,98.64) 93.73,99.21 96.19,101.67 96.19,105.25 96.96,106.02 96.96,111.46 97.45,111.94 97.45,119.61 99.36,121.52 99.36,124.31 101.42,126.37 103.62,126.37 103.74,126.25 ; v10(121.92,109.67) v1(122.56,109.67) 122.78,109.67 122.78,109.67 122.99,109.67 122.99,109.67 v10(123.21,109.67) v1(123.85,109.67) UC1.BB38 v10(125.14,109.67) v10(125.78,109.67) v1(126.43,109.67) v10(127.07,109.67) 127.15,109.67 v10(127.4,109.92) 127.47,109.92 v10(127.72,109.67) v1(128.36,109.67) v10(129.01,109.67) ; v10(119.99,109.67) v1(120.63,109.67) v10(121.28,109.67) 121.52,109.92 v10(121.6,109.92) ; v10(129.01,109.67) v10(129.65,109.67) v10(130.29,109.67) ; v10(129.01,109.67) v10(129.01,109.18) ; v10(119.29,108.01) 119.3,108 119.3,107.79 119.3,107.79 119.3,107.59 119.3,107.59 119.3,107.38 v10(119.29,107.37) 119.29,107.15 119.29,107.15 119.29,106.94 119.29,106.94 v10(119.29,106.72)
  IN1 w0.152: v10(129.01,109.18) 128.76,108.93 v1(128.68,108.93) ; v1(129.01,108.69) 128.93,108.69 v1(128.68,108.93) ; v10(127.72,109.18) v1(128.36,109.18) 128.44,109.18 v1(128.68,108.93) ; v10(119.99,109.67) 119.9,109.67 v1(119.67,109.43) 119.92,109.18 v10(119.99,109.18) ; v1(123.85,109.67) v10(123.85,109.18)
  IN1 w0.178: v10(119.34,109.67) 119.43,109.67 v1(119.67,109.43)
  IN1 w0.203: v10(130.62,108.93) 130.54,108.93 v10(130.29,108.69) ; v10(117.56,108.33) v10(118.05,108.33) v10(118.55,108.33) v10(119.04,108.33) ; 22.22,94.15 21,94.15 19.89,93.05 18.38,93.05 18.33,93.1 ; v10(119.04,108.33) 119.29,108.09 v10(119.29,108.01) ; v10(119.04,108.33) 119.04,108.41 v10(119.29,108.65) 119.53,108.41 v10(119.53,108.33) 119.63,108.33 v10(119.99,108.69) ; v10(119.29,106.08) 119.53,106.32 v10(119.53,106.4) 119.53,106.48 v10(119.29,106.72) ; 214.3,110.87 211.65,110.87 211.4,111.12 211.4,111.49 212.73,112.82 v10(212.73,113.17) 212.82,113.25 212.82,113.76 213.76,114.7 216.53,114.7 216.76,114.47 216.76,112.79 215.67,111.7 215.11,111.7 v5(215.01,111.61) 215.01,111.58 v10(214.76,111.33) 214.3,110.87
  IN1 w0.254: v1(124.03,103.8) v10(124.03,103.24) v1(124.03,102.68) v10(124.03,102.12) v1(124.03,101.57) v10(124.03,101.01) ; v5(120.79,101.01) 120.8,101.01 v1(121.06,101.01) ; v10(122.05,105.48) 121.79,105.48 v1(121.55,105.48) ; v1(119.04,103.18) v10(118.55,103.18) v10(118.05,103.18) v1(117.56,103.18) v10(117.07,103.18) ; v10(122.05,104.36) 121.79,104.36 v1(121.55,104.36) ; v1(124.03,104.92) v10(124.03,105.48) v1(124.03,106.04) v10(124.03,106.59) v1(124.03,107.15) v10(124.03,107.71) ; v1(120.07,107.71) v10(120.56,107.71) v8(120.91,107.71) ; v10(126.01,101.01) v1(126.01,101.57) v10(126.01,102.12) v1(126.01,102.68) v10(126.01,103.24) v1(126.01,103.8) ; v1(121.55,106.59) 121.79,106.6 v10(122.05,106.59) ; v1(120.07,106.59) v1(120.56,106.59) 120.94,106.59 120.93,106.58 v5(120.93,106.59) ; v1(120.07,102.12) v1(120.56,102.12) 120.57,102.12 120.94,102.12 v5(120.94,102.11) 121.54,102.11 v1(121.55,102.12) 121.56,102.13 121.79,102.13 121.8,102.12 v10(122.05,102.12) ; v1(120.07,105.48) v1(120.56,105.48) v8(120.95,105.48) ; v5(120.98,104.32) 120.94,104.36 v1(120.56,104.36) 120.56,104.36 v1(120.07,104.36) ; v1(126.01,104.92) v10(126.01,105.48) v1(126.01,106.04) v10(126.01,106.59) v1(126.01,107.15) v10(126.01,107.71) ; v1(131.95,106.04) 132.39,106.04 v10(132.44,106.08) ; v3(33.55,97.18) 33.77,97.18 v10(33.89,97.29) ; 130.96,101.11 v1(130.96,101.57) ; v10(120.56,103.24) v1(120.07,103.24) ; v10(116.8,101.57) v1(117.31,101.57) v10(117.81,101.57) v1(118.3,101.57) 118.79,101.57 v10(118.79,101.57) 119.04,101.32 v10(119.04,101.25) 119.29,101 v1(119.29,100.92)
  IN1 w0.305: 120.97,127.92 121.35,128.3 122.06,128.3 v10(122.7,128.94) 122.7,129.12 123.83,130.25 129.92,130.25 131.74,128.43 133.95,128.43 136.26,126.13 136.26,124.64 ; 114.74,124.35 108.07,124.35 106.1,122.39 105.11,122.39 104.58,121.85 103.94,121.85 103.63,121.54 v10(103.63,121.45) 103.39,121.45 103.13,121.19 v10(103.13,120.95) 103.07,120.95 101.91,119.79 101.91,118.83 100.9,117.82 100.9,117.04 99.98,116.13 99.98,110.3 102.73,107.56 104.3,107.56 106.03,105.83 111.45,105.83 112.83,104.45 v10(113.04,104.45) 113.3,104.45 113.44,104.59 113.82,104.59 113.82,104.58 113.83,104.59 114.73,104.59 114.74,104.58 114.74,104.59 116.59,104.59 v1(116.8,104.79) ; 114.74,124.37 116.71,122.4 119.91,122.4 120.37,122.86 120.37,123.77
  IN1 w0.381: v1(128.98,101.01) v1(128.98,101.57) v1(128.98,102.12) v1(128.98,102.68) v1(128.98,103.24) ; v1(131.46,102.68) 131.95,102.68 v10(131.95,102.68) ; v1(130.96,107.15) v10(131.46,107.15) v1(131.46,106.59) v10(131.46,106.04) ; v1(130.96,107.15) v1(130.47,107.15) v1(129.97,107.15) v10(129.97,106.59) ; v1(130.96,107.15) v1(130.96,107.71) ; v10(131.95,103.8) 131.95,103.8 v1(131.46,103.8) v10(130.96,103.8) 130.68,103.8 130.58,103.8 v10(130.47,103.8) v10(129.97,103.8) ; v10(127.99,103.8) v10(127.99,103.24) v1(127.99,102.68) v10(127.99,102.12) ; v1(130.96,101.01) 130.96,101.11 ; v10(131.46,104.92) v10(131.46,105.48) v10(131.46,106.04) ; v10(131.46,106.04) 131.95,106.04 v1(131.95,106.04) ; v10(127.99,108.27) v10(127.99,107.71) v1(127.99,107.15) v10(127.99,106.59) v1(127.99,106.04) v10(127.99,105.48)
  GND1 w0.06: v10(125.46,110.41) v10(126.11,110.41) v10(126.75,110.41)
  GND1 w0.076: 133.08,97.32 133.08,97.88 133.19,98 v10(133.19,98.34)
  GND1 w0.102: v10(169.19,121.2) 169.19,121.03 v8(168.79,120.63)
  GND1 w0.119: 166.25,128.46 166.25,128.43
  GND1 w0.127: 125.53,102.12 v4(125.63,102.12) v10(126.01,102.12) ; v10(126.01,105.48) v4(125.63,105.48) 125.53,105.48 ; v10(126.01,106.59) v4(125.63,106.59) 125.53,106.59 ; 125.53,101.01 v4(125.63,101.01) v10(126.01,101.01) ; 125.53,103.24 v4(125.63,103.24) v10(126.01,103.24) ; v4(124.66,101.01) v10(125.02,101.01)
  GND1 w0.203: 191.81,83.55 H2.1 ; H2.1 194.5,80.86 ; H2.1 197.19,83.55 ; H2.1 194.5,86.24 ; H2.1 196.44,81.61 ; H2.1 192.56,81.61 ; H2.1 192.56,85.49 ; H2.1 196.44,85.49 ; 13.1,0.86 H4.1 ; H4.1 11.16,1.61 ; H4.1 15.04,1.61 ; H4.1 10.41,3.55 ; H4.1 11.16,5.49 ; H4.1 15.79,3.55 ; H4.1 13.1,6.24 ; H4.1 15.04,5.49 ; 230.81,147.55 H6.1 ; H6.1 231.56,145.61 ; H6.1 235.44,145.61 ; H6.1 235.44,149.49 ; H6.1 231.56,149.49 ; H6.1 233.5,150.24 ; H6.1 233.5,144.86 ; H6.1 236.19,147.55 ; 7.4,92.33 JCR1.23 ; JCR1.23 7.4,93.71 ; JCR1.23 6.31,93.71 ; JCR1.23 8.49,93.02 ; JCR1.23 8.49,92.33 ; JCR1.23 6.31,92.33 ; JCR1.23 6.31,93.02 ; JCR1.23 8.49,93.71 ; JUSBC1.B1 7.8,28.06 ; JUSBC1.B1 7.45,28.15 ; JUSBC1.B1 7.1,27.35 ; JUSBC1.B1 7,27.71 ; H5.1 44.94,149.49 ; H5.1 41.06,145.61 ; H5.1 44.94,145.61 ; H5.1 43,144.86 ; H5.1 40.31,147.55 ; H5.1 41.06,149.49 ; H5.1 43,150.24 ; H5.1 45.69,147.55 ; 193.95,95.9 H10.1 ; H10.1 197.05,96.94 ; H10.1 195.5,94.86 ; H10.1 197.05,94.86 ; H10.1 197.05,95.9 ; H10.1 193.95,96.94 ; H10.1 193.95,94.86 ; H10.1 195.5,96.94 ; JUSBC1.B12 7.89,33.31 ; JUSBC1.B12 7.45,32.86 ; JUSBC1.B12 7.8,32.95 ; JUSBC1.B12 7.1,33.66 ; JUSBC1.B12 7,33.31 ; H7.1 7.5,110.74 ; H7.1 5.56,109.99 ; H7.1 4.81,108.05 ; H7.1 10.19,108.05 ; H7.1 9.44,106.11 ; H7.1 9.44,109.99 ; H7.1 7.5,105.36 ; H7.1 5.56,106.11 ; JCR1.22 7.4,79.31 ; JCR1.22 6.31,77.93 ; JCR1.22 6.31,79.31 ; JCR1.22 8.49,78.62 ; JCR1.22 8.49,79.31 ; JCR1.22 6.31,78.62 ; JCR1.22 8.49,77.93 ; JCR1.22 7.4,77.93 ; v4(128.98,107.12) v10(128.98,106.59) 128.98,106.59 128.98,106.24 129,106.22 v4(129,106.16) ; H11.1 3.77,95.13 ; H11.1 3,96.94 ; H11.1 1.96,95.9 ; H11.1 2.23,95.13 ; H11.1 4.04,95.9 ; H11.1 3,94.86 ; H11.1 3.77,96.67 ; H11.1 2.23,96.67 ; H9.1 104.84,102.88 ; H9.1 105.09,103.62 ; H9.1 103.36,104.36 ; H9.1 103.36,102.88 ; H9.1 103.11,103.62 ; H9.1 104.84,104.36 ; H9.1 104.1,104.61 ; H9.1 104.1,102.63 ; JNGFF3.18 249.65,112.22 ; JNGFF3.18 249.76,112.62 ; JNGFF3.18 249.65,113.03 ; v10(125.02,102.12) 124.58,102.12 v4(124.57,102.14) ; 142.11,104.62 H8.1 ; H8.1 143.1,103.63 ; H8.1 142.36,105.36 ; H8.1 143.84,103.88 ; H8.1 142.36,103.88 ; H8.1 144.09,104.62 ; H8.1 143.1,105.61 ; H8.1 143.84,105.36 ; 7.1,19.66 JUSBC2.B12 ; JUSBC2.B12 7,19.31 ; JUSBC2.B12 7.8,18.95 ; JUSBC2.B12 7.45,18.86 ; JUSBC2.B12 7.89,19.31 ; 7.1,13.35 JUSBC2.B1 ; JUSBC2.B1 7.8,14.06 ; JUSBC2.B1 7.45,14.15 ; JUSBC2.B1 7,13.71 ; v10(125.02,103.24) 124.79,103.24 v4(124.67,103.36) ; v4(124.54,105.39) 124.63,105.48 v10(125.02,105.48) ; v10(129.48,101.57) v10(129.97,101.57)
  GND1 w0.254: v4(127.64,107.6) 127.64,107.6 127.88,107.6 v10(127.99,107.71) ; v4(126.64,102.13) 126.64,102.12 v10(127,102.12) ; v4(126.67,103.21) 126.7,103.24 v10(127,103.24) ; v4(130.05,107.01) 130.05,106.67 v10(129.97,106.59) ; v4(127.64,106.7) 127.75,106.59 v10(127.99,106.59) ; v10(123.21,109.67) 123.21,109.62 v4(123.5,109.33) ; v4(127.65,105.6) 127.87,105.6 v10(127.99,105.48) ; v10(120.56,103.24) 119.83,103.24 119.82,103.23 ; v10(170.29,133.51) v4(171.22,133.51) ; v10(127,105.48) 126.64,105.48 v4(126.64,105.48) ; v4(123.5,109.33) 123.84,109.67 v1(123.85,109.67) ; v4(123.5,109.33) 123.5,109.31 123.63,109.18 v10(123.85,109.18) ; v4(128.02,102.48) 127.99,102.45 v10(127.99,102.12) ; v4(131.93,104.86) 131.52,104.86 v10(131.46,104.92) ; v10(127,104.36) 126.64,104.36 v4(126.64,104.36) ; v4(124.6,107.76) 124.65,107.71 v10(125.02,107.71) ; v4(123.56,103.24) 123.56,103.24 v10(123.04,103.24) v10(122.05,103.24) ; v10(127,107.71) 126.71,107.71 126.64,107.78 v4(126.64,107.82) ; v10(123.53,99.81) 123.53,100.17 123.54,100.17 ; v10(127.99,103.24) 127.76,103.24 v4(127.64,103.36) ; v10(127,106.59) 127,106.62 v4(126.64,106.69)
  GND1 w0.508: v10(196.5,121.7) 196.75,121.7 v4(197.01,121.95) ; v7(23.93,13.44) 23.5,13.01 23.5,12.28 23.96,11.82 23.96,9.38 v7(23.83,9.25)
  IN2 w0.102: 29.7,95.9 30.42,96.62 32.99,96.62 v3(33.55,97.18) 34.82,97.18 35.57,96.43 ; 29.7,95.9 29.95,95.9 30.62,95.23 34.14,95.23 35.34,96.43 35.57,96.43 ; 29.7,95.9 29.62,95.82 25.08,95.82 24.3,95.04 24.3,87.17 24.77,86.7 24.77,85.34 24.3,84.87 24.3,81.24 23.27,80.21 23.27,75.2 ; v12(140.98,115.65) 141.54,116.2 141.54,116.5 142.31,117.28 142.31,117.93 143.19,118.82 143.2,118.82 145.98,121.6 146.56,121.6 146.72,121.45 149.24,121.45 151.46,119.23 160.75,119.23 161.72,120.19 162.6,120.19 163.02,119.78 ; 75.72,122.66 75.72,123.86 79.6,127.73 82.61,127.73 83.98,129.1 86.86,129.1 87.4,128.56 95.69,128.56 98.92,125.33 100.39,125.33 100.8,124.92 103.36,124.92 104.31,125.87 108.62,125.87 v7(109.02,126.27) 109.78,127.03 116.15,127.03 118.24,129.12 119.36,129.12 119.92,129.68 119.92,133.4 120.37,133.85 124.79,133.85 124.93,133.71 128.83,133.71 132.11,130.44 136.34,130.44 137.93,128.84 139.08,128.84 139.52,129.29 140.89,129.29 142.16,128.01 144.62,128.01 144.82,128.21 145.38,128.21 145.5,128.33 145.5,128.72 145.41,128.81 144.67,128.81 v12(144.53,128.67) 144.34,128.48 142.24,128.48 141.05,129.67 139.36,129.67 138.92,129.23 138.11,129.23 136.5,130.84 132.25,130.84 129,134.1 125.09,134.1 124.91,134.29 120.16,134.29 119.59,133.71 117.54,133.71 ; 193.68,115.76 193.68,115.58 186.68,108.58 173.37,108.58 172.62,107.83 171.73,107.83 171.59,107.68 170.35,107.68 170.28,107.62 165.28,107.62 164.42,108.48 161.65,108.48 159.77,110.36 153.02,110.36 152.57,110.81 151.27,110.81 151.17,110.71 151.12,110.76 150.88,110.76 ; 35.1,40.15 35.1,42.51 34,43.6 34,50.62 33.35,51.27 33.35,51.41 32.1,52.66 32.1,61.31 29.71,63.7 29.71,65.92 23.51,72.13 23.51,74.8 ; 146.1,133.67 146.59,133.18 147.33,133.18 147.83,132.67 154.31,132.67 154.84,132.14 155.73,132.14 156.42,131.45 v12(156.52,131.45) ; 146.1,133.67 146.54,134.11 146.54,134.84 ; 146.1,133.67 145.55,133.67 145.19,134.03 144.75,134.03 143.98,134.8 143.98,137.28 143.69,137.57 143.48,137.57 143.31,137.4 143.31,137.04 143.1,136.83 143.1,133.53 141.37,131.8 132.14,131.8 130.76,133.18 130.76,133.74 129.72,134.77 129.72,135.07 129.99,135.34 v3(130.03,135.34) 130.14,135.34 130.77,134.72 130.77,134.28 131.2,133.85 131.2,133.34 132.28,132.27 141.29,132.27 142.71,133.69 142.71,136.99 142.92,137.2 142.92,137.56 143.32,137.96 143.85,137.96 144.37,137.44 144.37,137.08 144.95,136.5 148,136.5 148.32,136.81 150.54,136.81 151.37,135.98 154.79,135.98 156.13,137.32 157.33,137.32 157.78,136.88 159.05,136.88 v12(159.34,136.58) 159.74,136.99 160.55,136.99 v12(160.71,136.83) ; v3(177.44,120.28) 177.35,120.19 177.35,119.26 175.99,117.89 174,117.89 173.17,117.06 173.17,116.7 170.75,114.28 168.56,114.28 165.47,117.37 165.47,118.66 164.33,119.79 163.53,119.79 v4(163.4,119.67) ; 183.14,87.3 191,95.16 191,96.73 191.2,96.93 191.65,96.93 194.63,99.92 194.63,100.74 195.47,101.58 ; 110.31,127.41 115.99,127.41 118.12,129.55 119.24,129.55 119.53,129.84 119.53,131.73 117.54,133.71 ; 110.31,127.41 109.35,127.41 108.19,126.25 104.05,126.25 103.1,125.31 101,125.31 100.54,125.76 99.3,125.76 98.4,126.66 ; 110.31,127.41 110.05,127.68 107.28,127.68 106.9,127.3 106.9,127.06 106.62,126.78 105.54,126.78 104.71,127.62 100.37,127.62 98.57,129.41 98.57,131.41 96.23,133.75 v4(96.23,134.45) 96.23,134.53 96.89,135.19 97.45,135.19 98.52,134.12 99.1,134.12 ; 50.97,81.34 46.03,81.34 45.9,81.47 ; 164.7,105.77 164.62,105.7 164.62,104.76 164.45,104.58 162.69,104.58 162.07,103.96 159.81,103.96 159.15,104.62 153.22,104.62 152.98,104.86 152.12,104.86 151.71,105.27 151.71,105.78 151.09,106.4 v7(151.09,106.46) ; 198.62,98.73 198.62,98.04 199.32,97.34 199.32,96.54 ; 181.6,89.53 182.57,89.53 189.01,95.97 189.01,97.38 190.73,99.11 191.14,99.11 192.58,100.54 192.58,101.53 194.65,103.6 194.65,104.99 200.29,110.63 202.03,110.63 ; v12(147.24,111.95) 147.92,111.95 148.37,112.4 149.17,112.4 149.8,111.77 152.45,111.77 153.39,110.83 159.96,110.83 161.61,109.18 165.05,109.18 165.36,109.48 166.14,109.48 167.54,108.08 170.09,108.08 170.15,108.15 171.4,108.15 171.54,108.29 172.37,108.29 173.15,109.07 186.5,109.07 192.93,115.5 192.93,115.83 193.17,116.08 ; 35.57,96.43 50.63,96.43 51.59,95.46 59.95,95.46 61.85,93.56 62.16,93.56 65.42,90.29 74.64,90.29 75.06,89.87 86.81,89.87 88.02,88.66 96.61,88.66 96.73,88.78 102.03,88.78 102.1,88.7 103,88.7 103.54,88.17 107.13,88.17 107.29,88.33 110.57,88.33 110.95,88.71 112.39,88.71 112.52,88.59 113.89,88.59 114.17,88.31 115.98,88.31 v12(116.3,88.64) ; 117.54,133.71 117.53,133.7 113.58,133.7 112.78,132.9 112.78,130.29 112.35,129.85 110.12,129.85 109.46,129.19 108.53,129.19 ; 199.8,108.56 199.8,108.91 200.63,109.74 202.25,109.74 202.46,109.53 201.48,108.56 199.8,108.56 ; 199.8,108.56 196.8,105.55 196.8,105.28 195.66,104.15 195.66,103.16 193.64,101.14 193.64,100.2 191.47,98.03 191.03,98.03 190,97 190,95.55 182.87,88.43 v12(174.25,88.43) 174.25,88.77 172.81,90.21 154.46,90.21 153.72,90.95 150.39,90.95 148.37,88.93 147.12,88.93 146.72,89.34 144.13,89.34 143.05,90.42 139.27,90.42 137.92,91.77 137.92,93.77 136.23,95.46 v12(136.23,95.51) ; 43.71,102.64 42.93,101.86 42.93,101.48 42.34,100.88 ; 61.91,100.35 50.58,100.35 50.29,100.64 46.45,100.64 46.21,100.88 45.49,100.88 ; v12(157.46,131.45) 157.49,131.48 157.49,135.88 156.95,136.42 156.34,136.42 155,135.08 150,135.08 149.23,135.85 v12(148.09,135.85) 148.42,136.18 149.59,136.18 149.78,136.36 150.29,136.36 150.54,136.11 150.54,135.61 150.6,135.54 154.94,135.54 156.28,136.88 157.22,136.88 157.72,136.37 158.67,136.37 159.72,135.32 160.46,135.32 161.32,136.18 ; v12(172.87,91.37) 171.99,91.37 171.38,90.76 154.69,90.76 153.95,91.5 150.16,91.5 148.14,89.48 147.39,89.48 146.97,89.9 144.35,89.9 143.28,90.97 139.5,90.97 138.47,92 138.47,94.08 136.61,95.93 136.61,96.24 v12(136.18,96.68) ; 199.32,96.54 198.97,96.2 198.8,96.2 196.18,93.58 193.99,93.58 193.33,94.24 191.09,94.24 190.67,93.82 190.67,93.26 v4(189.8,92.39) 193.65,88.54 197.95,88.54 199.32,89.9 199.32,96.54 ; 31.91,75.1 30.51,75.1 30.36,75.25 30.36,76.98 28.78,78.56 v7(28.78,78.61) ; v12(37.06,104.54) 36.89,104.72 36.19,104.72 35.82,104.35 35.82,103.93 34.38,102.5 19.78,102.5 18.65,101.37 v4(17.57,101.37) ; 195.47,101.58 196.75,102.87 196.75,103.87 197.9,105.01 197.9,105.24 200.2,107.54 201.99,107.54 202.72,108.28 ; 195.47,101.58 196.73,101.58 ; 26.85,94.86 30.21,94.86 30.4,94.67 31.56,94.67 v12(31.69,94.53) ; 26.85,94.86 26.85,94.6 26,93.75 26,87.58 25.57,87.14 25.57,85.06 25.23,84.72 25.23,81.06 25,80.83 ; 26.85,94.86 26.05,94.86 25.76,95.16 25.76,95.41 ; 60.08,108.33 59.96,108.21 59.96,106.99 60.45,106.5 60.45,106.04 v7(60.59,105.9) 61.41,105.08 61.41,102.33 61.22,102.15 52.8,102.15 52.56,102.38 52.4,102.38 51.71,103.07 ; v12(151.38,136.85) 151.38,136.8 151.72,136.46 153.04,136.46 v12(153.26,136.67) 153.5,136.43 153.99,136.43 v12(154.57,137) 154.57,137.33 154.95,137.72 157.63,137.72 157.97,137.38 v12(158.77,137.38) ; 64.65,119.67 64.65,118.4 62.07,115.82 62.07,112.1 59.01,109.05 59.01,106.6 59.26,106.35 59.26,105.51 59.77,105 59.77,103.72 59.36,103.31 58.65,103.31 58.11,103.84 ; v4(41.43,95.39) 41.08,95.74 37.55,95.74 v7(35.29,93.48) 34.68,92.87 32.85,92.87 v4(32.66,92.68) 32.44,92.46 32.44,92.46 30.99,91.01 30.99,88.37 30.39,87.76 30.39,81.13 28.8,79.54 v7(28.8,79.5) 28.78,79.48 ; 99.42,133.22 99.42,132.16 99.89,131.7 99.89,129.93 100.23,129.59 100.48,129.59 ; 108.45,89.44 112.62,89.44 112.83,89.24 114.05,89.24 114.47,89.65 v12(115.62,89.65) ; v7(60.59,107.17) 60.88,106.87 60.88,106.5 61.8,105.59 61.8,102.17 61.38,101.76 52.53,101.76 52.37,101.93 48.16,101.93 46.49,103.6 46.17,103.6 ; v12(144.62,114.92) 144.62,115.21 145.04,115.63 145.04,117.05 145.5,117.51 147.14,117.51 147.45,117.2 147.45,115.81 148.84,114.42 150.43,114.42 153.56,111.29 160.16,111.29 161.87,109.58 164.01,109.58 164.03,109.57 164.89,109.57 165.19,109.87 166.57,109.87 167.7,108.73 169.82,108.73 169.88,108.8 171.13,108.8 171.27,108.94 172.21,108.94 172.91,109.64 186.26,109.64 187.81,111.2 187.81,112.43 ; 31.86,87.43 31.85,87.43 31.14,86.73 31.14,80.44 30.27,79.57 30.27,78.77 30.6,78.44 31.77,78.44 ; 26.93,96.93 28.17,96.93 28.38,97.13 v12(28.38,97.44) 28.06,97.76 26.93,97.76 26.75,97.58 v12(26.75,97.46) 26.75,97.1 26.93,96.93 ; 185.59,100.15 v12(185.45,100.01) 185.5,99.96 185.5,98.38 v12(185.83,98.05) 186.11,98.05 186.61,97.56 186.61,96.81 186.18,96.38 186.03,96.38 v12(185.3,97.11) 184.25,98.17 v12(184.25,99.03) 184.44,99.22 184.44,100.19 184.99,100.74 185.43,100.74 185.59,100.58 185.59,100.15 ; v12(85.29,136.27) 85.7,135.86 88.4,135.86 88.75,136.21 v12(88.75,136.5) 88.63,136.61 85.63,136.61 v12(85.29,136.27) ; 176.19,126.23 173.8,126.23 173.53,126.49 170.38,126.49 169.57,125.69 168.61,125.69 168.36,125.94 168.36,126.65 168.56,126.86 170.13,126.86 170.25,126.98 176.13,126.98 176.36,126.75 v3(176.36,126.4) 176.19,126.23 ; v3(171.66,97.04) v3(170.16,97.04) 168.98,97.04 v3(168.62,97.39) 168.62,97.61 168.87,97.85 v12(170.11,97.85) v12(171.61,97.85) v12(173.15,97.85) v12(174.63,97.85) 175.74,97.85 176.03,97.56 v3(176.03,97.24) 175.83,97.04 v3(174.64,97.04) v3(173.21,97.04) v3(171.66,97.04)
  IN2 w0.127: 209.56,110.32 209.56,110.62 209.85,110.92 211.88,110.92 212.88,109.92 212.88,109.44 ; v12(21.24,29.83) 20.86,29.83 20.4,30.28 20.4,33.73 20.28,33.85 20.28,37.74 20.52,37.98 20.52,40.6 19.31,41.81 v4(18.98,41.81)
  IN2 w0.254: v4(126.64,102.13) 126.65,102.14 126.65,103.19 v4(126.67,103.21) 126.65,103.23 126.65,104.36 v4(126.64,104.36) v4(126.64,105.48) v4(126.64,106.69) v4(126.64,107.82) ; 216.83,112.77 216.83,115.97 216.85,115.98 ; 170.45,109.99 171.3,109.99 174.5,113.19 176.46,113.19 176.88,113.61 176.88,114.54 179.23,116.89 179.27,116.85 v7(180.42,116.85) ; 236.68,115.03 236.46,114.8 236.46,112.79 234.81,111.14 233.74,111.14 232.79,112.09 232.79,113.33 230.76,115.36 226.65,115.36 225.22,116.8 218.28,116.8 217.47,115.98 216.85,115.98 ; v7(57.64,92.62) v7(56.62,92.62) v7(55.61,92.62) v7(54.59,92.62) v7(53.57,92.62) v7(52.43,92.62) v7(51.29,92.62) ; 216.85,115.98 213.39,115.98 212.58,115.17 212.58,113.91 213.06,113.43 v12(213.06,113.34)
  IN2 w0.305: v12(213.06,113.34) 213.3,113.1 216.01,113.1 216.34,112.77 216.83,112.77 216.83,111.06 215.86,110.09 213.79,110.09 v4(212.98,110.9) 212.27,111.6 209.55,111.6 209.29,111.34 206.07,111.34 205.35,110.63 202.03,110.63 ; 51.71,103.07 49.51,105.27 v4(49.51,106.19) 49.51,106.71 v4(47.69,108.53) 46.94,109.28 v4(46.07,109.28) v4(43.9,109.28) v4(41.61,109.28) 40.67,109.28 40.13,108.73 40.13,108.01 39.87,107.76 v4(38.8,107.76) 37.86,107.76 v4(37.67,107.95) 37.65,107.97 37.65,108.71 39.43,110.49 47.43,110.49 52.89,105.02 52.89,104.28 53.32,103.84 58.11,103.84 ; 243.48,110.12 244.35,110.99 244.35,111.71 243.75,112.31 237.09,112.31 235.16,110.38 233.42,110.38 232.07,111.74 232.07,113.02 230.46,114.62 218.54,114.62 217.6,113.67 217.6,110.69 216.2,109.29 213.03,109.29 212.88,109.44 212.4,109.44 v4(211.78,110.07) 211.61,109.9 210.66,109.9 210.24,110.32 206.62,110.32 205.84,109.53 202.46,109.53 ; 243.48,110.12 241.9,108.54 ; 243.48,110.12 242.67,110.94 236.85,110.94 235.53,109.62 233.05,109.62 231.31,111.36 231.31,112.67 230.17,113.81 218.98,113.81 218.4,113.23 218.4,110.34 216.44,108.38 212.08,108.38 211.33,109.13 207.33,109.13 206.48,108.28 202.72,108.28 ; 198.62,98.73 198.23,99.12 198.23,100.09 196.73,101.58 ; 183.14,87.3 173.69,87.3 v12(171.72,89.26) ; 187.81,112.43 187.81,114.18 188.58,114.94 v7(189.08,114.94) 189.72,115.58 190.46,115.58 193.27,118.4 193.27,119.16 195.64,121.52 195.64,121.73 199.78,125.87 200.66,125.87 201.38,126.59 201.38,126.82 201.69,127.13 202.64,127.13 202.89,126.88 207.45,126.88 207.91,127.34 210.61,127.34 211.01,127.74 214.69,127.74 215.12,127.31 215.12,126.96 215.66,126.42 217.76,126.42 218,126.65 219.03,126.65 219.34,126.35 223.75,126.35 223.89,126.49 225.97,126.49 228.75,123.71 v3(229.89,123.71) ; v7(76.28,96.36) 76.96,96.36 78.14,95.18 94.39,95.18 94.82,95.61 98.67,95.61 99.13,95.16 99.23,95.16 100.48,93.91 v4(101.94,93.91) ; 202.43,119.52 200.67,119.52 199.49,118.34 198.42,118.34 195.69,115.61 195.69,115.25 188.78,108.34 188.78,107.15 188.19,106.56 186.62,106.56 185.78,105.72 178.29,105.72 177.51,106.51 175.98,106.51 175.54,106.94 174.03,106.94 173.37,106.28 172.37,106.28 172.23,106.14 170.99,106.14 170.92,106.07 165,106.07 164.7,105.77 ; 19.04,72.41 19.04,85.47 21.2,87.62 21.2,96.26 23.87,98.93 24.78,98.93 25.47,99.61 27.77,99.61 28.25,100.1 31.63,100.1 32.33,100.8 35.57,100.8 36.6,99.76 40.33,99.76 40.79,100.22 41.4,100.22 42.07,100.88 45.49,100.88 ; v12(93.06,132.95) 92.61,132.49 89.4,132.49 88.19,131.28 83.34,131.28 83.08,131.02 82.21,131.02 80.63,129.45 78.94,129.45 74.05,124.57 73.61,124.57 73.23,124.19 71.23,124.19 70.48,123.44 68.42,123.44 64.65,119.67 ; v12(172.87,91.37) 174.71,89.53 181.6,89.53 ; 63,99.86 65.57,97.28 74.24,97.28 v7(75.1,96.43) ; 98.4,126.66 95.97,129.09 87.94,129.09 87.42,129.62 83.8,129.62 82.42,128.24 79.38,128.24 74.49,123.35 74.02,123.35 72.93,122.26 70.97,122.26 70.65,121.94 69.69,121.94 63.3,115.55 63.3,111.55 60.08,108.33 ; v2(203.56,115.27) 204.24,114.6 205.13,114.6 206.59,116.06 209.83,116.06 210.23,115.67 210.71,115.67 212.38,117.33 216.8,117.33 217.6,118.13 225.86,118.13 227.27,116.72 231.44,116.72 231.67,116.49 232.17,116.49 234.19,114.48 v12(235.04,114.48) 236.56,115.99 236.56,116.98 237.52,117.94 239.9,117.94 241.87,115.97 242.53,115.97 246.83,111.67 246.83,108.72 246.6,108.49 246.13,108.49 245.59,109.04 245.59,111.77 242.28,115.07 241.47,115.07 240.49,116.05 237.7,116.05 236.68,115.03 ; 31.91,64.93 31.91,75.1 ; 20.08,26.07 20.08,25.45 21.14,24.4 23.85,24.4 25.51,26.06 28.42,26.06 29.19,26.83 35.81,26.83 36.25,26.39 36.25,25.8 35.36,24.91 25.99,24.91 24.33,23.25 20.66,23.25 18.94,24.97 18.94,25.58 18.25,26.26 16.69,26.26 13.27,29.68 13.27,31.07 12.46,31.89 12.46,36.2 11.57,37.09 11.57,41.91 6.41,47.07 6.41,47.48 5.91,47.97 v2(5.91,49.89) 5.91,59.16 5.12,59.95 5.12,69.58 10.41,74.86 10.41,79.08 11.91,80.58 11.91,86.18 v4(11.23,86.85) 11.23,87.77 10.61,88.39 9.98,88.39 9.76,88.17 9.25,88.17 8.72,88.7 8.72,90.89 9.11,91.28 10.12,91.28 13.13,88.27 13.13,80.17 11.56,78.6 11.56,74.28 6.27,69 6.27,60.46 7.06,59.67 7.06,48.45 7.58,47.93 7.58,47.52 13.84,41.27 13.84,38.36 13.61,38.13 13.61,32.36 14.42,31.55 14.42,30.16 16.93,27.64 ; 46.82,97.25 50.92,97.25 51.93,96.24 60.79,96.24 65.6,91.42 74.95,91.42 75.57,90.8 87.8,90.8 88.93,89.67 102.27,89.67 ; 193.17,116.08 195.39,118.3 195.39,119.78 196.53,120.91 197.06,120.91 197.64,121.5 197.64,122.89 199.33,124.58 199.89,124.58 200.56,125.25 205.57,125.25 205.73,125.41 206.39,125.41 208.06,123.74 208.06,119.78 v2(208.25,119.59) ; v7(60.59,107.17) 60.58,107.18 v7(60.58,107.85) 60.58,107.97 63.94,111.32 63.94,115.35 69.81,121.22 73.36,121.22
  IN2 w0.508: v7(25.44,6.36) 25.44,7.52 24.29,8.67 24.29,8.67 23.83,9.13 v7(23.83,9.25) 23.39,8.81 21.25,8.81 v7(20.81,9.25) 20.81,9.81 v7(20.66,9.96) 20.63,9.94 15.67,9.94
  GND2 w0.203: H9.1 104.84,102.88 ; H9.1 104.1,102.63 ; H9.1 103.11,103.62 ; H9.1 104.1,104.61 ; H9.1 103.36,102.88 ; H9.1 105.09,103.62 ; H9.1 103.36,104.36 ; H6.1 235.44,149.49 ; H6.1 236.19,147.55 ; H6.1 233.5,150.24 ; H6.1 230.81,147.55 ; H6.1 231.56,145.61 ; H6.1 233.5,144.86 ; H6.1 231.56,149.49 ; H6.1 235.44,145.61 ; 7.4,77.93 JCR1.22 ; JCR1.22 7.4,79.31 ; JCR1.22 8.49,78.62 ; JCR1.22 6.31,79.31 ; JCR1.22 6.31,78.62 ; JCR1.22 8.49,79.31 ; JCR1.22 8.49,77.93 ; JCR1.22 6.31,77.93 ; 41.06,145.61 H5.1 ; H5.1 41.06,149.49 ; H5.1 40.31,147.55 ; H5.1 44.94,145.61 ; H5.1 44.94,149.49 ; H5.1 43,150.24 ; H5.1 45.69,147.55 ; H5.1 43,144.86 ; H10.1 197.05,95.9 ; H10.1 195.5,94.86 ; H10.1 197.05,96.94 ; H10.1 195.5,96.94 ; H10.1 197.05,94.86 ; H10.1 193.95,96.94 ; H10.1 193.95,95.9 ; H10.1 193.95,94.86 ; 192.56,81.61 H2.1 ; H2.1 196.44,81.61 ; H2.1 194.5,80.86 ; H2.1 196.44,85.49 ; H2.1 194.5,86.24 ; H2.1 192.56,85.49 ; H2.1 191.81,83.55 ; H2.1 197.19,83.55 ; 2.23,96.67 H11.1 ; H11.1 4.04,95.9 ; H11.1 3.77,96.67 ; H11.1 1.96,95.9 ; H11.1 3,94.86 ; H11.1 3,96.94 ; H11.1 3.77,95.13 ; H11.1 2.23,95.13 ; 6.31,93.02 JCR1.23 ; JCR1.23 6.31,93.71 ; JCR1.23 8.49,92.33 ; JCR1.23 6.31,92.33 ; JCR1.23 7.4,93.71 ; JCR1.23 8.49,93.71 ; JCR1.23 8.49,93.02 ; JCR1.23 7.4,92.33 ; JUSBC1.B1 7.45,28.15 ; JUSBC1.B1 7.1,27.35 ; JUSBC1.B1 7.8,28.06 ; JUSBC1.B1 7,27.71 ; 13.1,0.86 H4.1 ; H4.1 11.16,5.49 ; H4.1 15.04,1.61 ; H4.1 15.79,3.55 ; H4.1 11.16,1.61 ; H4.1 15.04,5.49 ; H4.1 10.41,3.55 ; H4.1 13.1,6.24 ; 7.5,105.36 H7.1 ; H7.1 10.19,108.05 ; H7.1 7.5,110.74 ; H7.1 9.44,106.11 ; H7.1 9.44,109.99 ; H7.1 4.81,108.05 ; H7.1 5.56,109.99 ; H7.1 5.56,106.11 ; 143.1,103.63 H8.1 ; H8.1 143.1,105.61 ; H8.1 144.09,104.62 ; H8.1 142.11,104.62 ; H8.1 142.36,105.36 ; H8.1 143.84,103.88 ; H8.1 143.84,105.36 ; H8.1 142.36,103.88 ; 7.45,32.86 JUSBC1.B12 ; JUSBC1.B12 7.1,33.66 ; JUSBC1.B12 7,33.31 ; JUSBC1.B12 7.8,32.95 ; JUSBC1.B12 7.89,33.31 ; 7,13.71 JUSBC2.B1 ; JUSBC2.B1 7.45,14.15 ; JUSBC2.B1 7.8,14.06 ; JUSBC2.B1 7.1,13.35 ; 7.45,18.86 JUSBC2.B12 ; JUSBC2.B12 7.8,18.95 ; JUSBC2.B12 7,19.31 ; JUSBC2.B12 7.89,19.31 ; JUSBC2.B12 7.1,19.66 ; JNGFF3.18 249.65,113.03 ; JNGFF3.18 249.76,112.62 ; JNGFF3.18 249.65,112.22
  GND3 w0.203: JCR1.22 8.49,79.31 ; JCR1.22 6.31,79.31 ; JCR1.22 8.49,77.93 ; JCR1.22 6.31,77.93 ; JCR1.22 6.31,78.62 ; JCR1.22 7.4,77.93 ; JCR1.22 7.4,79.31 ; JCR1.22 8.49,78.62 ; H10.1 197.05,95.9 ; H10.1 195.5,96.94 ; H10.1 193.95,94.86 ; H10.1 197.05,96.94 ; H10.1 193.95,95.9 ; H10.1 193.95,96.94 ; H10.1 195.5,94.86 ; H10.1 197.05,94.86 ; H7.1 9.44,109.99 ; H7.1 5.56,109.99 ; H7.1 5.56,106.11 ; H7.1 10.19,108.05 ; H7.1 9.44,106.11 ; H7.1 7.5,110.74 ; H7.1 7.5,105.36 ; H7.1 4.81,108.05 ; H9.1 104.84,102.88 ; H9.1 103.36,102.88 ; H9.1 103.36,104.36 ; H9.1 104.1,102.63 ; H9.1 104.84,104.36 ; H9.1 105.09,103.62 ; H9.1 104.1,104.61 ; H9.1 103.11,103.62 ; 194.5,80.86 H2.1 ; H2.1 191.81,83.55 ; H2.1 194.5,86.24 ; H2.1 196.44,81.61 ; H2.1 196.44,85.49 ; H2.1 197.19,83.55 ; H2.1 192.56,85.49 ; H2.1 192.56,81.61 ; 7.1,27.35 JUSBC1.B1 ; JUSBC1.B1 7.45,28.15 ; JUSBC1.B1 7.8,28.06 ; JUSBC1.B1 7,27.71 ; 142.36,105.36 H8.1 ; H8.1 143.1,103.63 ; H8.1 144.09,104.62 ; H8.1 143.84,103.88 ; H8.1 143.84,105.36 ; H8.1 142.11,104.62 ; H8.1 142.36,103.88 ; H8.1 143.1,105.61 ; 11.16,1.61 H4.1 ; H4.1 10.41,3.55 ; H4.1 13.1,6.24 ; H4.1 15.04,1.61 ; H4.1 15.79,3.55 ; H4.1 11.16,5.49 ; H4.1 15.04,5.49 ; H4.1 13.1,0.86 ; 2.23,96.67 H11.1 ; H11.1 3,96.94 ; H11.1 3.77,95.13 ; H11.1 2.23,95.13 ; H11.1 3,94.86 ; H11.1 4.04,95.9 ; H11.1 1.96,95.9 ; H11.1 3.77,96.67 ; JCR1.23 8.49,93.71 ; JCR1.23 6.31,92.33 ; JCR1.23 8.49,93.02 ; JCR1.23 6.31,93.71 ; JCR1.23 7.4,92.33 ; JCR1.23 6.31,93.02 ; JCR1.23 8.49,92.33 ; JCR1.23 7.4,93.71 ; H5.1 44.94,145.61 ; H5.1 43,144.86 ; H5.1 43,150.24 ; H5.1 41.06,149.49 ; H5.1 40.31,147.55 ; H5.1 44.94,149.49 ; H5.1 45.69,147.55 ; H5.1 41.06,145.61 ; JNGFF3.18 249.65,112.22 ; JNGFF3.18 249.65,113.03 ; JNGFF3.18 249.76,112.62 ; 7.45,32.86 JUSBC1.B12 ; JUSBC1.B12 7.8,32.95 ; JUSBC1.B12 7,33.31 ; JUSBC1.B12 7.1,33.66 ; JUSBC1.B12 7.89,33.31 ; 231.56,149.49 H6.1 ; H6.1 230.81,147.55 ; H6.1 233.5,144.86 ; H6.1 235.44,149.49 ; H6.1 233.5,150.24 ; H6.1 231.56,145.61 ; H6.1 235.44,145.61 ; H6.1 236.19,147.55 ; 7,13.71 JUSBC2.B1 ; JUSBC2.B1 7.1,13.35 ; JUSBC2.B1 7.8,14.06 ; JUSBC2.B1 7.45,14.15 ; 7.45,18.86 JUSBC2.B12 ; JUSBC2.B12 7.8,18.95 ; JUSBC2.B12 7.89,19.31 ; JUSBC2.B12 7.1,19.66 ; JUSBC2.B12 7,19.31
  IN3 w0.076: 159.64,134.98 159.61,134.98 159,135.59 158.68,135.59 v4(158.64,135.63) 158.54,135.73 158.54,136 158.26,136.28 157.8,136.28 157.71,136.37
  IN3 w0.084: v4(232.75,121.8) 232.57,121.8 v20(232.34,122.03)
  IN3 w0.102: 101.81,109.79 104.82,106.78 106.81,106.78 ; 101.81,109.79 100.95,110.64 100.95,118.13 101.26,118.44 101.26,122.67 102.74,124.15 104.48,124.15 105.1,124.77 ; 101.81,109.79 102.97,109.79 105.42,107.34 109.7,107.34 111.82,105.21 111.82,104.2 111.65,104.03 111.09,104.03 110.85,103.79 ; v20(172.88,104.86) v20(171.68,104.86) 167.68,104.86 166.67,103.84 165.3,103.84 164.3,102.84 163.5,102.84 163.36,102.7 161.19,102.7 157.97,99.48 156.57,99.48 155.76,98.66 150.86,98.66 150.35,98.15 149.03,98.15 148.44,97.57 148.06,97.57 145.84,95.35 144.14,95.35 143.03,94.24 142.1,94.24 141.99,94.14 139.17,94.14 138.99,93.96 137.04,93.96 v20(136.84,93.76) ; v20(172.88,104.86) v20(175.61,104.86) 180.7,104.86 183.47,102.09 184.59,102.09 186.6,100.08 186.6,99.73 190.07,96.25 190.66,96.25 190.91,95.99 191.57,95.99 191.75,96.17 191.75,99.17 ; v20(172.88,104.86) 172.88,106.27 v20(171.29,107.86) 171.29,107.98 168.76,110.51 168.76,111.61 170.95,113.79 170.95,117.59 169.07,119.47 v20(169.07,120.95) ; 15.09,100.8 15.32,101.04 15.32,101.14 v6(15.62,101.44) 16.37,102.19 v6(16.83,102.19) 16.94,102.29 v6(18.64,102.29) 19,102.29 19.15,102.45 26.84,102.45 26.92,102.37 v6(27.67,102.37) v6(28.81,102.37) 28.81,102.37 v6(30.36,102.37) 30.78,102.37 v6(31.42,101.74) 31.83,101.33 v6(33.06,101.33) v6(34.92,101.33) 35.53,101.33 v6(36.29,102.09) v4(36.93,102.73) v4(37.71,103.51) 38.28,103.51 ; v4(163.4,119.67) 163.43,119.64 163.43,119.18 163.66,118.96 163.66,118.1 163.09,117.54 163.09,115.02 163.83,114.29 163.83,114.18 ; v7(99.83,86.65) 99.5,86.98 91.95,86.98 90.98,86 ; v7(162.64,118.83) 162.64,118.97 162.8,119.13 162.8,121.78 163.77,122.75 163.77,123.16 163.29,123.64 163.29,124.15 163.4,124.26 163.4,124.62 162.69,125.33 v4(162.41,125.33) ; v20(150.93,92.39) 151.24,92.69 152.28,92.69 152.86,92.11 154.97,92.11 155.56,92.69 158.88,92.69 159.32,93.12 162.63,93.12 v20(164.61,95.11) ; 210.52,139.24 210.52,141.16 210.34,141.33 ; v20(154.43,93.32) 155.17,94.06 159.41,94.06 159.87,94.52 162.81,94.52 165.12,96.83 165.51,96.83 168.76,100.08 178.19,100.08 184.92,93.35 184.92,92.74 187.38,90.28 193.27,90.28 194.67,91.68 194.67,92.07 197.73,95.13 197.73,96.96 197.63,97.06 ; v20(92.41,86.29) 92.27,86.29 89.28,83.3 74.79,83.3 74.15,83.95 62.31,83.95 61.34,84.92 58.51,84.92 58.33,85.1 54.49,85.1 54.32,84.92 45.9,84.92 45.61,85.22 v20(44.73,85.22) ; 107.11,102.18 107.59,102.66 107.59,105.32 106.53,106.37 104.67,106.37 100.56,110.47 100.56,118.29 100.87,118.6 100.87,122.87 102.72,124.72 104,124.72 ; 107.11,102.18 105.9,100.97 105.9,99.76 105.34,99.2 103.54,99.2 ; 107.11,102.18 107.3,101.99 108.22,101.99 108.46,102.23 108.46,102.57 107.97,103.06 107.97,105.62 106.81,106.78 ; 19.87,99.58 20.2,99.91 v4(20.2,100.66) ; 19.87,99.58 18.98,99.58 ; 19.87,99.58 v7(17.67,97.38) 17.51,97.22 17.51,94.75 18.12,94.14 24.06,94.14 26.63,91.58 29.93,91.58 31.93,89.57 33.59,89.57 33.85,89.84 33.85,90.55 33.52,90.88 31.74,90.88 30.46,92.16 26.88,92.16 23.01,96.03 23.01,99 ; 27.9,97.02 27.9,97.29 26.97,98.22 25.62,98.22 25.21,98.62 23.39,98.62 23.01,99 ; 163.83,114.18 164,114.35 164,117.29 165.36,118.65 165.36,120.15 165.89,120.68 165.89,121.84 v20(165.7,122.03) ; 163.83,114.18 163.83,113.64 164.6,112.87 164.6,111.98 164.38,111.77 163.63,111.77 162.91,111.05 162.91,109.89 162.11,109.09 v20(162.11,106.83) ; 64.9,105.21 64.9,105.24 64.8,105.34 64.8,108.49 64.5,108.79 64.5,118.38 69.96,123.84 69.96,125.18 70.78,125.99 77.72,125.99 79.34,127.62 85.33,127.62 85.76,127.18 89.41,127.18 v7(90.15,127.92) ; 168.81,96.86 164.09,92.13 161.27,92.13 160.31,91.17 150.33,91.17 147.69,88.53 139.83,88.53 139.3,87.99 138.94,87.99 138.23,87.28 136.21,87.28 v4(136.14,87.36) 133.62,87.36 132.56,88.42 126.6,88.42 v20(126.55,88.37) ; 168.81,96.86 168.66,97.01 v20(168.66,97.14) 168.66,97.58 168.93,97.85 v20(170.15,97.85) v20(171.7,97.85) v20(173.2,97.85) v20(174.67,97.85) 175.91,97.85 176.1,97.66 v20(176.1,97.4) 176.1,97.1 175.85,96.86 ; 168.81,96.86 v20(170.1,96.86) v20(171.51,96.86) v20(173.13,96.86) v20(174.63,96.86) 175.85,96.86 ; 198.47,99.15 198.74,98.88 198.74,92.34 196.83,90.43 195.36,90.43 194.09,89.16 186.77,89.16 183.82,92.1 183.82,93 178.29,98.53 168.59,98.53 v20(165.44,95.39) ; 87.99,97.62 87.99,96.54 86.56,95.11 77.68,95.11 ; v7(163.02,118.33) 163.02,118.21 162.66,117.85 162.66,115.37 v4(162.44,115.15) ; 39.54,103.84 41.58,101.8 42.94,101.8 43.13,101.61 61.23,101.61 63.23,103.61 63.23,107.72 62.96,107.99 62.96,119.03 68.13,124.2 68.13,125.48 71.61,128.96 75.8,128.96 76.13,128.63 76.87,128.63 77.91,129.67 79.28,129.67 79.39,129.78 81.92,129.78 82.15,129.55 v20(83.7,129.55) 84.97,129.55 85.02,129.6 92.19,129.6 92.56,129.23 94.53,129.23 94.74,129.02 98.95,129.02 99.81,129.88 ; 39.54,103.84 39.54,103.45 39.38,103.28 38.48,103.28 38.28,103.49 38.28,103.51 ; 39.54,103.84 v4(39.54,103.92) ; v20(37.1,97.12) 36.77,96.79 28.49,96.79 28.02,96.32 ; v4(189.8,92.39) 188.47,92.39 186.92,93.94 186.92,95.49 183.52,98.89 182.2,98.89 178.88,102.22 168.71,102.22 166.68,100.19 164.99,100.19 163.41,98.6 161.82,98.6 159.29,96.07 157.26,96.07 156.98,95.79 154.01,95.79 153.6,95.39 152.78,95.39 v20(152.47,95.07) 151.77,94.37 148.62,94.37 v20(146.84,92.59) ; 175.85,96.86 176.41,96.3 178.9,96.3 181.46,93.73 181.46,92.18 181.49,92.16 ; v4(97.07,93.68) 97.19,93.56 99.24,93.56 99.68,93.99 ; 62.03,98.18 61.72,98.48 48.41,98.48 47.03,97.11 ; 157.71,136.37 155.66,136.37 154.4,135.11 149.41,135.11 149.13,134.83 146.56,134.83 v4(146.55,134.84) 146.39,135.01 145.04,135.01 142.86,132.83 142.86,132.04 142.63,131.81 141.9,131.81 140.37,130.27 140.37,129.12 141.12,128.36 142.19,128.36 142.81,127.75 142.81,126.9 143.26,126.45 143.26,122.66 142.91,122.31 142.91,117.28 143.47,116.71 143.47,110.49 141.64,108.66 141.64,107.85 139.58,105.79 139.58,103.74 139.22,103.39 139.22,102.56 138.97,102.31 138.97,101.29 137.92,100.25 137.15,100.25 136.91,100 136.91,99.3 136.76,99.14 v20(136.76,99.09) ; 10.96,88.06 10.7,88.32 v6(10.13,88.32) 9.53,88.32 8.69,89.16 v6(8.69,89.84) 8.69,90.91 v6(9.16,91.38) 9.66,91.89 v6(9.66,92.93) v6(9.66,94.52) v6(9.66,95.92) 9.66,97.14 v6(9.97,97.45) v6(11.18,98.66) v6(12.33,99.81) v6(13.79,101.27) 14.9,102.38 v6(14.94,102.38) 15.96,103.4 v6(16.49,103.4) v6(18.47,103.4) 18.54,103.46 31.25,103.46 v6(31.7,103.02) 32.14,102.57 v6(33.52,102.57) 35.1,102.57 v6(35.78,103.25) 36.69,104.16 v4(36.69,104.35) 37.66,105.32 v4(37.66,105.67) v4(37.66,106.74) 37.66,107.93 v4(37.67,107.95) 37.67,108.48 38.02,108.82 39.6,108.82 40.07,108.35 40.07,107.26 38.96,106.14 38.96,105.12 38.28,104.44 38.28,103.51 ; 35.27,97.93 35.25,97.93 34.83,97.51 28.68,97.51 27.32,98.86 26.05,98.86 25.55,99.37 24.77,99.37 v4(24.52,99.63) 24.52,99.7 24.28,99.94 23.27,99.94 23.01,99.68 23.01,99 ; 120.73,122.49 120.73,124.9 120.23,125.39 119.39,125.39 ; v20(165.94,116.21) 165.95,116.21 165.95,116.4 167.01,117.46 167.01,119.03 167.11,119.13 v20(167.14,119.13) ; v20(164.61,95.11) 164.78,94.94 164.78,94.6 165,94.37 165.29,94.37 165.56,94.65 165.56,95.26 v20(165.44,95.39) ; v20(164.61,95.11) 164.89,95.39 v20(165.44,95.39) ; 65.08,102.56 62.59,100.07 ; 62.59,100.07 62.58,100.08 42.46,100.08 42.3,100.25 40.93,100.25 39.57,101.61 38.18,101.61 36.23,99.66 35.42,99.66 34.04,98.28 29.29,98.28 27.84,99.73 26.61,99.73 25.98,100.36 25.2,100.36 24.63,100.94 22.51,100.94 ; 62.59,100.07 62.68,100.07 ; v4(120.19,124.67) 119.95,124.9 117.95,124.9 117.81,124.77 ; v20(86.93,133.49) 86.93,133.49 86.64,133.19 86.15,133.19 85.87,133.47 v20(85.87,133.89) 86.27,134.29 89.29,134.29 90.05,135.04 95.05,135.04 95.24,134.85 98.22,134.85 98.63,134.45 99.27,134.45 99.57,134.76 100.75,134.76 101.41,135.42 102.82,135.42 103.6,136.2 106.76,136.2 107.76,135.2 111.42,135.2 112.74,133.89 114.75,133.89 115.76,132.88 v7(116.03,132.88) 117.46,132.88 118.02,132.31 120.45,132.31 121.43,131.34 122.25,131.34 125.14,128.45 132.88,128.45 133.41,128.98 137.08,128.98 138.04,129.94 138.99,129.94 140.99,127.95 142.03,127.95 142.41,127.57 v20(142.41,126.51) ; 159.64,134.98 159.9,134.72 159.9,134.07 v4(159.72,133.89) 159.72,133.13 159.63,133.04 159.63,132.12 158.76,131.26 157.35,131.26 156.22,132.39 155.35,132.39 155.02,132.06 151.47,132.06 149.65,130.23 149.49,130.23 149.19,129.94 149.19,129.18 147.16,127.15 147.16,125.22 146.39,124.45 146.39,121.29 145.92,120.83 145.92,119.49 147.19,118.22 147.19,117.71 147.48,117.42 147.48,113.39 147.04,112.96 147.04,109.84 147.38,109.51 147.38,108.56 147.16,108.34 146.49,108.34 146.06,107.91 146.06,107.34 146.77,106.63 146.77,103.03 145.59,101.85 145.59,101.45 143.29,99.14 142.63,99.14 142.44,98.96 142.44,98.94 140.87,97.36 140.87,97.06 140.21,96.4 140.21,95.99 138.76,94.55 136.71,94.55 136.36,94.19 134.14,94.19 133.9,94.43 130.98,94.43 v6(130.28,95.13) ; 103.33,122.41 102.86,121.94 102.86,112.06 105.95,108.97 110.75,108.97 114.18,105.55 117.15,105.55 119.41,103.28 120.2,103.28 120.45,103.03 v4(120.45,102.27) ; 106.81,106.78 108.58,106.78 110.59,104.77 110.59,104.06 110.85,103.79 ; v20(169.04,101.07) 178.57,101.07 185.91,93.74 185.91,93.56 188.13,91.34 191.92,91.34 193.12,92.54 193.12,94.39 192.71,94.8 192.71,98.23 193.1,98.62 193.1,101.79 194.34,103.04 194.34,105.3 196.37,107.32 197.01,107.32 ; 99.81,129.88 100.36,130.43 101.1,130.43 101.43,130.77 v20(101.58,130.77) 101.78,130.56 101.78,130.01 101.43,129.66 100.03,129.66 99.81,129.88 ; 193.24,105.56 196.46,108.78 197.36,108.78 ; 198.3,99.32 198.89,99.91 198.89,101.73 198.15,102.47 198.15,104.3 197.92,104.53 197.92,105.5 197.57,105.86 ; v20(180.91,133.5) 180.41,133.5 179.04,132.13 177.58,132.13 177.32,131.87 177.32,130.87 175.69,129.24 175.19,129.24 173.99,130.44 171.35,130.44 169.2,128.29 169.2,127.03 169.02,126.86 168.12,126.86 168.07,126.8 166.86,126.8 166.63,127.03 166.63,128.02 171.22,132.61 v4(171.22,133.51) ; 110.85,103.79 111.09,103.55 111.47,103.55 113.2,101.82 113.41,101.82 v4(113.62,101.61) ; 108.39,122.41 109.07,123.1 115.53,123.1 116.72,121.9 118.29,121.9 120.22,123.83 ; v20(120.31,89.32) 122.83,86.8 123.33,86.8 126.32,83.81 127.34,83.81 127.7,83.45 140.18,83.45 142.1,85.37 v20(142.71,85.37) 142.75,85.41 149.21,85.41 150.48,86.67 153.44,86.67 154.39,87.62 163.47,87.62 163.63,87.79 ; 101.35,99.36 100.63,100.08 99.88,100.08 99.33,100.63 99.33,107.29 98.42,108.2 98.42,123.42 103.13,128.13 108.13,128.13 109.02,127.24 v7(109.02,126.27) ; 152.62,88.43 150.17,88.43 150.04,88.56 150.04,89.1 v20(150.36,89.42) 150.73,89.78 152.79,89.78 153.22,89.35 v4(153.22,89.25) 153.22,89.03 152.62,88.43 ; 215.58,116.39 215.58,115.36 214.85,114.64 213.05,114.64 v6(212.62,115.07) 212.26,115.43 212.26,119.19 211.98,119.48 211.98,121.26 210.58,122.66 210.58,123.62 209.91,124.29 209.91,131.15 211.86,133.09 212.74,133.09 213.37,132.47 213.37,128.3 213.24,128.18 213.24,125.66 213.68,125.22 213.68,124.53 214.23,123.99 214.23,121.89 v7(213.91,121.57) 213.9,121.57 213.88,121.55 213.88,120.32 v7(213.88,120.32) 214.55,119.65 214.55,117.42 215.58,116.39
  IN3 w0.127: v20(92.41,86.29) 92.52,86.39 98.94,86.39 99.44,85.9 101.4,85.9 101.78,86.28 v7(101.78,86.67) 101.78,87.13 102.38,87.73 102.38,88.53 102.61,88.75 103.98,88.75 104.22,88.51 106.24,88.51 106.58,88.17 107.02,88.17 107.3,88.45 107.3,89.15 106.99,89.45 106.6,89.45 106.33,89.19 104.44,89.19 104.3,89.33 102.37,89.33 101.81,88.77 101.81,87.97 100.85,87.01 v7(100.85,86.66) 100.84,86.65 v7(99.83,86.65) ; 33.98,46.67 33.98,47.71 36.84,50.57 36.84,80.34 39.17,82.67 41.65,82.67 44.2,85.22 v20(44.73,85.22)
  IN3 w0.254: v4(126.64,107.82) v4(126.64,106.69) v4(126.64,105.48) v4(126.64,104.36) 126.65,104.36 126.65,103.23 v4(126.67,103.21) 126.65,103.19 126.65,102.14 v4(126.64,102.13) ; v4(128.02,102.48) 127.64,102.87 v4(127.64,103.36) 127.64,105.58 v4(127.65,105.6) 127.65,106.69 v4(127.64,106.7) v4(127.64,107.6)
  IN3 w0.305: v20(95.95,89.95) 90.41,89.95 88.62,88.17 85.91,88.17 85.39,87.65 76.41,87.65 75.97,88.09 64.91,88.09 62.93,90.08 57.69,90.08 v7(57.64,90.13) 56.94,89.43 51.25,89.43 50.42,90.27 48.66,90.27 47.58,89.18 42.75,89.18 39.54,85.97 37.73,85.97 33.44,81.68 33.44,52.28 30.6,49.43 29.16,49.43 28.84,49.11 27.72,49.11 26.5,47.89 26.5,47.48 ; 240.89,119.6 240.72,119.44 240.72,118.07 239.96,117.3 238.72,117.3 234.92,113.51 219.22,113.51 212.36,106.65 212.36,106.13 ; 240.89,119.6 242.17,120.89 243.3,120.89 v4(243.52,120.67) 243.72,120.87 243.72,122.17 243.35,122.54 240.58,122.54 240.19,122.14 ; 240.89,119.6 240.89,121.45 240.19,122.14 ; 62.03,98.18 65.52,94.69 v7(68.27,94.69) v7(68.83,94.69) v7(69.44,94.69) 71.6,94.69 v7(71.69,94.78) v7(72.24,94.78) v7(72.85,94.78) v7(73.41,94.78) 74.15,94.78 75.62,93.3 v7(75.72,93.3) 75.85,93.18 79.48,93.18 79.61,93.3 87.24,93.3 89.65,95.71 99.2,95.71 99.68,95.23 99.68,93.99 ; v7(91.42,127.92) 91.42,127.7 92.13,127 93.58,127 93.83,126.74 94.48,126.74 94.73,127 101.31,127 102.92,128.62 108.35,128.62 110.31,126.65 110.74,126.65 112,125.39 119.39,125.39 ; 28.02,96.32 27.9,96.45 27.9,97.02 ; v7(22.85,44.61) 22.85,45.23 24.57,46.95 25.97,46.95 26.5,47.48 ; v20(40.33,104.69) 40.33,104.3 40.47,104.16 40.47,103.87 41.88,102.46 43.28,102.46 43.47,102.26 60.45,102.26 60.59,102.4 v7(60.59,103.11) ; v7(204.07,123.1) 203.82,123.35 203.82,124.49 204.81,125.48 204.81,129.01 203.73,130.08 203.73,134.3 204.04,134.61 204.04,135.93 206.94,138.83 206.94,141.79 207.32,142.17 209.51,142.17 210.34,141.33 ; 47.03,97.11 43.69,97.11 42.88,97.93 35.27,97.93 ; 120.73,122.49 120.96,122.26 120.96,118.93 124.1,115.79 128.67,115.79 v20(129.04,116.16) ; 205.47,107.96 211.33,107.96 211.58,108.2 211.58,108.75 211.4,108.92 ; 205.47,107.96 205.47,108.5 205.89,108.92 211.4,108.92 ; 205.47,107.96 198.38,107.96 197.74,107.32 197.01,107.32 ; v7(206.1,123.1) 206.55,123.54 206.95,123.54 207.27,123.86 207.27,126.34 206.91,126.7 206.91,130.71 210.75,134.55 210.75,136.7 210.32,137.13 210.32,137.89 210.52,138.1 210.52,139.24 ; 117.81,124.77 105.1,124.77 ; v7(29.57,45.75) 30.54,46.72 31.95,46.72 36.14,50.91 36.14,80.64 38.84,83.34 41.31,83.34 44.16,86.19 45.7,86.19 46.31,85.58 54.04,85.58 54.27,85.81 58.69,85.81 58.92,85.58 62.85,85.58 63.83,84.6 74.56,84.6 75.15,84.01 88.99,84.01 90.98,86 ; 211.4,108.92 212.46,108.92 218.61,115.07 234.21,115.07 237.65,118.5 237.65,120.67 240.52,123.54 243.67,123.54 246.93,120.28 246.93,118.56 246.23,117.86 ; 245.17,117.41 245.17,116.95 245.75,116.37 246.77,116.37 247.7,117.29 247.7,120.59 243.94,124.35 240.25,124.35 236.87,120.97 236.87,119.08 233.63,115.84 218.32,115.84 215.45,112.97 215.06,112.97 v4(212.98,110.9) 212.15,110.07 v4(211.78,110.07) 211.42,109.71 210.22,109.71 210.18,109.75 204.9,109.75 203.89,108.75 197.4,108.75 197.36,108.78 ; v4(97.07,93.68) 96.76,93.99 90.31,93.99 87.46,91.13 79.66,91.13 79.05,91.74 75.08,91.74 v7(74.49,92.32) v7(73.91,92.32) v7(73.35,92.32) 71.49,92.32 v7(71.48,92.34) v7(70.9,92.34) v7(70.19,92.34) 70.17,92.32 v7(68.07,92.32) v7(67.48,92.32) v7(66.77,92.32) 65.12,92.32 60.18,97.27 49.62,97.27 48.05,95.7 43,95.7 42.11,96.59 39.26,96.59 36.15,93.48 v7(35.29,93.48) ; 197.86,87.93 185.72,87.93 181.49,92.16 180.3,92.16 179.75,92.7 173.14,92.7 169.04,88.6 164.45,88.6 163.63,87.79 ; 104,124.72 105.12,125.84 108.59,125.84 v7(109.02,126.27) ; v4(11.23,86.85) 10.96,87.12 v6(10.96,89.91) v6(10.96,92.76) 10.96,93.77 11.58,94.38 v7(11.58,94.61) v6(11.58,97.07) 11.58,97.29 v6(12.25,97.97) v6(13.65,99.37) 15.09,100.8 ; 26.5,47.48 26.45,47.48 ; 64.9,105.21 65.08,105.03 65.08,102.56 ; 238.89,120.84 239.22,120.51 239.22,119.69 239.82,119.1 239.82,118.49 239.53,118.19 ; 238.89,120.84 238.44,120.39 238.44,118.17 ; 238.89,120.84 240.19,122.14 ; 238.44,118.17 234.54,114.27 218.9,114.27 211.74,107.11 199.41,107.11 198.16,105.86 196.17,105.86 195.41,105.1 195.41,102.58 194.24,101.41 194.24,100.54 ; 238.44,118.17 238.46,118.19 ; 87.99,97.62 88.88,98.51 91.78,98.51 92.11,98.18 97.99,98.18 98.36,98.55 99.97,98.55 100.78,99.36 103.37,99.36 103.54,99.2 ; 194.24,100.54 194.52,100.82 195.1,100.82 195.51,100.41 v4(195.51,100.39) 197.23,100.39 198.47,99.15 ; 194.24,100.54 194.24,99.45 194.75,98.94 196.58,98.94 197.63,97.89 197.63,97.06 ; 103.33,122.41 108.39,122.41 ; 120.22,123.83 120.22,124.63 v4(120.19,124.67) ; 18.98,99.58 17.49,98.09 15.55,98.09 12.76,95.3 12.76,93.28 12.29,92.81 v20(12.29,91.82) ; 62.68,100.07 66.29,96.46 74.38,96.46 74.97,95.87 75.85,95.87 76.61,95.11 77.68,95.11 ; 191.75,99.17 191.73,99.2 191.98,99.45 191.98,102.37 193.24,103.63 193.24,105.56
  IN3 w0.381: v7(35.29,93.48) v7(34.27,93.48) 33.28,93.48 v7(33.25,93.46) 33.25,93.28 v4(32.66,92.68)
  GND4 w0.102: v20(162.11,106.83) 161.93,106.65 161.93,105.72 v7(161.98,105.67)
  GND4 w0.203: 7,27.71 JUSBC1.B1 ; JUSBC1.B1 7.1,27.35 ; JUSBC1.B1 7.45,28.15 ; JUSBC1.B1 7.8,28.06 ; 10.41,3.55 H4.1 ; H4.1 15.04,5.49 ; H4.1 13.1,6.24 ; H4.1 13.1,0.86 ; H4.1 15.04,1.61 ; H4.1 11.16,5.49 ; H4.1 11.16,1.61 ; H4.1 15.79,3.55 ; 6.31,79.31 JCR1.22 ; JCR1.22 6.31,77.93 ; JCR1.22 7.4,79.31 ; JCR1.22 8.49,78.62 ; JCR1.22 8.49,77.93 ; JCR1.22 6.31,78.62 ; JCR1.22 8.49,79.31 ; JCR1.22 7.4,77.93 ; H2.1 196.44,85.49 ; H2.1 194.5,86.24 ; H2.1 194.5,80.86 ; H2.1 192.56,81.61 ; H2.1 196.44,81.61 ; H2.1 192.56,85.49 ; H2.1 191.81,83.55 ; H2.1 197.19,83.55 ; H7.1 7.5,110.74 ; H7.1 4.81,108.05 ; H7.1 9.44,106.11 ; H7.1 5.56,109.99 ; H7.1 5.56,106.11 ; H7.1 9.44,109.99 ; H7.1 7.5,105.36 ; H7.1 10.19,108.05 ; H10.1 197.05,95.9 ; H10.1 197.05,94.86 ; H10.1 193.95,96.94 ; H10.1 193.95,95.9 ; H10.1 195.5,94.86 ; H10.1 195.5,96.94 ; H10.1 193.95,94.86 ; H10.1 197.05,96.94 ; 230.81,147.55 H6.1 ; H6.1 231.56,149.49 ; H6.1 236.19,147.55 ; H6.1 233.5,150.24 ; H6.1 231.56,145.61 ; H6.1 235.44,149.49 ; H6.1 235.44,145.61 ; H6.1 233.5,144.86 ; H11.1 3.77,96.67 ; H11.1 2.23,95.13 ; H11.1 1.96,95.9 ; H11.1 3,96.94 ; H11.1 4.04,95.9 ; H11.1 3,94.86 ; H11.1 2.23,96.67 ; H11.1 3.77,95.13 ; H8.1 143.84,103.88 ; H8.1 143.1,105.61 ; H8.1 143.84,105.36 ; H8.1 143.1,103.63 ; H8.1 142.36,103.88 ; H8.1 144.09,104.62 ; H8.1 142.11,104.62 ; H8.1 142.36,105.36 ; JNGFF3.18 249.76,112.62 ; JNGFF3.18 249.65,112.22 ; JNGFF3.18 249.65,113.03 ; 41.06,145.61 H5.1 ; H5.1 43,150.24 ; H5.1 40.31,147.55 ; H5.1 41.06,149.49 ; H5.1 45.69,147.55 ; H5.1 44.94,145.61 ; H5.1 44.94,149.49 ; H5.1 43,144.86 ; JUSBC2.B12 7.89,19.31 ; JUSBC2.B12 7.8,18.95 ; JUSBC2.B12 7.45,18.86 ; JUSBC2.B12 7,19.31 ; JUSBC2.B12 7.1,19.66 ; 7,13.71 JUSBC2.B1 ; JUSBC2.B1 7.8,14.06 ; JUSBC2.B1 7.45,14.15 ; JUSBC2.B1 7.1,13.35 ; JCR1.23 8.49,93.02 ; JCR1.23 7.4,92.33 ; JCR1.23 8.49,93.71 ; JCR1.23 6.31,92.33 ; JCR1.23 8.49,92.33 ; JCR1.23 6.31,93.71 ; JCR1.23 6.31,93.02 ; JCR1.23 7.4,93.71 ; H9.1 104.84,104.36 ; H9.1 104.1,102.63 ; H9.1 103.36,104.36 ; H9.1 105.09,103.62 ; H9.1 103.36,102.88 ; H9.1 104.84,102.88 ; H9.1 103.11,103.62 ; H9.1 104.1,104.61 ; JUSBC1.B12 7.89,33.31 ; JUSBC1.B12 7.8,32.95 ; JUSBC1.B12 7.1,33.66 ; JUSBC1.B12 7.45,32.86 ; JUSBC1.B12 7,33.31
  GND4 w0.254: 123.63,102.06 v4(123.56,102.12) ; 161.78,138.11 161.78,138.13 v4(162.2,138.55) ; 13.1,47.86 v15(13.1,47.4) ; v4(125.62,107.7) 125.62,107.72 125.26,107.72 125.22,107.76 v4(124.6,107.76) ; v16(123.09,101.13) 123.44,101.13 v4(123.56,101.01) ; v4(123.56,106.59) 123.77,106.38 v16(123.88,106.38)
  GND4 w0.508: 173.44,114.16 173.84,113.75 173.87,113.75
  VCC w0.203: 7,13.71 JUSBC2.B1 ; JUSBC2.B1 7.25,13.25 ; JUSBC2.B1 7.1,13.35 ; H7.1 9.44,106.11 ; H7.1 4.81,108.05 ; H7.1 10.19,108.05 ; H7.1 5.56,109.99 ; H7.1 9.44,109.99 ; H7.1 5.56,106.11 ; H7.1 7.5,105.36 ; H5.1 44.94,145.61 ; H5.1 44.94,149.49 ; H5.1 41.06,145.61 ; H5.1 43,144.86 ; H5.1 41.06,149.49 ; H5.1 43,150.24 ; H5.1 40.31,147.55 ; H5.1 45.69,147.55 ; H4.1 15.04,5.49 ; H4.1 11.16,5.49 ; H4.1 15.04,1.61 ; H4.1 13.1,0.86 ; H4.1 15.79,3.55 ; H4.1 13.1,6.24 ; H4.1 10.41,3.55 ; H4.1 11.16,1.61
  BOTTOM w0.06: v9(122.99,107.83) 122.97,107.86 PC1102.2
  BOTTOM w0.203: C1292.1 23.82,34.15 23.16,34.81 23.16,35.2 v7(23.63,35.66)
  BOTTOM w0.254: C188.2 235.72,125.71 v9(235.82,125.81) ; CC53.2 v6(131.06,105.11) ; v9(192.68,144.1) 192.89,144.32 C111.2 ; CC26.2 131.9,102.58 v9(131.93,102.61) ; v9(232.24,126.79) C176.2 ; RC98.2 131.08,108.58 v6(130.97,108.69) ; v9(122.83,110.9) v9(122.27,110.9) ; v9(120.31,110.9) v9(120.87,110.9)
  BOTTOM w0.305: v9(132.7,102.42) 132.37,102.09 CC135.2 ; v17(127.27,101.68) PC1139.2 v17(127.27,100.36) ; CC131.2 133.12,106.9 v9(133.1,106.92) ; C183.2 v9(234.25,119.77) ; CC132.2 132.8,101.38 v9(132.98,101.2) ; PR612.2 151.07,105.56 v7(151.09,105.57) ; v7(215.09,144.13) 215.28,143.94 JSPI1.21 ; v9(9.43,31.8) C1359.1
  BOTTOM w0.356: C1287.1 21.68,33.45 v7(21.68,33.06) 21.52,32.91 C1284.2 ; v7(28.18,33.71) 28.15,33.71 27.6,34.26 C1323.1 ; C1325.1 26.73,35.68 C1286.2 26.12,35.59 C1295.1
  BOTTOM w0.381: v7(24.93,32.41) 24.98,32.37 C1299.1 ; v9(134.02,106.05) 133.62,106.05 133.43,105.86 133.42,105.86 133.26,105.7 CC36.2 ; C1315.1 25.66,36.4 v7(25.58,36.31) 25.55,36.28 C1295.1 25.55,35.05 v7(25.58,35.01) ; CC33.2 134.77,110.02 129.48,110.02 v9(129.27,109.8) ; C1324.1 28.09,32.51 v7(28.18,32.41) ; C1293.1 25.65,33.71 v7(26.23,33.71) 26.23,34.18 C1296.1 ; R173.1 v9(233.53,115.81) ; C1407.1 C1406.1 20.42,41.27 v7(20.3,41.38)
  BOTTOM w0.508: 42.28,130.84 v9(43.97,130.84) ; v9(231.25,140.04) JSER.20 ; JSER.19 v9(218.55,143.34) ; C124.2 v6(142.02,136.69)
  vias: v1(6.08,54.49) v2(5.2,42.92) v2(6.03,42.9) v2(6.97,42.87) v2(7.98,42.53) v2(8.62,38.62) v2(8.69,41.89) v2(8.99,39.11) v2(9.15,40.76) v2(9.18,39.76) v2(10.56,12.25) v2(10.79,20.28) v2(12.45,109.29) v2(12.45,108.02) v2(20.95,16.44) v2(34.84,19.68) v2(34.84,18.99) v2(37.64,21.46) v2(37.81,60.78) v2(38.21,20.18) v2(38.53,71.18) v2(38.53,69.27) v2(38.53,67.37) v2(38.53,65.46) v2(38.7,60.97) v2(39.45,72.21) v2(39.45,66.81) v2(39.59,64.73) v2(39.68,70.44) v2(40.72,62.72) v2(61.63,133.33) v2(62.79,138.6) v2(71.99,106.38) v2(72.42,110.35) v2(75.55,108.86) v2(83.67,116.37) v2(84.31,105.19) v2(84.44,116.37) v2(85.07,105.19) v2(108.99,134.7) v2(109.87,135.51) v2(110.45,135.51) v2(117.42,136.61) v2(118.98,136.61) v2(119.78,136.58) v2(123.96,137.04) v2(126.23,135.24) v2(127.44,135.24) v2(128.64,135.23) v2(143.62,138.95) v2(144.89,138.95) v2(146.16,138.95) v2(147.53,138.93) v2(148.75,138.95) v2(199.29,83.73) v2(204.32,115.44) v2(233.31,121.75) v2(233.36,136.88) v2(242.56,150.21) v2(243.83,150.21) v2(245.1,150.21) v3(49.54,87.16) v3(103.84,129.19) v3(105.71,129.15) v3(107.82,129.85) v3(145.93,129.93) v4(1.78,74.3) v4(1.78,72.27) v4(1.78,70.24) v4(1.78,68.21) v4(1.78,66.18) v4(1.78,64.14) v4(4.22,58.25) v4(4.22,56.98) v4(4.22,55.71) v4(4.22,54.44) v4(4.22,53.17) v4(4.22,51.9) v4(4.22,50.63) v4(4.22,49.36) v4(4.22,48.09) v4(4.22,46.82) v4(5.62,42.96) v4(6.52,42.97) v4(7.45,42.83) v4(7.79,69.13) v4(7.88,67.34) v4(7.97,38.01) v4(8.4,42.27) v4(8.92,60.04) v4(9.04,65.13) v4(9.07,41.27) v4(9.09,38.65) v4(9.26,40.23) v4(9.38,39.37) v4(9.37,38.16) v4(9.95,63.33) v4(10.2,71.36) v4(10.57,68.5) v4(12.05,109.61) v4(12.05,108.34) v4(12.13,71.01) v4(13.19,63.36) v4(13.74,78) v4(13.68,76) v4(13.68,73.69) v4(13.7,67.25) v4(14.64,97.84) v4(14.83,99.75) v4(14.84,70.89) v4(15.27,76.56) v4(15.42,77.94) v4(15.49,98.8) v4(15.93,96.97) v4(15.89,74.61) v4(16.08,95.96) v4(16.29,19.34) v4(17.11,70.24) v4(17.19,66.04) v4(17.53,68.3) v4(18.5,96.68) v4(19.7,62.53) v4(20.83,35.34) v4(20.89,38.57) v4(21.02,37.08) v4(21.7,60.14) v4(21.69,35.01) v4(22.69,60.84) v4(22.84,42.12) v4(22.96,39.54) v4(23.63,39.56) v4(23.7,31) v4(23.93,43.44) v4(24.05,32.47) v4(24.34,56.56) v4(24.64,58.15) v4(24.55,39.21) v4(24.62,30.23) v4(24.7,55.24) v4(24.68,30.97) v4(25.13,31.12) v4(25.23,30.27) v4(25.69,41.13) v4(25.76,64.23) v4(25.93,31.33) v4(25.89,30.41) v4(26.09,32.29) v4(26.47,23.22) v4(26.9,42.17) v4(26.85,38.95) v4(27.54,39.56) v4(27.5,31.4) v4(27.84,23.24) v4(27.87,31.91) v4(28.17,45.37) v4(28.66,42.12) v4(28.78,23.31) v4(29.44,36.99) v4(29.47,39.58) v4(29.55,38.92) v4(29.47,38.26) v4(29.52,34.3) v4(29.5,33.64) v4(29.48,33.17) v4(31.41,19.78) v4(31.69,17.75) v4(33.01,20.2) v4(33.32,22.45) v4(33.92,17.94) v4(34.58,22.47) v4(35.49,20.48) v4(37.29,20.53) v4(37.53,44.42) v4(37.92,47) v4(38.02,33.08) v4(38.06,59.95) v4(38.17,68.35) v4(38.25,63.14) v4(38.18,42.62) v4(38.4,74) v4(38.37,45.4) v4(38.56,70.4) v4(38.6,54.55) v4(38.67,72.21) v4(38.7,46.01) v4(38.72,43.76) v4(38.84,29.59) v4(39.19,37.03) v4(39.22,23) v4(39.41,74.79) v4(39.44,65.83) v4(39.41,42.24) v4(39.43,34.96) v4(39.45,62.95) v4(39.53,61.39) v4(39.47,59.79) v4(39.45,58.36) v4(39.54,56.56) v4(39.64,71.34) v4(39.58,27.36) v4(39.68,100.41) v4(39.76,54.68) v4(39.85,25.43) v4(39.91,68.79) v4(39.96,73.03) v4(40,43.72) v4(40.01,29.7) v4(39.96,23.73) v4(40.02,21.01) v4(40.32,37.31) v4(41.52,111.13) v4(49.94,86.04) v4(50.6,86.06) v4(52.61,86.09) v4(53.91,86.09) v4(76.23,134.73) v4(79.55,131.38) v4(80.74,131.21) v4(81.16,133.15) v4(92.2,124.51) v4(92.35,78.84) v4(94.89,78.84) v4(97.43,78.84) v4(97.85,129.74) v4(99.4,120.96) v4(99.97,78.84) v4(102.51,78.84) v4(104.71,126.89) v4(105.05,78.84) v4(106.45,127.14) v4(107.59,78.84) v4(108.57,127.15) v4(110.13,78.84) v4(112.67,78.84) v4(115.21,78.84) v4(118.12,95.02) v4(119.23,93.91) v4(119.5,87.84) v4(120.68,93.66) v4(121.61,109.41) v4(122.38,101) v4(122.64,106.64) v4(122.64,105.39) v4(122.66,107.83) v4(122.69,104.22) v4(122.69,102.27) v4(123.56,105.48) v4(123.56,104.36) v4(123.67,107.73) v4(124.26,90.43) v4(124.43,91.93) v4(124.66,104.36) v4(125.1,93.51) v4(125.44,109.32) v4(125.63,104.36) v4(126.35,92.17) v4(127.88,135) v4(131.35,103.81) v4(131.5,106.74) v4(140.33,119.08) v4(141.43,117.97) v4(141.5,120.11) v4(143.1,138.92) v4(144.37,138.92) v4(145.66,138.93) v4(147.12,138.93) v4(147.8,119.73) v4(148.37,138.93) v4(149.36,99.16) v4(150.5,127.57) v4(151.71,127.58) v4(152.89,127.52) v4(153.75,136.86) v4(154.03,131.4) v4(197.34,82.28) v4(197.42,85.3) v4(198.42,81.52) v4(198.55,85.92) v4(198.46,83.17) v4(198.6,84.68) v4(199.59,86.72) v4(199.7,85.49) v4(199.84,88.01) v4(199.8,84.17) v4(199.94,116.57) v4(200.44,101.8) v4(200.43,100.49) v4(200.51,99.39) v4(200.64,88.78) v4(200.65,87.45) v4(200.69,86.24) v4(200.77,117.79) v4(200.77,84.98) v4(200.84,83.75) v4(201.21,116.75) v4(201.19,102.62) v4(201.85,82.65) v4(202.57,117.78) v4(202.76,116.92) v4(203.88,116.61) v4(234.51,106.46) v4(236.87,106.42) v4(238.74,106.42) v4(240.43,106.38) v4(241.9,106.38) v4(243.1,149.7) v4(243.91,106.42) v4(244.21,109.3) v4(244.37,149.7) v4(244.48,143.34) v4(245.14,146.02) v4(245.45,147.9) v4(245.64,149.7) v4(245.75,108.17) v4(246.21,106.4) v4(246.48,143.33) v4(246.92,112.62) v4(247.55,112.24) v4(247.55,108.77) v4(250.12,105.8) v4(251.01,143.34) v4(251.14,137.09) v4(251.12,134.81) v4(251.49,130.5) v4(251.91,138.98) v4(252.11,105.61) v4(252.32,133.74) v4(252.7,135.48) v4(252.69,132.04) v4(253.49,143.07) v4(253.69,137.16) v4(253.88,140.76) v4(254.49,135.59) v4(254.51,132.04) v4(254.69,133.51) v4(254.84,130.25) v5(19.96,95.96) v5(19.97,89.31) v5(20.91,96.38) v5(21.65,96.36) v5(22.66,89.29) v5(23.32,96.38) v5(24.02,88.88) v5(24.14,96.38) v5(25.7,88.92) v5(27.54,90.25) v5(27.72,90.66) v5(29.81,91.32) v5(29.78,90.11) v5(36.61,106.5) v5(37.23,106.08) v5(40.43,119.5) v5(40.43,115.53) v5(40.42,114.19) v5(40.42,112.83) v5(40.47,120.72) v5(40.51,118.16) v5(40.46,116.71) v5(41.1,114.96) v5(41.1,113.48) v5(41.23,119.96) v5(41.24,118.79) v5(41.26,117.29) v5(41.27,116.09) v5(41.99,114.7) v5(42.04,113.94) v5(41.99,113.09) v5(91.08,78.84) v5(93.62,78.84) v5(96.16,78.84) v5(98.7,78.84) v5(101.24,78.84) v5(103.78,78.84) v5(104.02,127.61) v5(105.48,127.21) v5(106.28,127.95) v5(106.32,78.84) v5(107.21,126.93) v5(107.8,127.67) v5(108.86,78.84) v5(111.4,78.84) v5(111.59,125.37) v5(113.05,126.55) v5(113.39,123.68) v5(113.61,125.4) v5(113.94,78.84) v5(114.61,123.35) v5(114.87,126.41) v5(115.68,124.38) v5(116.08,125.41) v5(116.21,126.45) v5(116.59,124.25) v5(116.96,122.87) v5(117.84,123.81) v5(117.82,119.73) v5(118.56,124.37) v5(118.75,123.07) v5(119.88,121.28) v5(119.91,117.64) v5(120.15,124.21) v5(121.79,107.72) v5(121.79,101.01) v5(122.31,132.02) v5(124.35,81.01) v5(124.81,81.57) v5(125.26,80.88) v5(125.52,81.72) v5(125.94,82.27) v5(127.05,82.08) v5(127.9,81.32) v5(129.72,104.69) v5(130.53,80.82) v5(132.76,81.39) v5(135.07,81.87) v5(135.69,83.95) v5(137.08,83.87) v5(137.88,86.03) v5(138.54,86.53) v5(138.57,85.5) v5(182.07,90.8) v5(182.28,89.73) v5(184.22,90.93) v5(184.5,89.58) v5(186.14,90.67) v5(186.57,89.63) v5(187.51,90.71) v5(187.74,92.34) v5(188.5,93.12) v5(188.55,91.51) v5(189.74,94.05) v5(192.34,91.71) v5(193.22,93.37) v5(193.77,91.23) v5(194.01,92.76) v5(194.66,93.39) v5(195.87,93.21) v5(195.9,91.78) v6(29.08,25.78) v6(29.86,26.34) v6(30.19,35.91) v6(30.19,35.34) v6(30.84,26.42) v6(31.46,26.46) v6(32.07,26.48) v6(32.62,26.5) v6(32.96,26.98) v6(33.45,26.47) v6(33.45,25.78) v6(33.52,21.73) v6(33.74,28.2) v6(33.95,26.96) v6(34.32,25.83) v6(34.36,26.45) v6(34.39,19.71) v6(34.7,20.95) v6(35.24,26.45) v6(35.21,25.79) v6(35.29,27.45) v6(36.04,27.78) v6(36.07,25.79) v6(36.25,26.56) v6(36.39,20.47) v6(36.47,21.73) v6(36.79,27.58) v6(37.31,21.52) v6(39.77,24.84) v6(39.8,22.45) v6(46.33,138.04) v6(46.33,136.79) v6(145.57,137.19) v6(206.16,148.8) v6(241.43,143.09) v6(242.47,144.08) v7(1.79,98.37) v7(1.8,97.52) v7(1.85,94.32) v7(1.8,92.68) v7(1.8,90.65) v7(1.78,88.96) v7(1.8,87.6) v7(1.8,85.73) v7(1.8,83.65) v7(1.8,82.52) v7(1.8,80.84) v7(1.81,78.7) v7(1.78,77.69) v7(1.81,63.61) v7(1.8,61.62) v7(1.8,60.55) v7(1.87,99.7) v7(3.13,110.38) v7(3.13,105.65) v7(3.13,104.3) v7(3.11,103.03) v7(3.11,100.96) v7(3.08,61.57) v7(3.24,111.32) v7(3.22,59.2) v7(3.35,108.24) v7(3.54,80.68) v7(3.54,76.11) v7(4.2,93.29) v7(4.26,43.04) v7(4.46,108.06) v7(4.76,111.29) v7(5.33,110.22) v7(5.31,105.86) v7(5.44,98.37) v7(6.04,98.36) v7(6.38,111.36) v7(6.84,80.55) v7(6.84,75.98) v7(7.5,111.18) v7(7.52,104.92) v7(7.74,0.5) v7(8.19,111.36) v7(9.72,110.22) v7(9.7,105.86) v7(9.73,19.22) v7(9.8,17.9) v7(10.06,3.54) v7(10.23,29.28) v7(10.34,27.84) v7(10.38,31.69) v7(10.52,111.1) v7(10.5,33.38) v7(10.47,15.24) v7(10.53,13.98) v7(10.7,108.02) v7(10.93,5.74) v7(10.92,1.35) v7(11.49,111.39) v7(11.79,50.71) v7(12.27,105.42) v7(12.38,111.26) v7(12.35,107.04) v7(13.1,6.57) v7(13.09,0.5) v7(15.12,20.61) v7(15.28,5.72) v7(15.28,1.35) v7(16.14,3.54) v7(16.57,33.23) v7(16.76,34.78) v7(16.78,33.75) v7(17.13,32.05) v7(17.24,35.83) v7(17.27,36.85) v7(18.05,37.81) v7(18.42,39.37) v7(19.21,31.33) v7(23.87,51.73) v7(23.95,50.45) v7(24.19,53.48) v7(24.55,50.45) v7(25.13,50.45) v7(25.19,53.49) v7(25.38,44.2) v7(25.76,53.48) v7(26.08,50.52) v7(26.41,45.04) v7(26.77,80.64) v7(26.77,79.5) v7(26.75,78.61) v7(27.54,20.73) v7(27.54,18.83) v7(27.54,16.8) v7(27.78,80.64) v7(27.78,79.5) v7(27.77,78.61) v7(27.84,42.12) v7(28.8,80.64) v7(29.18,44.38) v7(29.57,20.73) v7(29.57,18.83) v7(29.57,16.8) v7(31.48,20.73) v7(31.48,18.83) v7(31.48,16.8) v7(34.83,110.7) v7(34.91,32.4) v7(35.25,106.99) v7(35.21,106.15) v7(35.82,111.23) v7(35.91,107.79) v7(35.92,86.01) v7(37.14,111.23) v7(38.14,31.66) v7(38.2,34.35) v7(38.35,77.58) v7(38.28,20.96) v7(38.6,79.88) v7(38.82,111.31) v7(38.86,20.29) v7(39.05,24.07) v7(39.1,73.31) v7(39.1,69.25) v7(39.25,21.94) v7(39.24,20.96) v7(39.47,75.8) v7(39.58,150.33) v7(39.55,148.45) v7(39.58,146.59) v7(39.58,145.09) v7(39.58,143.98) v7(39.58,142.98) v7(39.62,20.28) v7(39.83,147.54) v7(39.82,141.24) v7(39.79,140.24) v7(39.79,139.1) v7(39.79,137.7) v7(39.79,136.56) v7(39.79,135.16) v7(39.79,133.89) v7(39.79,132.62) v7(39.79,131.35) v7(39.79,130.08) v7(39.79,128.81) v7(39.79,127.54) v7(39.79,126.27) v7(39.79,125) v7(39.79,123.73) v7(39.79,122.46) v7(39.79,121.32) v7(39.79,119.92) v7(39.79,118.78) v7(39.79,117.38) v7(39.79,116.11) v7(39.79,114.84) v7(39.79,113.57) v7(39.79,112.3) v7(39.88,67.85) v7(40.04,81.25) v7(40.49,57.31) v7(40.49,55.51) v7(40.49,53.5) v7(40.49,51.6) v7(40.49,49.69) v7(40.49,47.79) v7(40.49,45.88) v7(40.49,43.98) v7(40.49,42.07) v7(40.49,40.17) v7(40.49,38.26) v7(40.49,36.36) v7(40.49,34.45) v7(40.49,32.55) v7(40.49,30.64) v7(40.49,28.74) v7(40.49,26.83) v7(40.49,24.93) v7(40.49,23.02) v7(40.52,21.8) v7(40.49,20.26) v7(40.62,74.71) v7(40.7,149.82) v7(40.82,145.36) v7(40.76,73.35) v7(40.76,71.45) v7(40.76,69.54) v7(40.76,67.64) v7(40.76,65.73) v7(40.76,63.83) v7(40.76,61.92) v7(40.76,60.88) v7(42.06,81.31) v7(43.01,144.34) v7(43.53,80.56) v7(44.6,78.9) v7(44.81,150.25) v7(44.94,105.32) v7(44.94,104.73) v7(44.94,104.15) v7(44.96,103.55) v7(45.19,145.35) v7(45.36,149.79) v7(45.51,105.33) v7(45.51,104.75) v7(45.51,104.16) v7(46.15,147.53) v7(46.29,150.25) v7(46.56,78.84) v7(47.12,150.25) v7(48.11,150.17) v7(48.47,78.84) v7(49.99,105.47) v7(50.37,78.84) v7(50.58,105.47) v7(50.83,118.32) v7(50.81,117.14) v7(50.96,116.2) v7(51.15,150.13) v7(51.16,115.15) v7(51.3,115.73) v7(51.29,91.35) v7(51.29,90.13) v7(51.39,118.32) v7(51.37,117.14) v7(51.73,114.98) v7(52.18,150.15) v7(52.28,78.84) v7(52.43,91.35) v7(52.43,90.13) v7(53.08,102.95) v7(53.57,150.15) v7(53.57,91.35) v7(53.57,90.13) v7(54.18,102.98) v7(54.18,78.84) v7(54.59,91.35) v7(54.59,90.13) v7(54.72,150.15) v7(55.48,102.98) v7(55.61,91.35) v7(55.61,90.13) v7(55.99,150.15) v7(56.09,78.84) v7(56.62,91.35) v7(56.62,90.13) v7(56.7,102.98) v7(56.79,126.87) v7(57.13,126.39) v7(57.26,150.15) v7(57.64,91.35) v7(57.89,102.98) v7(57.99,78.84) v7(58.53,150.15) v7(59.66,116.37) v7(59.66,115.78) v7(59.66,115.2) v7(59.66,114.61) v7(59.66,114.03) v7(59.8,150.15) v7(59.85,119.43) v7(59.9,78.84) v7(60.13,121.31) v7(60.22,116.37) v7(60.22,115.78) v7(60.22,115.2) v7(60.22,114.61) v7(60.22,114.03) v7(60.33,119.72) v7(60.55,121.69) v7(60.59,104.28) v7(61.07,150.15) v7(61.4,131.14) v7(61.41,130.56) v7(61.47,127.3) v7(61.51,126.73) v7(61.8,78.84) v7(62.34,150.15) v7(63.71,78.84) v7(64.88,150.15) v7(65.61,78.84) v7(66.15,150.15) v7(67.42,150.15) v7(67.52,78.84) v7(68.69,150.15) v7(69.16,147.26) v7(69.18,146.19) v7(69.42,78.84) v7(69.7,146.72) v7(69.96,150.15) v7(70.26,147.26) v7(70.25,146.17) v7(71.23,150.15) v7(71.33,78.84) v7(72.5,150.15) v7(73.23,78.84) v7(73.77,150.15) v7(74.85,102.7) v7(75.04,150.15) v7(75.14,78.84) v7(75.25,96.97) v7(75.41,102.7) v7(75.72,96.38) v7(75.86,96.95) v7(76.02,102.7) v7(76.31,150.15) v7(76.49,96.95) v7(76.57,102.7) v7(77.04,78.84) v7(77.36,88.77) v7(77.58,150.15) v7(78.45,106.87) v7(78.85,150.15) v7(78.95,78.84) v7(79.03,106.87) v7(79.61,111.16) v7(79.61,106.9) v7(80.12,150.15) v7(80.12,148.88) v7(80.12,147.61) v7(80.12,146.21) v7(80.12,145.07) v7(80.12,143.8) v7(80.12,142.53) v7(80.12,141.38) v7(80.12,139.94) v7(80.17,111.16) v7(80.22,106.88) v7(80.44,123.9) v7(80.38,123.34) v7(80.42,121.27) v7(80.58,138.84) v7(80.94,123.34) v7(80.85,112.23) v7(80.85,111.67) v7(80.85,111.03) v7(80.85,78.84) v7(80.99,123.9) v7(80.98,121.28) v7(81.13,92.74) v7(81.41,122.27) v7(81.41,112.23) v7(81.41,111.67) v7(81.41,111.03) v7(81.6,123.83) v7(81.55,123.27) v7(81.67,121.75) v7(81.69,92.74) v7(81.82,122.72) v7(82.02,138.72) v7(81.98,124.42) v7(81.97,112.23) v7(81.97,111.67) v7(82.11,123.27) v7(82.16,123.85) v7(82.39,124.85) v7(82.38,122.72) v7(82.35,92.74) v7(82.51,112.61) v7(82.53,112.06) v7(82.53,111.5) v7(82.72,123.86) v7(82.68,123.27) v7(82.82,124.42) v7(82.76,78.84) v7(82.91,92.74) v7(83.06,112.61) v7(83.09,112.06) v7(83.09,111.5) v7(83.24,123.27) v7(83.2,122.63) v7(83.29,138.72) v7(83.29,123.86) v7(83.5,92.74) v7(83.62,112.61) v7(83.65,112.06) v7(83.65,111.5) v7(83.8,123.27) v7(83.78,122.53) v7(83.86,124.07) v7(84.05,92.74) v7(84.18,112.61) v7(84.21,112.06) v7(84.21,111.5) v7(84.35,123.76) v7(84.36,123.19) v7(84.36,122.56) v7(84.56,138.72) v7(84.74,112.61) v7(84.66,78.84) v7(84.77,112.06) v7(84.77,111.5) v7(84.77,92.74) v7(84.92,123.22) v7(84.94,122.56) v7(85.3,112.61) v7(85.32,112.06) v7(85.32,111.5) v7(85.32,92.74) v7(85.83,138.72) v7(85.86,112.61) v7(85.88,112.06) v7(85.88,111.5) v7(86.06,92.74) v7(86.57,78.84) v7(87.1,138.72) v7(88.37,138.72) v7(88.47,78.84) v7(89.39,104.05) v7(89.39,103.49) v7(89.64,138.72) v7(90.15,126.65) v7(90.38,78.84) v7(90.79,127.29) v7(90.91,138.72) v7(91.24,103.28) v7(91.42,126.65) v7(91.8,103.28) v7(92.18,138.72) v7(93.45,138.72) v7(93.78,104.07) v7(93.78,103.51) v7(94.72,138.72) v7(94.72,121.78) v7(94.72,121.19) v7(94.72,120.63) v7(94.72,120.07) v7(94.72,119.49) v7(94.72,118.91) v7(94.72,118.35) v7(94.72,117.76) v7(95.99,138.72) v7(97.26,138.72) v7(98.53,138.72) v7(99.8,138.72) v7(101.07,138.72) v7(102.34,138.72) v7(103.61,138.72) v7(104.78,134.4) v7(104.88,138.72) v7(106.15,138.72) v7(107.42,138.72) v7(107.88,133.56) v7(108.69,138.72) v7(109.96,138.72) v7(111.23,138.72) v7(111.49,102.29) v7(112.25,101.35) v7(112.5,138.72) v7(113.77,138.72) v7(115.04,138.72) v7(116.31,138.72) v7(116.48,78.84) v7(117.58,138.72) v7(118.85,138.72) v7(119.02,78.84) v7(120.12,138.72) v7(121.39,138.72) v7(121.56,78.84) v7(122.66,138.72) v7(123.93,138.72) v7(124.1,78.84) v7(125.2,138.72) v7(126.47,138.72) v7(126.64,78.84) v7(127.74,138.72) v7(129.01,138.72) v7(129.18,78.84) v7(130.28,138.72) v7(131.68,138.72) v7(131.68,137.57) v7(131.68,136.3) v7(131.68,135.03) v7(131.72,78.84) v7(131.97,133.61) v7(133.08,133.05) v7(134.35,133.05) v7(134.26,78.84) v7(135.62,133.05) v7(135.96,79.17) v7(136.89,133.05) v7(137.06,80.93) v7(138.16,133.05) v7(139.05,81.55) v7(139.13,133.17) v7(140.01,138.87) v7(140.01,137.6) v7(140.01,136.33) v7(140.01,135.06) v7(139.99,133.92) v7(140.7,138.87) v7(141.15,80.84) v7(141.97,138.87) v7(142.09,79.68) v7(142.74,79.14) v7(143.74,79.93) v7(143.76,81.81) v7(144.94,83.36) v7(147.48,83.36) v7(149.33,138.87) v7(150.02,83.36) v7(150.6,138.87) v7(150.58,126.45) v7(150.96,85.02) v7(151.09,109.51) v7(151.09,108.49) v7(151.09,107.48) v7(151.09,104.55) v7(151.71,126.42) v7(151.87,138.87) v7(152.46,126.39) v7(152.88,85.82) v7(153.02,126.39) v7(153.14,138.87) v7(153.57,126.39) v7(154.41,138.87) v7(155.2,85.82) v7(155.33,138.88) v7(156.42,138.88) v7(157.69,138.88) v7(157.74,85.82) v7(158.96,138.88) v7(159.34,85.5) v7(159.85,106.22) v7(159.81,105.66) v7(160.74,84.04) v7(160.75,105.71) v7(161.4,105.74) v7(161.61,105.2) v7(162.19,83.32) v7(162.44,118.27) v7(162.74,138.64) v7(163.43,138.67) v7(164.7,138.67) v7(164.73,83.32) v7(165.97,138.67) v7(167.24,138.67) v7(167.27,83.32) v7(168.51,138.67) v7(169.78,138.67) v7(169.81,83.32) v7(171.05,138.67) v7(172.32,138.67) v7(172.35,83.32) v7(173.59,138.67) v7(173.7,82.27) v7(173.7,80.37) v7(174.86,138.67) v7(175.46,80.33) v7(175.9,83.47) v7(176.13,138.67) v7(177.4,138.67) v7(178,80.33) v7(178.09,82.2) v7(178.67,138.67) v7(179.94,138.67) v7(180.22,83.45) v7(180.41,117.99) v7(180.41,117.42) v7(180.54,80.33) v7(180.97,117.97) v7(180.98,117.37) v7(181.44,134.63) v7(181.49,117.74) v7(182,134.65) v7(182.28,82.3) v7(182.56,134.65) v7(183.04,138.64) v7(183.08,80.33) v7(185.15,132.9) v7(185.2,138.64) v7(185.4,132.39) v7(185.5,83.4) v7(185.62,80.33) v7(185.72,132.93) v7(185.97,132.42) v7(186.26,138.84) v7(186.29,132.94) v7(186.54,132.43) v7(186.85,132.94) v7(186.9,150.17) v7(186.9,148.9) v7(186.9,147.63) v7(186.9,146.36) v7(186.87,145.09) v7(186.87,143.82) v7(186.9,142.55) v7(186.9,141.28) v7(186.9,140.01) v7(187.17,132.44) v7(187.69,82.35) v7(187.86,150.17) v7(188.16,80.33) v7(189.13,150.17) v7(189.1,114.35) v7(189.26,83.52) v7(189.74,114.33) v7(190.15,114.92) v7(190.4,150.17) v7(190.67,114.44) v7(190.7,80.33) v7(191.47,83.55) v7(191.67,150.17) v7(192.32,85.73) v7(192.35,81.34) v7(192.94,150.17) v7(193.24,80.33) v7(194.14,130.2) v7(194.21,150.17) v7(194.51,86.58) v7(194.48,80.5) v7(195.48,150.17) v7(195.66,126.53) v7(195.78,80.33) v7(196.68,85.73) v7(196.67,81.34) v7(196.75,150.17) v7(197.03,126.5) v7(197.54,83.55) v7(198.02,150.17) v7(197.97,134.53) v7(197.97,133.13) v7(197.97,131.73) v7(198.32,80.33) v7(199.29,150.17) v7(199.37,134.53) v7(199.38,133.12) v7(199.37,131.73) v7(200.56,150.17) v7(200.77,134.53) v7(200.77,133.13) v7(200.77,131.73) v7(200.86,80.33) v7(201.63,99.14) v7(201.83,150.17) v7(202.52,99.91) v7(202.55,98.69) v7(203.1,150.17) v7(203.05,123.1) v7(203.05,122.08) v7(203.05,121.06) v7(203.05,120.05) v7(203.08,104.63) v7(203.4,80.33) v7(204.04,104.12) v7(204.07,122.08) v7(204.07,121.06) v7(204.07,120.05) v7(204.37,150.17) v7(205.09,123.1) v7(205.09,122.08) v7(205.09,121.06) v7(205.09,120.05) v7(205.64,150.17) v7(205.94,80.33) v7(206.1,122.08) v7(206.1,121.06) v7(206.1,120.05) v7(206.46,150.17) v7(207.42,147.89) v7(207.55,104.12) v7(207.73,150.17) v7(208.65,105.01) v7(209,150.17) v7(209.86,147.96) v7(210.23,105.01) v7(210.27,150.17) v7(211.54,150.17) v7(212.81,150.17) v7(212.77,105.01) v7(214.08,150.17) v7(215.25,125.51) v7(215.35,150.17) v7(215.51,144.5) v7(216.26,125.51) v7(216.62,150.17) v7(217.89,150.17) v7(219.16,150.17) v7(220.43,150.17) v7(221.7,150.17) v7(222.97,150.17) v7(224.24,150.17) v7(225.51,150.17) v7(226.78,150.17) v7(228.05,150.17) v7(229.32,150.17) v7(230.46,147.56) v7(231.32,149.74) v7(231.31,145.35) v7(233.48,144.51) v7(235.67,149.77) v7(235.71,145.36) v7(236.54,147.52) v7(238.21,150.17) v7(239.25,150.2) v7(240.52,150.2) v7(241.51,150.17) v7(243.17,144.08) v7(243.25,105.01) v7(243.94,105) v7(245.79,105.01) v7(246.01,150.17) v7(248.09,105.06) v7(250.87,105.01) v7(251.05,106.14) v7(253.19,105.04) v7(255.76,143.8) v7(255.76,142.53) v7(255.76,141.26) v7(255.76,139.99) v7(255.76,138.72) v7(255.76,137.45) v7(255.76,136.18) v7(255.76,134.91) v7(255.76,133.64) v7(255.76,132.37) v7(255.76,131.1) v8(22.04,93.51) v8(22.05,92.12) v8(22.5,92.88) v8(22.61,91.36) v8(22.89,93.51) v8(23.15,92.15) v8(23.72,92.55) v8(24.06,93.52) v8(24.43,91.56) v8(24.7,92.6) v8(25.19,93.49) v8(25.51,92.9) v8(25.57,91.98) v8(25.94,93.52) v8(27.58,93.77) v9(1.7,75.32) v9(1.7,73.29) v9(1.7,71.26) v9(1.7,69.22) v9(1.7,67.19) v9(1.7,65.16) v9(1.7,63.13) v9(4.16,57.62) v9(4.16,56.35) v9(4.16,55.08) v9(4.16,53.81) v9(4.16,52.54) v9(4.16,51.27) v9(4.16,50) v9(4.16,48.73) v9(4.16,47.46) v9(4.21,44.14) v9(9.23,17.72) v9(9.23,17.15) v9(9.47,52.12) v9(10.37,24.77) v9(10.61,36.16) v9(11.33,24.77) v9(11.57,36.16) v9(11.73,32.17) v9(11.78,22.89) v9(12,29.83) v9(12.36,31.41) v9(12.45,109.93) v9(12.45,108.66) v9(12.45,37.18) v9(12.64,29.06) v9(12.77,22.89) v9(13.18,24.77) v9(13.44,53.67) v9(13.41,37.18) v9(14.17,24.77) v9(14.78,23.39) v9(15.77,23.39) v9(17,84.36) v9(17.65,41.1) v9(18.42,76.89) v9(19.86,36.27) v9(20.02,33.9) v9(20.09,32.28) v9(20.09,31.71) v9(20.43,36.27) v9(20.59,33.9) v9(20.81,72.88) v9(21,36.27) v9(21.1,49.2) v9(21.16,33.9) v9(22.7,50.49) v9(22.71,40.74) v9(22.76,85.58) v9(23.03,36.5) v9(22.97,27.94) v9(23.16,37.09) v9(23.6,40.74) v9(24.33,40.67) v9(24.33,40.1) v9(24.87,30.56) v9(25.52,30.56) v9(25.6,54.52) v9(29.44,24.76) v9(29.7,21.97) v9(29.96,33.71) v9(30.33,24.76) v9(30.66,33.97) v9(30.93,34.58) v9(30.88,22) v9(31.22,24.76) v9(32.11,24.76) v9(33,24.76) v9(33.89,24.76) v9(34.78,24.76) v9(35.67,24.76) v9(38.41,109.81) v9(50.31,89.57) v9(54.84,94.52) v9(91.08,78.84) v9(93.62,78.84) v9(94.48,131.42) v9(95.14,130.16) v9(95.4,127.17) v9(96.03,126.11) v9(96.16,78.84) v9(98.7,78.84) v9(99.4,129.28) v9(99.74,125.8) v9(101.24,78.84) v9(103.78,78.84) v9(106.32,78.84) v9(108.05,86.07) v9(108.86,78.84) v9(109.55,91.8) v9(109.55,86.07) v9(111.05,91.42) v9(111.05,86.07) v9(111.4,78.84) v9(112.55,91.8) v9(112.55,86.07) v9(113.94,78.84) v9(114.05,91.47) v9(114.05,86.07) v9(115.26,100.87) v9(115.55,91.8) v9(115.55,86.07) v9(117.05,91.8) v9(117.05,86.07) v9(118.45,107.83) v9(118.42,106.62) v9(118.45,104.14) v9(118.52,130.87) v9(118.85,109.61) v9(119.01,107.83) v9(119.01,106.62) v9(118.98,105.35) v9(119.03,104.14) v9(119.06,100.96) v9(119.46,109.65) v9(119.61,110.92) v9(119.56,107.83) v9(119.56,105.34) v9(119.59,104.14) v9(119.61,100.96) v9(120.02,99.49) v9(120.05,91.8) v9(120.05,86.07) v9(120.07,109.61) v9(120.12,105.34) v9(120.12,102.23) v9(120.17,104.14) v9(120.63,99.49) v9(120.68,106.64) v9(120.68,105.34) v9(120.73,104.12) v9(120.76,107.83) v9(120.78,102.23) v9(120.76,100.97) v9(121.24,106.64) v9(121.24,105.34) v9(121.24,102.23) v9(121.24,99.49) v9(121.29,109.61) v9(121.29,104.12) v9(121.8,106.64) v9(121.8,105.34) v9(121.9,109.61) v9(121.88,107.83) v9(121.85,104.12) v9(121.9,102.23) v9(121.93,100.97) v9(121.85,99.49) v9(122.33,107.83) v9(122.31,106.64) v9(122.31,105.39) v9(122.36,104.17) v9(122.36,102.23) v9(122.46,99.49) v9(122.55,91.8) v9(122.97,106.64) v9(122.97,105.39) v9(123.02,102.23) v9(123.07,99.49) v9(123.5,130.28) v9(123.73,109.61) v9(123.68,99.49) v9(124.22,107.67) v9(124.23,106.56) v9(124.21,105.42) v9(124.21,103.16) v9(124.19,102.04) v9(124.26,104.28) v9(124.3,100.81) v9(124.29,99.49) v9(124.52,110.85) v9(124.92,109.61) v9(124.87,105.39) v9(124.87,101.96) v9(125.56,110.87) v9(126.02,108.45) v9(126.08,107.37) v9(126.08,105.7) v9(126.08,104.58) v9(126.08,103.44) v9(126.08,102.34) v9(126.08,101.23) v9(126.35,98.55) v9(126.4,110.87) v9(126.78,109.62) v9(127.06,110.87) v9(127.27,107.5) v9(127.27,106.38) v9(127.29,102.29) v9(127.39,109.62) v9(127.69,98.88) v9(127.79,110.87) v9(128.43,108.11) v9(128.43,102.52) v9(128.49,106.23) v9(128.47,103.77) v9(128.47,101.33) v9(128.61,110.87) v9(128.68,109.62) v9(129.11,107.48) v9(129.1,105.77) v9(129.09,105.19) v9(129.15,106.83) v9(129.34,99.35) v9(129.52,101.94) v9(129.69,101.13) v9(131.11,107.54) v9(131.13,106.97) v9(131.08,106.33) v9(131.12,104.4) v9(131.68,107.31) v9(131.78,106.35) v9(131.76,104.43) v9(132.31,127.97) v9(132.48,100.74) v9(133,108.59) v9(133.03,107.96) v9(135.55,103.79) v9(141.37,112.81) v9(142.13,110.4) v9(142.58,138.96) v9(143.17,133.9) v9(143.92,139) v9(144.53,137.18) v9(144.63,135.73) v9(145.26,138.98) v9(146.04,135.28) v9(146.74,138.93) v9(147.67,136.39) v9(147.97,138.95) v9(148.81,135.76) v9(149.16,137.19) v9(150.43,116.87) v9(150.91,137.32) v9(151.44,119.24) v9(158.91,88.7) v9(159.14,117.2) v9(159.7,118.83) v9(159.91,91.2) v9(163.41,91.2) v9(163.65,92.49) v9(165.41,88.7) v9(175.27,84.93) v9(178.33,87.93) v9(178.65,85.44) v9(181.28,90.89) v9(181.58,85.71) v9(181.8,88.96) v9(183.72,87.5) v9(183.83,83.68) v9(184.87,91.66) v9(185.75,91.15) v9(185.76,87.61) v9(186.19,85.7) v9(186.32,89.43) v9(186.37,92.47) v9(187.16,91.54) v9(187.28,86.27) v9(187.73,89.02) v9(187.82,93.69) v9(188.07,147.94) v9(189.03,90.78) v9(190.38,94.61) v9(190.38,88.56) v9(191.81,91.89) v9(192.95,92.53) v9(194.08,91.84) v9(194.81,143.67) v9(194.81,142.83) v9(194.81,142.15) v9(195.54,143.58) v9(195.85,91.81) v9(198.32,88.3) v9(198.79,137.78) v9(201.38,137.65) v9(201.52,142.01) v9(203.78,143.14) v9(205.8,137.75) v9(207.22,138.84) v9(208.17,138.27) v9(208.26,138.96) v9(208.36,136.83) v9(210.05,138.54) v9(210.23,139.11) v9(211.27,138.43) v9(212.11,138.86) v9(212.06,138.01) v9(222.65,138.59) v9(225.15,138.59) v9(228.65,138.59) v9(230.16,121.06) v9(230.36,126.35) v9(230.97,126.31) v9(231.48,123.06) v9(231.6,126.31) v9(233.41,126.35) v9(235.83,121.75) v9(241.79,142.27) v9(242.13,150.19) v9(243.4,150.19) v9(243.4,141.53) v9(244.67,150.19) v9(247.48,141.48) v9(249.79,126.2) v9(249.79,125.1) v9(249.79,124.09) v9(249.79,123.17) v9(249.79,122.08) v9(249.79,121.14) v9(249.79,120.15) v9(249.79,119.11) v9(249.79,118.12) v9(249.79,117) v9(249.79,113.09) v9(249.79,112.15) v9(249.79,111.11) v9(249.79,110.09) v9(249.76,109.1) v9(252.3,141.53) v10(1.7,75.32) v10(1.7,73.29) v10(1.85,76.12) v10(4.71,59.85) v10(4.71,59.22) v10(4.71,58.58) v10(4.71,57.95) v10(4.71,57.31) v10(4.71,56.68) v10(4.71,56.04) v10(4.71,55.41) v10(4.71,54.77) v10(4.71,54.14) v10(4.71,53.5) v10(4.71,52.87) v10(4.69,52.12) v10(4.69,51.48) v10(4.69,50.85) v10(4.69,50.21) v10(4.69,49.58) v10(4.69,48.94) v10(4.69,48.31) v10(4.69,47.67) v10(4.69,47.04) v10(5.34,60.05) v10(6.03,94.66) v10(5.98,60.05) v10(6,46.55) v10(6.06,51.79) v10(6.17,44.78) v10(6.51,66.71) v10(6.61,60.05) v10(6.71,48.55) v10(6.8,44.78) v10(6.93,55.11) v10(6.92,53.6) v10(6.93,52.52) v10(6.92,51.65) v10(6.85,47.06) v10(6.85,46.19) v10(7.25,60.05) v10(7.44,44.78) v10(7.88,60.05) v10(8.07,44.78) v10(8.52,60.05) v10(8.71,44.78) v10(8.66,33.26) v10(8.66,19.26) v10(9.02,23.07) v10(9.33,60.07) v10(9.29,45.06) v10(9.42,49.73) v10(9.91,60.03) v10(9.93,45.06) v10(10.17,57.22) v10(10.27,39.77) v10(10.42,38.45) v10(10.56,45.06) v10(10.8,22.23) v10(10.85,35.39) v10(11.25,56.35) v10(11.2,45.06) v10(11.42,51.23) v10(11.92,52.23) v10(12.06,94.06) v10(12.06,32.39) v10(12.1,30.93) v10(12.1,30.3) v10(12.13,26.83) v10(12.13,26.2) v10(12.12,25.73) v10(12.12,25.09) v10(12.12,24.46) v10(12.12,23.82) v10(12.13,23.46) v10(12.13,21.79) v10(12.13,21.15) v10(12.13,14.45) v10(12.1,8.95) v10(12.22,59.91) v10(12.16,19.99) v10(12.17,17.84) v10(12.2,17.2) v10(12.42,52.23) v10(12.77,94.06) v10(12.76,8.4) v10(13.06,59.9) v10(13.12,33.43) v10(13.35,34.56) v10(13.44,24.35) v10(13.46,30.01) v10(13.46,29.29) v10(13.49,27.49) v10(13.49,26.84) v10(13.49,25.83) v10(13.46,14.79) v10(13.58,24.06) v10(13.74,23.78) v10(13.87,59.91) v10(13.92,48.24) v10(13.91,46.1) v10(13.91,8.39) v10(14,58.01) v10(14.05,22.83) v10(14.12,22.04) v10(14.12,21.32) v10(14.19,38.07) v10(14.17,15.17) v10(14.31,34.16) v10(14.34,27.49) v10(14.29,26.6) v10(14.32,25.71) v10(14.31,24.81) v10(14.42,49.73) v10(14.43,25.15) v10(14.55,44.29) v10(14.55,43.02) v10(14.55,41.75) v10(14.46,27.81) v10(14.46,26.87) v10(14.46,26.04) v10(14.8,102.36) v10(14.78,21.42) v10(14.8,19.74) v10(14.88,59.89) v10(14.94,34.79) v10(15.02,18.47) v10(15.14,98.51) v10(15.23,97.58) v10(15.16,29.84) v10(15.3,102.36) v10(15.34,31.98) v10(15.34,31.1) v10(15.26,21.41) v10(15.3,8.33) v10(15.5,13.91) v10(15.47,13.34) v10(15.82,44.29) v10(15.82,43.02) v10(15.82,41.75) v10(15.79,13.62) v10(15.75,12.68) v10(15.88,75.77) v10(15.87,18.4) v10(16.11,54.17) v10(16.14,22.73) v10(16.15,21.46) v10(16.08,8.35) v10(16.34,22.47) v10(16.33,21.18) v10(16.36,96.9) v10(16.49,22.21) v10(16.48,20.9) v10(16.56,93.4) v10(16.58,18.4) v10(16.74,96.55) v10(16.85,66.5) v10(16.85,53.12) v10(16.93,49.87) v10(16.99,97.43) v10(17.14,93.12) v10(17.09,44.29) v10(17.09,43.02) v10(17.09,41.75) v10(17.15,87.72) v10(17.2,29.31) v10(17.32,54.17) v10(17.25,49.88) v10(17.37,51.31) v10(17.51,23.36) v10(17.74,93.09) v10(17.74,31.22) v10(17.7,23.71) v10(17.81,96.43) v10(17.81,31.92) v10(17.88,23.35) v10(18.8,102.36) v10(19.26,42.45) v10(19.5,97.24) v10(19.73,49.02) v10(19.84,45.12) v10(20.01,101.06) v10(20.05,16.04) v10(20.24,51.95) v10(20.21,50.19) v10(20.19,30.28) v10(20.43,88.01) v10(20.43,87.37) v10(20.43,86.74) v10(20.4,86) v10(20.4,85.36) v10(20.42,83.37) v10(20.42,82.74) v10(20.4,82.05) v10(20.4,81.42) v10(20.43,78.99) v10(20.43,78.35) v10(20.43,77.72) v10(20.43,77.08) v10(20.43,76.45) v10(20.43,75.81) v10(20.43,75.18) v10(20.43,74.54) v10(20.43,73.91) v10(20.43,73.27) v10(20.43,72.64) v10(20.43,71.37) v10(20.52,98.71) v10(20.54,97.23) v10(20.45,96.44) v10(20.45,89.23) v10(20.45,70.88) v10(20.48,67.18) v10(20.48,66.54) v10(20.48,65.91) v10(20.48,65.27) v10(20.49,57.56) v10(20.63,99.3) v10(20.59,59.77) v10(20.65,30.74) v10(20.81,60.64) v10(21.14,61.25) v10(21.23,59.77) v10(21.19,26.41) v10(21.27,99.3) v10(21.44,60.64) v10(21.6,97.23) v10(21.58,61.25) v10(21.57,57.39) v10(21.7,84.7) v10(21.7,83.62) v10(21.8,102.36) v10(21.82,86.98) v10(21.83,47.07) v10(21.9,99.3) v10(21.86,59.77) v10(22.04,98.2) v10(21.99,43.57) v10(21.95,42.44) v10(22.07,96.45) v10(22.22,61.25) v10(22.19,20.29) v10(22.41,46.36) v10(22.54,99.3) v10(22.5,97.24) v10(22.5,59.77) v10(22.63,72.69) v10(22.85,61.25) v10(22.9,56.93) v10(23.02,96.45) v10(23.1,99.3) v10(23.12,60.64) v10(23.12,59.77) v10(23.06,27.94) v10(23.17,21.12) v10(23.3,102.36) v10(23.34,97.23) v10(23.36,92.9) v10(23.37,80.55) v10(23.43,76.15) v10(23.37,61.27) v10(23.37,46.25) v10(23.59,91.55) v10(23.64,27.94) v10(23.72,99.24) v10(23.72,83.85) v10(23.72,82.95) v10(23.73,60.64) v10(23.76,59.77) v10(24.01,79.37) v10(24.01,78.05) v10(24.01,76.78) v10(24.01,61.27) v10(24.26,97.24) v10(24.25,46.25) v10(24.4,99.26) v10(24.35,94.14) v10(24.39,59.77) v10(24.62,75.07) v10(24.64,63.53) v10(24.64,61.27) v10(24.72,96.44) v10(24.72,73.12) v10(24.67,67.99) v10(24.72,60.64) v10(24.8,102.36) v10(24.77,58.68) v10(24.75,50.98) v10(24.87,25.26) v10(24.99,83.85) v10(25.03,59.77) v10(25.08,99.3) v10(25.28,61.27) v10(25.25,52.48) v10(25.25,51.98) v10(25.42,97.23) v10(25.51,75.08) v10(25.53,66.81) v10(25.52,65.71) v10(25.53,64.7) v10(25.71,99.3) v10(25.75,68.73) v10(25.74,60.64) v10(25.66,59.77) v10(25.7,57.77) v10(25.7,56.93) v10(25.74,43.23) v10(25.75,52.48) v10(25.75,51.98) v10(25.91,61.3) v10(26.17,96.62) v10(26.18,95.94) v10(26.16,27.49) v10(26.3,102.36) v10(26.35,99.3) v10(26.3,59.77) v10(26.4,74.71) v10(26.54,96.99) v10(26.55,61.3) v10(26.68,60.64) v10(26.93,59.77) v10(26.98,99.3) v10(27.15,74.96) v10(27.18,61.3) v10(27.3,96.77) v10(27.49,60.64) v10(27.46,58.66) v10(27.53,44.94) v10(27.62,99.3) v10(27.57,59.77) v10(27.67,25.51) v10(27.75,49.48) v10(28.2,59.77) v10(28.25,99.3) v10(28.42,94.64) v10(28.64,68.44) v10(28.71,69.07) v10(28.68,58.48) v10(28.76,59.8) v10(28.89,99.3) v10(29.22,66.4) v10(29.22,65.51) v10(29.23,58.48) v10(29.38,59.79) v10(29.52,99.3) v10(30.16,99.3) v10(30.21,58.33) v10(30.3,102.36) v10(30.33,53.01) v10(30.28,48.73) v10(30.28,47.84) v10(30.6,96.71) v10(30.79,99.3) v10(31.02,96.83) v10(30.98,51.06) v10(31.35,59.8) v10(31.43,58.33) v10(31.48,90.46) v10(31.8,102.36) v10(32.2,61.25) v10(32.3,102.52) v10(32.47,66.45) v10(32.52,44.36) v10(32.82,31.69) v10(32.82,30.54) v10(32.95,58.43) v10(33.01,59.15) v10(33.38,69.67) v10(33.79,105.23) v10(33.75,45.72) v10(33.76,45.32) v10(34.02,53.32) v10(34.02,52.07) v10(34.14,96.29) v10(34.72,105.39) v10(34.8,110.04) v10(34.8,109.02) v10(34.8,107.75) v10(34.78,89.95) v10(35.1,102.01) v10(35.44,102.73) v10(35.66,101.48) v10(36.11,104.72) v10(36.19,102.85) v10(36.38,96.05) v10(36.6,74.57) v10(36.6,73.93) v10(36.6,73.3) v10(36.6,72.66) v10(36.6,72.03) v10(36.62,71.23) v10(36.62,70.59) v10(36.62,69.96) v10(36.62,69.32) v10(36.62,68.69) v10(36.62,68.05) v10(36.62,67.42) v10(36.62,66.78) v10(36.62,66.15) v10(36.62,65.51) v10(36.62,64.88) v10(37.02,85.26) v10(37.37,59.84) v10(38.08,45.82) v10(38.09,24.16) v10(38.19,88.76) v10(38.17,54.85) v10(38.3,102.85) v10(38.3,53.88) v10(38.3,51.98) v10(38.3,50.07) v10(38.3,48.17) v10(38.31,46.86) v10(38.6,106.4) v10(38.58,44.43) v10(38.59,30.1) v10(38.84,104.63) v10(38.92,105.74) v10(38.86,102.69) v10(38.86,101.86) v10(38.86,85.78) v10(39.02,88.06) v10(39,59.85) v10(39.15,104.96) v10(39.14,103.08) v10(39.15,102.32) v10(39.1,87.04) v10(39.3,85.3) v10(39.49,90.66) v10(40.09,88.01) v10(40.11,84.96) v10(40.21,107.32) v10(40.21,106.84) v10(40.21,106.21) v10(40.21,104.94) v10(40.21,104.3) v10(40.21,103.67) v10(40.21,103.03) v10(40.48,88.88) v10(40.99,87.17) v10(41.27,140.5) v10(41.26,133.46) v10(41.28,124.6) v10(41.33,123.35) v10(41.32,121.36) v10(41.27,106.45) v10(41.31,91.96) v10(41.4,89.52) v10(41.68,87.61) v10(42.18,132.51) v10(42.49,89.84) v10(42.7,85.97) v10(42.79,129.47) v10(42.89,90.55) v10(43.13,140.54) v10(43.07,132.51) v10(43.15,123.71) v10(43.18,120.88) v10(43.34,138.94) v10(43.28,125.63) v10(43.36,128.33) v10(43.64,142.17) v10(43.55,87.87) v10(44.05,132.51) v10(44.28,87.51) v10(44.52,142.16) v10(44.53,90.32) v10(44.53,88.87) v10(44.58,127.53) v10(44.94,132.51) v10(45.33,124.8) v10(45.49,82.24) v10(45.79,142.16) v10(45.84,126.33) v10(45.88,140.55) v10(45.89,129.18) v10(45.94,80.09) v10(46.02,82.84) v10(45.99,82.28) v10(46.2,81.53) v10(46.39,79.41) v10(46.51,82.84) v10(46.45,80.12) v10(46.63,82.28) v10(46.69,139.07) v10(46.72,130.3) v10(46.72,129.71) v10(46.7,81.57) v10(46.91,83.62) v10(46.89,79.45) v10(47.04,82.03) v10(47.06,142.16) v10(47.12,128.25) v10(47.15,82.84) v10(47.09,80.12) v10(47.34,81.57) v10(47.48,88.76) v10(47.54,82.06) v10(47.53,79.45) v10(47.68,80.07) v10(47.78,82.84) v10(47.77,81.28) v10(47.99,91.75) v10(48.04,83.94) v10(48.23,125.44) v10(48.23,124.56) v10(48.24,82.53) v10(48.18,82.06) v10(48.19,80.11) v10(48.22,79.42) v10(48.26,128.98) v10(48.28,81.31) v10(48.43,149.32) v10(48.43,148.69) v10(48.43,148.05) v10(48.43,147.42) v10(48.43,146.78) v10(48.43,146.15) v10(48.43,145.51) v10(48.43,144.88) v10(48.47,144.2) v10(48.49,84.45) v10(48.48,83.52) v10(48.63,141.8) v10(48.62,135.81) v10(48.71,137.89) v10(48.69,82.08) v10(48.72,79.46) v10(48.83,80.11) v10(48.91,81.31) v10(48.98,84.93) v10(49,82.99) v10(49.13,127.2) v10(49.14,81.63) v10(49.42,83.55) v10(49.38,82.65) v10(49.36,79.46) v10(49.49,96.2) v10(49.61,84.93) v10(49.59,81.18) v10(49.63,79.91) v10(49.83,142.5) v10(49.82,141.61) v10(49.82,83.82) v10(49.83,82.2) v10(49.87,83.03) v10(50.04,140.39) v10(50.02,79.27) v10(50.13,79.94) v10(50.25,84.93) v10(50.27,85.63) v10(50.25,82.69) v10(50.28,81.75) v10(50.4,96.63) v10(50.5,83.62) v10(50.54,80.21) v10(50.53,79.31) v10(50.62,99.39) v10(50.7,82.25) v10(50.7,81.34) v10(50.92,148.62) v10(50.88,84.93) v10(51.15,81.8) v10(51.15,80.89) v10(51.17,79.71) v10(51.16,79.31) v10(51.25,99.39) v10(51.29,96.63) v10(51.25,83.87) v10(51.29,82.77) v10(51.63,81.45) v10(51.64,80.78) v10(51.76,140.64) v10(51.77,82.09) v10(51.81,79.71) v10(51.89,99.39) v10(51.89,85.11) v10(51.89,83.56) v10(51.92,82.77) v10(52.27,81.45) v10(52.28,80.78) v10(52.41,82.09) v10(52.44,79.71) v10(52.52,99.39) v10(52.52,85.11) v10(52.51,83.71) v10(52.56,82.77) v10(52.9,81.45) v10(52.91,80.78) v10(53.04,82.09) v10(53.08,79.71) v10(53.16,99.39) v10(53.16,85.11) v10(53.18,83.71) v10(53.28,82.76) v10(53.54,81.45) v10(53.55,80.78) v10(53.79,99.39) v10(53.79,85.11) v10(53.77,82.08) v10(53.8,79.7) v10(53.92,82.76) v10(54.13,83.64) v10(54.26,81.44) v10(54.27,80.77) v10(54.43,99.39) v10(54.4,82.08) v10(54.44,79.7) v10(54.9,81.44) v10(54.91,80.77) v10(54.96,81.94) v10(55.06,99.39) v10(55.2,79.71) v10(55.53,81.44) v10(55.59,81.94) v10(55.56,80.78) v10(55.7,99.39) v10(55.84,79.71) v10(56.24,85.56) v10(56.23,81.94) v10(56.17,81.44) v10(56.19,80.78) v10(56.33,99.39) v10(56.28,82.93) v10(56.52,144.96) v10(56.47,79.71) v10(56.62,84.49) v10(56.83,80.78) v10(56.92,82.93) v10(56.97,99.39) v10(56.99,81.44) v10(57.05,81.94) v10(57.11,79.71) v10(57.46,80.78) v10(57.64,122.97) v10(57.6,99.39) v10(57.55,82.93) v10(57.63,81.44) v10(57.69,81.94) v10(57.82,146.86) v10(57.83,79.7) v10(57.95,141.02) v10(58.24,99.39) v10(58.19,82.93) v10(58.19,80.77) v10(58.26,81.44) v10(58.41,81.94) v10(58.46,79.7) v10(58.82,80.77) v10(58.87,99.39) v10(58.9,81.44) v10(59.05,81.94) v10(59.11,101.02) v10(59.2,145.22) v10(59.19,79.74) v10(59.35,83.92) v10(59.51,99.39) v10(59.49,80.77) v10(59.68,81.94) v10(59.85,139.72) v10(59.82,79.74) v10(59.87,81.43) v10(60.13,148.52) v10(60.13,80.77) v10(60.51,81.94) v10(60.51,81.43) v10(60.46,79.74) v10(60.76,80.77) v10(60.85,139.63) v10(61.14,81.94) v10(61.14,81.43) v10(61.09,79.74) v10(61.33,147.7) v10(61.36,93.84) v10(61.36,91.93) v10(61.36,91.3) v10(61.36,90.03) v10(61.36,88.76) v10(61.4,80.77) v10(61.56,98.01) v10(61.56,97.38) v10(61.56,96.74) v10(61.78,81.43) v10(61.82,79.73) v10(61.98,141.83) v10(61.98,81.97) v10(62.12,80.75) v10(62.27,145.35) v10(62.45,79.73) v10(62.59,141) v10(62.64,118.92) v10(62.57,99) v10(62.57,98.37) v10(62.57,97.73) v10(62.57,96.92) v10(62.62,93.25) v10(62.62,92.62) v10(62.62,91.98) v10(62.62,91.35) v10(62.58,90.72) v10(62.58,90.09) v10(62.58,89.45) v10(62.64,85.59) v10(62.64,84.86) v10(62.62,81.97) v10(62.71,132.01) v10(62.68,131.5) v10(62.71,130.89) v10(62.69,86.51) v10(62.76,136.16) v10(62.77,81.43) v10(62.76,80.75) v10(62.88,110.09) v10(62.88,109.46) v10(62.88,108.82) v10(62.88,108.19) v10(62.88,107.55) v10(62.88,106.92) v10(62.88,106.28) v10(62.88,105.65) v10(62.88,105.01) v10(62.88,104.38) v10(62.88,103.74) v10(62.88,103.11) v10(62.88,102.47) v10(62.99,133.62) v10(63.23,132) v10(63.25,81.97) v10(63.4,81.43) v10(63.38,79.75) v10(63.52,80.78) v10(63.73,124.7) v10(63.82,149.65) v10(63.82,148.38) v10(63.8,147.32) v10(63.8,146.25) v10(63.79,145.37) v10(63.84,143.89) v10(63.84,143.28) v10(63.84,90.61) v10(63.86,132.04) v10(63.94,117.28) v10(63.87,91.87) v10(63.87,91.23) v10(63.94,85.66) v10(63.99,120.21) v10(64.01,100.31) v10(64.01,99.68) v10(64.01,99.04) v10(64.01,98.41) v10(64.01,97.77) v10(64.01,97.14) v10(64.01,96.5) v10(64.01,95.87) v10(63.99,88.39) v10(63.95,84.95) v10(64,83.4) v10(64.04,81.43) v10(64.01,79.75) v10(64.07,87.21) v10(64.08,81.97) v10(64.19,127.81) v10(64.15,80.78) v10(64.54,143.23) v10(64.5,132.04) v10(64.64,83.4) v10(64.65,79.75) v10(64.71,81.97) v10(64.67,81.43) v10(64.8,148.28) v10(64.8,147.68) v10(64.8,147.09) v10(64.79,80.78) v10(65.32,140.98) v10(65.32,130.69) v10(65.31,119.44) v10(65.27,83.4) v10(65.28,81.96) v10(65.28,79.75) v10(65.42,80.78) v10(65.54,143.26) v10(65.7,81.42) v10(65.75,131.34) v10(65.93,138.07) v10(65.91,83.4) v10(65.92,81.96) v10(66.01,79.74) v10(66.12,147.7) v10(66.14,146.55) v10(66.15,80.77) v10(66.19,143.24) v10(66.2,135.29) v10(66.31,130.7) v10(66.27,125.79) v10(66.34,81.42) v10(66.54,83.4) v10(66.63,131.34) v10(66.55,81.96) v10(66.64,79.74) v10(66.66,85.5) v10(66.66,85.12) v10(66.78,80.77) v10(67.04,85.5) v10(67.04,85.12) v10(66.97,81.42) v10(67.15,143.29) v10(67.23,139.97) v10(67.18,83.4) v10(67.37,127.35) v10(67.38,81.96) v10(67.53,140.94) v10(67.46,80.74) v10(67.65,93.8) v10(67.61,81.42) v10(67.72,79.76) v10(67.81,83.4) v10(67.94,145.16) v10(67.98,93.8) v10(68.01,81.96) v10(68.08,123.02) v10(68.09,80.74) v10(68.33,81.43) v10(68.45,83.4) v10(68.36,79.76) v10(68.73,80.74) v10(68.83,143.25) v10(68.79,81.95) v10(68.97,81.43) v10(68.99,79.76) v10(69.08,83.4) v10(69.4,143.26) v10(69.42,81.95) v10(69.36,80.74) v10(69.58,121.12) v10(69.6,81.43) v10(69.65,130.97) v10(69.72,83.4) v10(69.72,79.75) v10(70.02,143.25) v10(70.03,131.34) v10(70.06,81.95) v10(70.08,80.73) v10(70.24,81.43) v10(70.42,112.35) v10(70.42,111.95) v10(70.42,109.15) v10(70.42,108.75) v10(70.35,83.4) v10(70.35,79.75) v10(70.5,143.25) v10(70.68,93.68) v10(70.72,80.73) v10(70.82,112.35) v10(70.82,111.95) v10(70.82,111.55) v10(70.82,111.15) v10(70.82,109.15) v10(70.82,108.75) v10(70.94,127.26) v10(70.86,103.73) v10(70.89,81.95) v10(71,131.36) v10(71.01,93.68) v10(70.99,83.4) v10(70.99,79.76) v10(71.23,85.5) v10(71.23,85.12) v10(71.29,143.29) v10(71.25,81.42) v10(71.52,81.95) v10(71.51,80.75) v10(71.63,131.36) v10(71.61,85.5) v10(71.61,85.12) v10(71.62,79.76) v10(71.67,126.18) v10(71.93,143.29) v10(71.89,81.42) v10(72.14,80.75) v10(72.22,140.37) v10(72.27,131.36) v10(72.32,85.35) v10(72.35,82.89) v10(72.53,121.97) v10(72.5,85.1) v10(72.52,81.42) v10(72.51,79.74) v10(72.56,143.29) v10(72.68,85.35) v10(72.75,131.36) v10(72.88,85.1) v10(73.2,143.29) v10(73.22,108.75) v10(73.18,79.48) v10(73.35,93.75) v10(73.48,81.96) v10(73.45,81.44) v10(73.62,112.35) v10(73.62,111.95) v10(73.62,109.55) v10(73.62,109.15) v10(73.62,108.75) v10(73.68,93.75) v10(73.7,82.85) v10(73.83,143.29) v10(74.02,112.35) v10(74.02,111.95) v10(74.02,109.55) v10(74.02,109.15) v10(74.02,108.75) v10(74.09,125.07) v10(74.11,93.8) v10(74.11,81.96) v10(74.09,81.44) v10(74.28,80.89) v10(74.44,93.8) v10(74.47,143.29) v10(74.5,128.38) v10(74.75,81.96) v10(74.72,81.44) v10(74.91,80.89) v10(75.1,143.29) v10(75.32,121.7) v10(75.36,81.44) v10(75.52,128.32) v10(75.55,80.89) v10(75.57,81.96) v10(75.74,143.29) v10(76.08,81.45) v10(76.21,81.96) v10(76.18,80.89) v10(76.37,143.29) v10(76.71,81.45) v10(76.9,80.91) v10(77.01,143.29) v10(76.96,81.96) v10(77.35,81.45) v10(77.39,119.29) v10(77.39,118.97) v10(77.39,118.65) v10(77.39,118.33) v10(77.54,80.91) v10(77.64,143.29) v10(77.59,81.96) v10(77.69,142.1) v10(77.69,140.83) v10(77.69,139.56) v10(77.69,138.29) v10(77.67,137.49) v10(77.73,135.63) v10(77.7,121.5) v10(78.01,130.64) v10(77.98,81.45) v10(78.23,81.96) v10(78.17,80.91) v10(78.57,81.49) v10(78.8,130.89) v10(78.85,122.02) v10(78.81,80.91) v10(79.05,81.96) v10(79.17,122.02) v10(79.2,81.49) v10(79.48,122.02) v10(79.46,81) v10(79.69,81.96) v10(79.8,122.02) v10(79.84,81.49) v10(80.12,133.35) v10(80.09,81) v10(80.47,81.49) v10(80.63,116.62) v10(80.68,136.03) v10(80.73,81) v10(80.75,130.44) v10(81.01,129.19) v10(81.01,116.62) v10(81.06,136.03) v10(81.2,82.13) v10(81.39,136.03) v10(81.43,130.44) v10(81.39,116.62) v10(81.48,83.85) v10(81.54,81.61) v10(81.92,82.14) v10(82.11,130.44) v10(82.28,81.61) v10(82.38,133.88) v10(82.53,135.21) v10(82.56,82.14) v10(82.71,130.45) v10(82.91,81.61) v10(83.19,82.14) v10(83.55,81.61) v10(83.58,136.1) v10(83.83,82.14) v10(84.13,136.84) v10(84.18,81.61) v10(84.41,82.18) v10(84.77,81.64) v10(85.05,82.18) v10(85.31,136.63) v10(85.28,133.54) v10(85.4,81.64) v10(85.66,90.46) v10(85.66,89.57) v10(85.68,88.91) v10(85.67,88.3) v10(85.65,87.23) v10(85.67,86.55) v10(85.68,85.92) v10(85.65,85.25) v10(85.68,82.18) v10(86.04,81.64) v10(86.32,82.18) v10(86.53,89.61) v10(86.54,88.34) v10(86.55,88.95) v10(86.67,81.64) v10(86.84,87.23) v10(86.84,85.25) v10(86.86,86.55) v10(86.87,85.92) v10(87.01,135.63) v10(86.99,82.19) v10(87.16,90.45) v10(87.34,81.66) v10(87.4,135.66) v10(87.56,89.68) v10(87.59,89.02) v10(87.58,88.41) v10(87.62,82.19) v10(87.98,81.66) v10(88.26,82.19) v10(88.4,87.24) v10(88.42,86.57) v10(88.43,85.94) v10(88.4,85.26) v10(88.5,89.63) v10(88.52,88.97) v10(88.51,88.36) v10(88.61,81.66) v10(88.86,133.36) v10(88.87,91.64) v10(88.89,82.19) v10(89.16,136.63) v10(89.25,81.66) v10(89.44,89.69) v10(89.48,90.44) v10(89.46,89.03) v10(89.45,88.42) v10(89.62,91.37) v10(89.56,87.18) v10(89.57,86.51) v10(89.58,85.88) v10(89.56,85.2) v10(89.66,82.16) v10(90.01,81.63) v10(90.29,82.16) v10(90.54,97) v10(90.54,96.64) v10(90.61,136.58) v10(90.55,96.27) v10(90.62,86.06) v10(90.63,85.27) v10(90.65,81.63) v10(90.76,98.46) v10(90.93,82.16) v10(91.27,101.07) v10(91.27,100.62) v10(91.28,81.63) v10(91.9,100.85) v10(91.98,90.74) v10(92.25,136.63) v10(92.28,91.53) v10(92.53,129.37) v10(92.56,101.07) v10(92.56,100.62) v10(93.84,90.85) v10(93.94,90.11) v10(94.33,130.93) v10(94.73,89.79) v10(94.76,91.67) v10(94.76,90.84) v10(95.04,129.32) v10(95.1,125.89) v10(95.5,133.6) v10(95.91,90.47) v10(95.88,89.76) v10(95.97,93.65) v10(96.81,133.85) v10(96.96,131.86) v10(97.13,88.75) v10(97.17,122.98) v10(97.19,121.95) v10(97.22,121.31) v10(97.24,120.39) v10(97.2,90.14) v10(97.21,89.43) v10(97.22,87.37) v10(97.24,86.53) v10(97.17,85.7) v10(97.19,85.17) v10(97.4,130.44) v10(97.38,83.54) v10(98.14,131.85) v10(98.32,93.32) v10(98.32,92.68) v10(98.41,91.84) v10(98.55,127.8) v10(98.46,121.8) v10(98.53,95.33) v10(98.6,124.47) v10(98.56,123.11) v10(98.6,109.93) v10(98.57,98.36) v10(98.58,96.13) v10(98.57,94.48) v10(98.66,131.06) v10(98.69,125.79) v10(98.66,87.37) v10(99.33,89.82) v10(99.38,107.49) v10(99.38,107.18) v10(99.38,106.88) v10(99.38,106.57) v10(99.93,95.19) v10(99.97,104.02) v10(100.06,123.38) v10(100.06,118.37) v10(100.07,91.26) v10(100.27,104.03) v10(100.44,99.73) v10(100.51,97.45) v10(100.58,104.05) v10(100.74,99.73) v10(101.1,91.28) v10(101.21,128.56) v10(101.42,133.4) v10(102.22,89.91) v10(103.13,120.45) v10(103.13,119.45) v10(103.13,118.95) v10(103.13,117.45) v10(103.13,115.95) v10(103.13,114.95) v10(103.63,120.45) v10(103.63,116.45) v10(103.64,84.25) v10(103.69,93.09) v10(103.94,98.41) v10(104.02,110.52) v10(104.13,121.45) v10(104.13,120.95) v10(104.13,116.95) v10(104.13,116.45) v10(104.1,85.38) v10(104.25,84.31) v10(104.26,98.41) v10(104.58,131.12) v10(104.63,119.95) v10(104.63,118.45) v10(104.63,116.95) v10(104.63,114.95) v10(104.63,113.45) v10(104.69,124.96) v10(104.92,91.52) v10(105.04,94.34) v10(105.13,121.45) v10(105.13,119.45) v10(105.13,115.95) v10(105.16,83.96) v10(105.34,94.34) v10(105.39,125.17) v10(105.47,98.15) v10(105.63,121.45) v10(105.63,118.45) v10(105.63,116.95) v10(105.63,115.95) v10(105.63,115.45) v10(105.63,114.95) v10(105.63,113.45) v10(105.58,100.59) v10(105.58,100.29) v10(105.75,135.75) v10(105.72,133.71) v10(105.75,84.01) v10(105.82,98.15) v10(106.04,100.83) v10(106.13,119.95) v10(106.13,118.95) v10(106.13,115.45) v10(106.14,98.14) v10(106.08,94.34) v10(106.34,100.83) v10(106.38,133.71) v10(106.41,94.34) v10(106.48,135.75) v10(106.52,134.93) v10(106.51,130.93) v10(106.47,98.15) v10(106.63,115.45) v10(106.8,86.22) v10(106.8,83.09) v10(106.94,93.51) v10(107.04,135.75) v10(107.02,105.39) v10(106.97,98.2) v10(107.13,121.45) v10(107.13,115.45) v10(107.07,94.36) v10(107.19,133.71) v10(107.28,130.87) v10(107.33,105.39) v10(107.27,98.2) v10(107.4,94.36) v10(107.63,120.45) v10(107.63,119.95) v10(107.63,118.95) v10(107.63,113.45) v10(107.64,105.39) v10(107.6,101.61) v10(107.7,94.36) v10(107.98,101.61) v10(108.03,94.38) v10(108.13,120.95) v10(108.13,120.45) v10(108.13,105.37) v10(108.18,125.17) v10(108.24,98.18) v10(108.44,105.38) v10(108.54,98.18) v10(108.63,121.45) v10(108.63,119.45) v10(108.63,118.95) v10(108.74,105.38) v10(108.82,101.58) v10(109.13,118.95) v10(109.13,118.45) v10(109.13,117.95) v10(109.13,116.45) v10(109.13,113.45) v10(109.15,101.58) v10(109.34,105.37) v10(109.53,98.15) v10(109.63,121.45) v10(109.63,119.95) v10(109.63,118.95) v10(109.65,105.38) v10(109.72,127.49) v10(109.77,128.04) v10(109.84,98.15) v10(109.91,100.77) v10(109.91,100.39) v10(110.04,131) v10(109.95,105.38) v10(109.99,101.61) v10(110.13,114.95) v10(110.34,101.61) v10(110.55,105.37) v10(110.64,114.95) v10(110.7,100.69) v10(110.7,97.7) v10(110.85,105.37) v10(111,100.69) v10(111,97.7) v10(111.14,119.95) v10(111.14,118.95) v10(111.14,116.45) v10(111.14,115.95) v10(111.14,114.95) v10(111.16,105.37) v10(111.5,131.02) v10(111.59,100.69) v10(111.59,97.7) v10(111.74,104.53) v10(111.89,100.69) v10(111.89,97.7) v10(112.05,96.45) v10(112.15,135.86) v10(112.1,128.74) v10(112.17,127.73) v10(112.48,100.69) v10(112.48,97.7) v10(112.78,100.69) v10(112.78,97.7) v10(113.14,128.74) v10(113.37,100.69) v10(113.37,97.8) v10(113.37,86.91) v10(113.48,110.14) v10(113.48,107.98) v10(113.58,97.57) v10(113.67,135.89) v10(113.67,100.69) v10(113.81,128.74) v10(114.04,131.15) v10(114.51,135.92) v10(114.51,135.03) v10(114.76,134.76) v10(114.94,131.17) v10(115.23,134.78) v10(115.35,135.92) v10(115.71,129.91) v10(116.8,109.3) v10(117.07,110.91) v10(117.07,110.26) v10(117.23,111.37) v10(117.27,131.06) v10(117.94,110.75) v10(118,128.81) v10(118.02,98.7) v10(118.06,111.15) v10(118.05,107.69) v10(118.05,107.04) v10(118.05,106.4) v10(118.05,105.76) v10(118.05,105.11) v10(118.38,131.06) v10(118.6,98.71) v10(119.3,131.06) v10(119.34,98.58) v10(119.73,94.56) v10(119.72,91.32) v10(119.99,98.58) v10(120.12,129.69) v10(120.63,98.58) v10(120.78,128.34) v10(120.95,131.15) v10(121.02,136.66) v10(121.28,98.58) v10(121.41,91.31) v10(121.6,110.41) v10(121.77,93.54) v10(121.88,131.06) v10(121.92,111.15) v10(121.92,98.58) v10(122.41,136.19) v10(122.41,129.55) v10(122.6,131.03) v10(122.56,111.15) v10(122.56,98.58) v10(122.82,94.22) v10(122.87,91.31) v10(123.01,88.49) v10(123.21,111.15) v10(123.21,98.58) v10(123.2,82) v10(123.27,126.25) v10(123.95,131.05) v10(123.85,111.15) v10(123.85,98.58) v10(123.85,98.09) v10(123.9,88.49) v10(124.2,86.09) v10(124.2,83.09) v10(124.29,133.69) v10(124.31,91.3) v10(124.5,98.58) v10(125,134.23) v10(125.14,111.15) v10(125.22,131.05) v10(125.44,93.68) v10(125.46,111.89) v10(125.78,111.15) v10(126.13,134.64) v10(126.11,111.89) v10(126.24,123.42) v10(126.24,121.92) v10(126.24,121.42) v10(126.24,87.58) v10(126.32,95.05) v10(126.32,94.12) v10(126.43,111.15) v10(126.49,131.05) v10(126.74,121.42) v10(126.74,120.92) v10(126.74,119.92) v10(126.75,111.89) v10(126.87,135.66) v10(127,101.01) v10(127.07,98.58) v10(127.24,121.42) v10(127.24,120.42) v10(127.24,119.92) v10(127.23,91.45) v10(127.31,86.43) v10(127.41,134.72) v10(127.74,127.92) v10(127.74,126.42) v10(127.74,121.42) v10(127.74,120.92) v10(127.74,120.42) v10(127.74,119.92) v10(127.72,111.15) v10(127.72,98.58) v10(127.76,131.05) v10(128.06,135.58) v10(128.24,124.42) v10(128.24,123.92) v10(128.24,123.42) v10(128.24,122.92) v10(128.24,122.42) v10(128.24,121.92) v10(128.33,134.64) v10(128.36,111.15) v10(128.36,98.58) v10(128.45,91.28) v10(128.74,127.92) v10(128.74,121.92) v10(128.74,119.92) v10(128.84,134.79) v10(129.01,111.15) v10(129.01,98.58) v10(129.05,91.28) v10(129.25,127.42) v10(129.25,126.92) v10(129.25,121.92) v10(129.25,119.92) v10(129.25,137.38) v10(129.42,131.03) v10(129.64,137.37) v10(129.65,111.15) v10(129.65,98.58) v10(129.62,91.27) v10(129.75,126.92) v10(129.75,126.42) v10(129.75,125.42) v10(129.75,121.92) v10(130.12,131.03) v10(130.25,127.92) v10(130.25,121.92) v10(130.23,91.58) v10(130.29,98.58) v10(130.46,136.65) v10(130.64,95.51) v10(130.75,121.92) v10(130.94,98.58) v10(131.25,126.42) v10(131.25,125.42) v10(131.25,121.92) v10(131.26,110.9) v10(131.26,109.92) v10(131.45,91.61) v10(131.58,98.58) v10(131.75,127.92) v10(131.75,124.92) v10(131.75,123.42) v10(131.75,122.42) v10(131.75,121.92) v10(131.75,121.42) v10(131.75,119.92) v10(131.81,130.84) v10(131.9,110.9) v10(132.25,127.92) v10(132.25,125.92) v10(132.25,122.42) v10(132.75,126.42) v10(132.75,124.92) v10(132.75,123.42) v10(132.75,121.42) v10(132.75,119.92) v10(132.93,109.3) v10(133.25,127.92) v10(133.25,127.42) v10(133.25,123.42) v10(133.25,122.92) v10(133.42,109.3) v10(133.75,127.92) v10(133.75,126.92) v10(133.75,122.92) v10(133.76,131.06) v10(134.25,127.42) v10(134.25,126.92) v10(134.25,123.92) v10(134.25,122.42) v10(134.25,121.42) v10(134.26,131.06) v10(134.51,97.57) v10(134.75,88.88) v10(134.9,100.28) v10(134.95,86.8) v10(135.22,88.9) v10(135.42,112.65) v10(135.42,111.74) v10(135.42,98.48) v10(135.45,91.44) v10(135.67,88.89) v10(135.99,131.11) v10(136.48,131.06) v10(137,91.5) v10(137.56,91.5) v10(137.73,130.81) v10(138.07,103.16) v10(138.16,123.43) v10(138.35,131.12) v10(138.28,91.55) v10(138.55,106.02) v10(138.73,92.87) v10(138.83,128.57) v10(138.93,91.54) v10(139.01,104.55) v10(139.47,114.97) v10(139.48,90.61) v10(139.64,91.54) v10(139.71,126.58) v10(139.71,126.2) v10(139.66,106.21) v10(139.69,100.58) v10(140.14,111.04) v10(140.21,126.58) v10(140.21,126.2) v10(140.48,91.54) v10(140.66,128.66) v10(140.85,126.58) v10(140.85,126.2) v10(141.07,94.01) v10(141.2,121.72) v10(141.41,126.58) v10(141.41,126.2) v10(141.57,130.79) v10(141.66,122.03) v10(141.71,98.18) v10(142.3,124.11) v10(142.5,120.66) v10(142.6,118.75) v10(143.11,137.45) v10(143.34,132.72) v10(143.66,99.69) v10(143.74,94.31) v10(143.91,126.03) v10(144.23,137.45) v10(144.16,96.54) v10(144.34,133.51) v10(144.37,133.09) v10(144.52,135.26) v10(144.46,131.29) v10(144.46,122.33) v10(144.6,116.28) v10(144.58,114.46) v10(144.77,126.04) v10(144.84,96.54) v10(145.03,137.46) v10(145.14,110.28) v10(145.7,135.09) v10(145.82,121.57) v10(145.83,90.56) v10(145.86,97.99) v10(146.2,123.28) v10(146.53,109.67) v10(146.84,90.61) v10(146.95,85.82) v10(147.44,133.37) v10(147.47,124.65) v10(147.52,91.83) v10(147.57,118.85) v10(147.57,102.89) v10(147.55,101.3) v10(147.68,130.39) v10(147.75,129.64) v10(147.75,128.43) v10(147.75,127.69) v10(147.67,123.31) v10(147.75,122.83) v10(147.73,121.5) v10(147.76,128.99) v10(147.81,117.66) v10(147.78,116.86) v10(147.85,115.68) v10(147.82,97.82) v10(147.78,96.68) v10(147.77,95.99) v10(147.9,131.16) v10(147.89,93.66) v10(148.67,134.86) v10(148.77,115.76) v10(148.9,137.54) v10(148.93,130.17) v10(148.89,124.42) v10(148.93,123.44) v10(148.91,116.85) v10(149.02,117.8) v10(149.26,115.73) v10(149.66,131.53) v10(149.74,117.05) v10(149.75,117.41) v10(149.83,115.69) v10(149.82,115.36) v10(149.97,98.32) v10(150.2,127.29) v10(150.2,126.93) v10(150.31,132.2) v10(150.32,131.52) v10(150.37,118.75) v10(150.41,116.47) v10(150.43,116.16) v10(150.81,127.29) v10(150.81,126.93) v10(150.81,93.58) v10(150.86,118.75) v10(151.01,131.55) v10(151.31,98.48) v10(151.34,96.07) v10(151.4,132.13) v10(151.39,127.29) v10(151.39,126.93) v10(151.49,102.14) v10(151.54,93.63) v10(151.61,118.78) v10(151.92,118.77) v10(151.99,132.15) v10(152,127.29) v10(152,126.93) v10(152.58,127.29) v10(152.58,126.96) v10(152.67,132.15) v10(152.84,118.76) v10(153.22,137.22) v10(153.19,127.29) v10(153.19,126.96) v10(153.33,132.16) v10(153.31,118.75) v10(153.65,127.87) v10(153.65,127.57) v10(153.66,127.25) v10(153.66,126.94) v10(153.92,131.81) v10(154.06,132.25) v10(154.22,95.66) v10(154.22,94.57) v10(154.22,93.51) v10(154.5,131.48) v10(154.63,95.66) v10(154.63,94.56) v10(154.63,93.51) v10(154.67,132.3) v10(155,113.01) v10(155.05,112.15) v10(155.17,131.47) v10(155.25,132.02) v10(155.35,113.01) v10(155.35,112.15) v10(155.38,101.33) v10(155.52,136.1) v10(155.49,134.22) v10(156.46,118.11) v10(157.02,137.07) v10(157.62,95.92) v10(157.66,93.12) v10(158.55,90.74) v10(159.05,123.95) v10(159.26,102.38) v10(159.32,101.38) v10(159.37,94.59) v10(159.62,125.13) v10(159.8,90.74) v10(160,125.13) v10(160.01,124.79) v10(160.04,112.12) v10(160.09,135.54) v10(160.34,112.12) v10(160.36,133.28) v10(160.36,124.81) v10(160.37,112.49) v10(160.65,112.12) v10(161.02,121.5) v10(161.05,90.74) v10(161.27,136.43) v10(161.52,118.56) v10(161.58,118.87) v10(161.6,112.75) v10(161.65,118.22) v10(161.65,94.59) v10(161.77,119.15) v10(161.91,121.42) v10(161.91,112.75) v10(162.15,133.9) v10(162.21,112.75) v10(162.54,136.43) v10(162.64,121.4) v10(162.79,123.64) v10(163.06,130.03) v10(163.33,110.69) v10(163.38,130.03) v10(163.81,96.43) v10(163.9,85.78) v10(164.53,96.33) v10(164.85,108.9) v10(165.5,96.93) v10(165.59,126.4) v10(165.59,126) v10(165.59,125.6) v10(165.94,91.7) v10(165.99,126.4) v10(165.99,126) v10(165.99,125.6) v10(165.99,123.6) v10(166.1,90.83) v10(166.16,97.12) v10(166.39,126.4) v10(166.39,126) v10(166.53,111.91) v10(167.19,121.6) v10(167.2,109.14) v10(167.21,96.1) v10(167.43,97.38) v10(167.57,95.08) v10(167.82,108.36) v10(168,100.62) v10(168.13,128.84) v10(168.39,124) v10(168.46,95.36) v10(168.59,130.59) v10(168.59,129.62) v10(168.63,96.64) v10(168.65,93.96) v10(168.61,90.01) v10(168.79,123.6) v10(168.92,119.59) v10(168.99,90.01) v10(169.19,121.6) v10(169.2,119.24) v10(169.3,136.76) v10(170.08,110.7) v10(170.15,93.96) v10(170.16,136.76) v10(170.39,122) v10(170.39,121.6) v10(170.39,121.2) v10(170.8,129.62) v10(170.79,122) v10(170.79,121.6) v10(170.79,121.2) v10(171.24,113.32) v10(171.24,112.05) v10(171.65,93.96) v10(171.81,102.75) v10(172.04,127) v10(172.6,111.98) v10(172.7,133.51) v10(172.83,125.17) v10(172.83,111.01) v10(172.83,103.88) v10(172.89,128.18) v10(173.03,130.23) v10(172.99,127) v10(173.15,93.96) v10(173.25,87.14) v10(173.36,130.23) v10(173.59,114.64) v10(173.88,126.94) v10(173.97,100.15) v10(174.45,115.4) v10(174.47,114.38) v10(174.47,114.03) v10(174.52,87.14) v10(174.52,85.87) v10(174.65,93.96) v10(174.67,127.19) v10(174.83,115.4) v10(174.85,114.38) v10(174.81,112.12) v10(174.82,111.69) v10(174.82,110.5) v10(174.87,114.03) v10(175,127.17) v10(175.33,112.96) v10(175.37,111.01) v10(175.79,87.14) v10(175.79,85.87) v10(176.04,124.75) v10(176.35,95.66) v10(176.43,96.43) v10(176.61,128.94) v10(176.73,99.73) v10(177.06,87.14) v10(177.06,85.87) v10(177.23,98.12) v10(177.39,110.28) v10(177.79,127.88) v10(177.95,105.91) v10(178.02,98.12) v10(178.1,127.88) v10(178.33,133.09) v10(178.34,132.72) v10(178.34,132.06) v10(178.34,131.71) v10(178.33,87.14) v10(178.33,85.87) v10(178.4,127.87) v10(178.67,117.85) v10(178.67,117.47) v10(178.66,107.77) v10(178.85,97.49) v10(178.91,108.02) v10(179.01,99.89) v10(179.05,117.85) v10(179.05,117.47) v10(179.05,98.1) v10(179.15,93.96) v10(179.3,111.02) v10(179.3,110.69) v10(179.29,110.31) v10(179.29,110) v10(179.43,117.85) v10(179.43,117.47) v10(179.48,132.09) v10(179.51,131.78) v10(179.48,97.48) v10(179.6,87.14) v10(179.6,85.87) v10(179.75,96.3) v10(179.81,132.09) v10(179.84,131.78) v10(179.81,117.86) v10(179.81,117.47) v10(179.98,136.34) v10(180.12,132.09) v10(180.14,131.78) v10(180.06,120.53) v10(180.15,93.96) v10(180.21,136.57) v10(180.44,120.53) v10(180.4,90.06) v10(180.65,93.96) v10(180.78,90.06) v10(180.87,87.14) v10(180.87,85.87) v10(181.13,96.83) v10(181.31,120.53) v10(181.65,93.96) v10(181.67,120.53) v10(182.14,97.48) v10(182.15,93.96) v10(182.14,87.14) v10(182.14,85.87) v10(182.65,93.96) v10(182.75,97.43) v10(183.15,93.96) v10(183.2,96.85) v10(183.2,96.5) v10(183.41,87.14) v10(183.39,85.89) v10(183.48,97.43) v10(183.98,123.24) v10(183.98,122.6) v10(184.11,120.7) v10(184.3,122.6) v10(184.26,97.49) v10(184.36,123.24) v10(184.36,120.95) v10(184.68,87.17) v10(185.15,97.46) v10(185.44,122.31) v10(185.53,96.88) v10(185.71,97.39) v10(186.29,98.32) v10(186.48,96.3) v10(186.82,107.55) v10(186.95,98) v10(186.99,97.46) v10(187.08,107.81) v10(187.24,118.84) v10(187.24,118.52) v10(187.34,100.49) v10(187.38,135.44) v10(187.37,97.53) v10(187.56,118.84) v10(187.56,118.52) v10(187.6,98) v10(187.83,107.75) v10(187.8,103.89) v10(187.88,118.84) v10(187.88,118.52) v10(188.09,134.01) v10(188.11,107.54) v10(188.14,98) v10(188.44,132.75) v10(188.63,146.45) v10(188.63,144.08) v10(188.64,127.19) v10(188.65,141.83) v10(188.69,135.53) v10(188.68,126.74) v10(188.68,126.4) v10(188.69,125.94) v10(188.75,128.09) v10(188.88,131.55) v10(188.91,98.06) v10(189.05,128.21) v10(188.96,127.19) v10(189.02,118.84) v10(189.02,118.52) v10(188.96,100.3) v10(189.17,126.42) v10(189.16,107.77) v10(189.17,107.46) v10(189.34,118.84) v10(189.34,118.52) v10(189.35,127.2) v10(189.4,88.3) v10(189.53,126.82) v10(189.46,85.2) v10(189.63,141.47) v10(189.64,134.03) v10(189.66,118.84) v10(189.66,118.52) v10(189.85,139.64) v10(189.83,132.37) v10(189.97,136.01) v10(190.06,144.66) v10(190.3,88.26) v10(190.49,107.74) v10(190.73,139.64) v10(190.73,136.01) v10(190.68,108.03) v10(190.7,99.47) v10(190.76,144.22) v10(190.84,102.9) v10(190.94,129.81) v10(191.19,86.98) v10(191.27,100.06) v10(191.27,87.99) v10(191.62,138.26) v10(191.6,124.66) v10(191.65,108.4) v10(191.8,90.06) v10(192.03,123.74) v10(192.07,127.2) v10(192.18,90.06) v10(192.26,132.96) v10(192.44,102.93) v10(192.46,88.29) v10(192.65,125.43) v10(192.92,124.66) v10(193,121.47) v10(193.38,143.29) v10(193.35,119.65) v10(193.43,88.27) v10(193.66,127.25) v10(193.81,138.63) v10(194.29,127.25) v10(194.29,88.27) v10(194.42,133.54) v10(194.57,143.7) v10(194.57,141.7) v10(194.6,137.7) v10(194.57,121.15) v10(194.7,138.63) v10(194.78,131.27) v10(194.76,101.38) v10(194.96,120.11) v10(195.05,92.39) v10(195.05,92.01) v10(195.05,88.31) v10(195.37,141.3) v10(195.69,121.28) v10(196.15,138.64) v10(196.11,88.37) v10(196.36,137.68) v10(196.63,88.97) v10(196.67,122.46) v10(196.68,111.56) v10(196.73,86.93) v10(197.08,143.23) v10(197.1,98.04) v10(197.08,88.32) v10(197.21,90.89) v10(197.33,110.03) v10(197.34,93.02) v10(197.45,101.57) v10(197.47,91.47) v10(197.59,138.76) v10(197.68,98.56) v10(197.67,87.23) v10(197.76,104.48) v10(197.76,100.71) v10(197.76,99.96) v10(197.76,99.25) v10(197.77,88.76) v10(197.9,145.65) v10(197.87,93.48) v10(197.92,91.27) v10(198,90.58) v10(197.97,86.39) v10(198.14,137.74) v10(198.05,92.16) v10(198.33,145.64) v10(198.33,102.42) v10(198.25,101.18) v10(198.66,119.92) v10(198.66,118.78) v10(199.08,139.81) v10(199.11,111.8) v10(199.17,98.2) v10(199.17,81.01) v10(199.29,102.23) v10(199.29,101.73) v10(199.29,101.23) v10(199.29,99.37) v10(199.29,97.73) v10(199.29,96.23) v10(199.29,94.73) v10(199.29,93.23) v10(199.29,91.73) v10(199.29,90.23) v10(199.29,88.73) v10(199.29,87.23) v10(199.29,85.73) v10(199.29,84.23) v10(199.32,82.81) v10(199.46,122.36) v10(199.59,124.11) v10(199.59,123.22) v10(200.3,138.02) v10(200.54,89.37) v10(200.63,141.66) v10(200.64,99.96) v10(200.59,95.31) v10(200.59,93.96) v10(200.67,92.16) v10(200.77,90.97) v10(200.89,98.86) v10(201,145.49) v10(201.13,130.57) v10(201.09,116.33) v10(201.25,148.24) v10(201.71,146.96) v10(201.95,137.78) v10(202.34,81.08) v10(202.52,82.96) v10(202.69,116.21) v10(202.72,97.52) v10(202.75,95.41) v10(202.75,93.51) v10(202.75,91.35) v10(202.75,90.46) v10(202.67,88.48) v10(202.7,87.43) v10(202.7,86.44) v10(202.72,85.45) v10(202.75,84.31) v10(202.77,96.43) v10(202.77,94.45) v10(202.77,92.49) v10(202.77,89.47) v10(202.9,147.75) v10(202.94,139.28) v10(202.96,111.8) v10(203.38,131.3) v10(203.51,139.28) v10(203.63,147.93) v10(204.49,136.81) v10(204.79,149.64) v10(204.81,148.9) v10(204.81,148.27) v10(204.81,147.63) v10(204.77,145.21) v10(204.77,144.57) v10(204.77,143.94) v10(204.77,143.3) v10(204.81,142.71) v10(204.78,142.26) v10(204.77,141.35) v10(204.84,106.28) v10(205.92,106.36) v10(206.04,142.67) v10(206.03,113.33) v10(206.23,148.72) v10(206.66,140.62) v10(206.74,136.56) v10(207.46,141.4) v10(207.77,140.61) v10(208.25,140.64) v10(208.85,126.65) v10(209.19,140.69) v10(209.66,140.67) v10(209.77,108.94) v10(209.86,121.95) v10(210.15,140.69) v10(210.28,118.84) v10(210.39,121.94) v10(210.43,119.5) v10(211.02,140.66) v10(211.26,108.99) v10(211.54,113.52) v10(211.65,140.66) v10(212.07,135.58) v10(212.73,148.72) v10(213.66,113.25) v10(214.6,113.18) v10(215.45,113.15) v10(216.22,113.42) v10(216.33,140.36) v10(216.26,108.83) v10(217.01,140.34) v10(217.34,109.65) v10(217.43,111.92) v10(217.35,111.15) v10(217.4,108.91) v10(217.4,107.75) v10(217.4,107.17) v10(217.68,140.37) v10(217.74,110.4) v10(218.27,143.67) v10(218.41,140.36) v10(218.43,113.42) v10(218.98,123.46) v10(219.23,140.38) v10(219.23,113.3) v10(219.27,143.67) v10(219.88,113.15) v10(220.27,143.67) v10(220.35,113.17) v10(220.9,113.14) v10(221.27,143.67) v10(221.53,113.14) v10(222.11,116.64) v10(222.1,113.18) v10(222.19,123.46) v10(222.74,113.18) v10(222.82,141.35) v10(223.41,123.45) v10(223.49,141.33) v10(223.65,140.53) v10(223.74,113.38) v10(224.11,141.33) v10(224.34,140.52) v10(224.71,141.38) v10(224.77,123.8) v10(225.01,140.55) v10(225.08,122.99) v10(225.38,141.41) v10(225.74,140.53) v10(225.79,141.69) v10(226.1,141.4) v10(226.17,135.68) v10(226.33,113.39) v10(226.51,141.37) v10(226.56,140.56) v10(226.65,143.1) v10(226.83,113.38) v10(226.9,141.68) v10(226.91,118.59) v10(227.1,140.67) v10(227.12,128.29) v10(227.12,127.71) v10(227.12,125.94) v10(227.44,140.37) v10(227.68,113.3) v10(228.12,122.77) v10(228.34,113.32) v10(228.43,125.94) v10(228.93,137.15) v10(229.09,128.98) v10(229.22,119.07) v10(229.23,113.37) v10(229.81,125.75) v10(229.98,118.49) v10(229.97,113.33) v10(230.49,128.98) v10(230.8,111.13) v10(230.78,109.91) v10(230.78,109.1) v10(230.99,113.37) v10(231.5,129.76) v10(231.81,125.25) v10(232.31,125.25) v10(232.54,135.49) v10(232.62,129.32) v10(232.58,113.25) v10(232.84,134.73) v10(232.81,126.25) v10(233.03,113.25) v10(233.37,141.24) v10(234.31,128.39) v10(234.3,113.23) v10(234.27,108.97) v10(234.65,140.57) v10(234.68,116.67) v10(234.74,115.73) v10(234.68,113.24) v10(234.8,131.26) v10(235.29,140.57) v10(235.31,113.24) v10(235.44,117.09) v10(235.77,136.46) v10(235.77,135.95) v10(235.77,135.44) v10(235.77,134.81) v10(235.77,134.26) v10(235.81,126.25) v10(235.81,125.75) v10(235.92,140.57) v10(235.95,131.17) v10(235.95,113.24) v10(236.56,140.57) v10(236.58,113.24) v10(237.19,140.57) v10(237.22,113.24) v10(237.27,111.47) v10(237.83,140.57) v10(237.83,129.07) v10(237.83,126.37) v10(237.83,120.04) v10(237.85,113.24) v10(238.18,138.11) v10(238.37,124.67) v10(238.46,140.57) v10(238.49,130.93) v10(238.77,111.47) v10(238.89,136.11) v10(238.89,135.22) v10(238.86,118.72) v10(239.03,113.25) v10(239.08,141.24) v10(239.1,140.57) v10(239.72,141.24) v10(239.67,113.25) v10(239.78,140.55) v10(239.95,132.57) v10(240.3,113.28) v10(240.35,141.24) v10(240.42,140.55) v10(240.57,118.37) v10(240.66,132.67) v10(240.77,108.97) v10(241,130.04) v10(241.62,141.24) v10(241.8,123.73) v10(242.26,141.24) v10(242.39,128.98) v10(242.41,123.74) v10(242.74,126.06) v10(242.89,141.24) v10(243.05,137.45) v10(243.05,136.18) v10(243.27,141.51) v10(243.66,140.74) v10(243.78,106.05) v10(243.97,141.51) v10(244.06,133.6) v10(244.24,138.12) v10(244.21,137.41) v10(244.23,131.24) v10(244.18,129.73) v10(244.16,115.01) v10(244.23,113.9) v10(244.29,139.59) v10(244.27,138.78) v10(244.28,132.52) v10(244.27,131.88) v10(244.32,129.15) v10(244.32,113.22) v10(244.43,140.72) v10(244.52,136.83) v10(244.47,133.15) v10(244.61,141.51) v10(245.24,141.51) v10(245.88,141.51) v10(246.42,144.04) v10(246.39,126.87) v10(246.39,125.37) v10(246.39,123.87) v10(246.39,122.37) v10(246.39,120.87) v10(246.39,119.37) v10(246.39,117.87) v10(246.39,116.37) v10(246.39,109.87) v10(246.39,108.37) v10(246.51,141.51) v10(246.58,134.32) v10(246.77,107.15) v10(247.05,107.92) v10(247.07,105.7) v10(247.47,115.96) v10(247.47,115.32) v10(247.47,114.46) v10(247.47,113.83) v10(247.5,113.23) v10(247.57,141.56) v10(247.59,137.27) v10(247.58,136.57) v10(247.58,135.86) v10(247.78,107.77) v10(248.06,115.11) v10(248.08,114.54) v10(248.09,113.77) v10(248.2,141.56) v10(248.27,141.13) v10(248.69,114.4) v10(248.7,107.84) v10(248.88,141.13) v10(249.24,115.42) v10(249.19,107.07) v10(249.28,114.42) v10(249.35,107.81) v10(249.49,129.21) v10(250.7,139.35) v10(252.91,129.01) v10(253.55,134.6) v10(253.55,131.2) v10(253.75,143.45) v10(253.75,136.75) v11(249.99,130.67) v12(1.87,67.83) v12(2.01,76.88) v12(1.99,68.82) v12(1.99,66.73) v12(2.05,71.95) v12(2.18,81.29) v12(2.23,70.52) v12(2.15,65.48) v12(2.2,62.97) v12(2.17,61.08) v12(2.28,84.84) v12(2.6,89.37) v12(2.71,74.71) v12(2.88,71.57) v12(3.04,72.87) v12(3.14,69.72) v12(3.23,68.5) v12(3.3,67.29) v12(3.33,66.12) v12(3.36,62.33) v12(3.4,60.26) v12(3.49,99.21) v12(3.51,79.46) v12(3.97,72.22) v12(4.04,58.75) v12(4.53,91.61) v12(4.54,73.8) v12(4.78,81.58) v12(4.95,104.81) v12(4.95,77.01) v12(5.06,101.86) v12(5.26,43.45) v12(5.63,45.42) v12(5.76,84.58) v12(6.13,74.65) v12(6.17,96.64) v12(6.51,43.89) v12(6.78,99.31) v12(7.19,90.22) v12(7.19,87.75) v12(7.45,82.49) v12(7.88,103.45) v12(7.96,96.32) v12(7.97,79.9) v12(8.16,84.58) v12(8.31,76.94) v12(8.31,42.81) v12(8.46,38.18) v12(8.81,92.22) v12(9.25,89.76) v12(9.53,85.97) v12(9.66,40.39) v12(10.28,102.57) v12(10.8,85.76) v12(10.95,83.61) v12(10.98,81.63) v12(11.35,84.69) v12(11.44,91.41) v12(11.44,82.57) v12(11.66,87.23) v12(12.6,90.04) v12(12.59,37.13) v12(12.68,92.16) v12(14.47,91.91) v12(18.18,98.64) v12(19.02,94.53) v12(18.98,92.38) v12(20,91.08) v12(20.07,94.46) v12(20.48,84.26) v12(20.55,80.15) v12(20.72,81.69) v12(20.78,82.41) v12(21.06,83.08) v12(21.23,85.76) v12(21.24,80.82) v12(21.42,97.58) v12(21.75,82.38) v12(21.93,63.55) v12(22.05,86.42) v12(22.22,81.85) v12(22.29,85.45) v12(22.33,84.4) v12(22.36,82.98) v12(22.55,98.79) v12(22.56,100.35) v12(23.88,67.57) v12(23.88,65.06) v12(24.03,66.28) v12(24.01,63.33) v12(24.21,72.5) v12(24.61,74.39) v12(24.7,79.13) v12(24.71,77.58) v12(24.67,76.54) v12(24.68,75.69) v12(24.94,71.69) v12(24.97,79.95) v12(25.15,73.34) v12(26.27,70.24) v12(26.4,71.94) v12(26.56,73.41) v12(27.2,70.16) v12(27.26,72.25) v12(27.48,69.1) v12(27.9,73.49) v12(28.01,71.14) v12(28.12,100.5) v12(29.13,100.58) v12(30.02,27.68) v12(30.09,25.87) v12(30.36,44.03) v12(30.51,37.55) v12(30.65,26.13) v12(31.01,41.49) v12(31.18,40.04) v12(31.44,100.52) v12(31.43,38.53) v12(31.67,29.07) v12(31.82,37.6) v12(31.91,27.34) v12(32.24,40.1) v12(32.59,89.09) v12(33.28,91.16) v12(33.41,87.68) v12(33.39,28.34) v12(34.4,91.4) v12(34.87,30.42) v12(34.87,25.46) v12(35.01,88.92) v12(35.05,76.73) v12(35.05,71.65) v12(35.05,66.57) v12(35.05,61.49) v12(35.05,56.41) v12(35.06,79.81) v12(35.06,74.73) v12(35.06,69.65) v12(35.06,64.57) v12(35.06,59.49) v12(35.06,54.41) v12(35.22,92.21) v12(35.21,29.76) v12(35.36,33.21) v12(35.6,91.64) v12(35.6,90.41) v12(35.64,30.44) v12(36.05,93.04) v12(35.99,28.61) v12(36.15,88.98) v12(36.23,83.75) v12(36.24,29.76) v12(36.74,91.34) v12(36.7,34.34) v12(36.76,93.72) v12(36.84,33.27) v12(36.85,30.41) v12(36.99,26.35) v12(37.14,93.22) v12(37.05,28.75) v12(37.33,29.69) v12(37.36,90.19) v12(37.59,31.33) v12(37.89,36.15) v12(37.9,30.41) v12(37.99,74.81) v12(37.99,72.27) v12(37.99,69.73) v12(37.99,67.19) v12(37.95,64.82) v12(37.99,62.11) v12(38.02,28.53) v12(38.07,44.36) v12(38.21,42.2) v12(38.21,29.4) v12(38.33,37.47) v12(38.31,26.97) v12(38.42,94.19) v12(38.53,91.12) v12(38.73,32.43) v12(38.78,92.09) v12(38.77,31.2) v12(38.96,93.22) v12(39.34,33.84) v12(39.29,30.56) v12(39.33,28.89) v12(39.41,41.09) v12(39.41,36.25) v12(39.39,29.69) v12(39.63,86.27) v12(39.63,43.48) v12(39.63,38.74) v12(39.69,31.72) v12(39.69,26.34) v12(39.95,95.37) v12(40.25,92.13) v12(40.58,94.25) v12(40.82,91.07) v12(41.28,93.41) v12(41.8,91.52) v12(42.28,95.52) v12(42.6,93.88) v12(42.94,90.99) v12(42.96,92.57) v12(43.15,91.48) v12(43.56,93.49) v12(44.41,92.53) v12(44.47,95.31) v12(44.53,91.59) v12(44.47,85.92) v12(44.57,101.84) v12(45.01,90.09) v12(45.28,93.46) v12(46.09,92.51) v12(46.18,95.31) v12(46.82,91.32) v12(46.82,90.68) v12(46.88,93.44) v12(47.14,102.4) v12(47.39,95.41) v12(47.91,92.46) v12(47.99,90.86) v12(48.06,89.56) v12(48.87,93.46) v12(49.04,95.37) v12(49.5,91.32) v12(49.59,90.13) v12(49.96,87.6) v12(50.34,93.17) v12(50.3,89.38) v12(50.43,92.08) v12(50.78,87) v12(51.04,88.56) v12(51.74,87.6) v12(51.73,86.69) v12(52.33,147.62) v12(52.32,89.09) v12(52.86,148.52) v12(52.98,87.05) v12(52.97,84.78) v12(53.74,88.58) v12(53.8,86.63) v12(53.87,87.56) v12(54.22,147.63) v12(54.58,93.86) v12(54.76,84.12) v12(54.87,148.52) v12(54.89,89.08) v12(54.96,85.42) v12(55.21,86.95) v12(55.75,147.63) v12(55.72,84.22) v12(56.24,84.75) v12(56.34,148.51) v12(56.43,88.51) v12(56.54,87.65) v12(56.48,86.18) v12(57.22,148.66) v12(57.37,93.8) v12(57.47,147.66) v12(57.69,149.16) v12(57.75,87) v12(57.68,84.36) v12(57.77,85.62) v12(58.12,96.82) v12(58.13,89.08) v12(58.25,148.47) v12(58.49,90.6) v12(58.92,84.75) v12(58.9,83.67) v12(59,92.57) v12(59.05,87.57) v12(58.99,86.29) v12(59.28,93.76) v12(59.45,88.51) v12(59.85,91.23) v12(59.85,86.07) v12(59.88,87.57) v12(60.33,89.09) v12(60.42,86.8) v12(60.51,92.85) v12(60.5,84.93) v12(60.52,83.65) v12(60.61,91.53) v12(60.88,90.74) v12(60.99,92.65) v12(61.56,87.49) v12(61.75,88.18) v12(61.95,91.78) v12(61.99,85.56) v12(62.12,83.71) v12(63.03,90.88) v12(63.08,89.35) v12(63.7,90.09) v12(63.81,84.24) v12(64.38,87.89) v12(64.64,89.25) v12(64.81,83.72) v12(65.01,86.3) v12(65.21,85.18) v12(65.43,84.31) v12(65.7,89.86) v12(65.75,88.44) v12(66.2,89.34) v12(66.3,87.39) v12(66.58,104.66) v12(66.74,103.39) v12(67.15,100.57) v12(67.64,88.42) v12(68.19,103.11) v12(68.22,86.19) v12(68.25,85.47) v12(68.58,87.47) v12(68.78,84.28) v12(68.87,89.29) v12(69.4,89.78) v12(69.51,86.07) v12(69.72,85.2) v12(70.08,88.38) v12(70.66,84.45) v12(70.83,87.49) v12(70.76,86.33) v12(71.96,89.34) v12(72.05,86.31) v12(72.35,89.76) v12(72.57,89.37) v12(72.76,87.44) v12(72.86,84.64) v12(73.39,86.44) v12(74.13,88.38) v12(74.37,86.07) v12(75,84.66) v12(75.32,120.37) v12(75.57,89.28) v12(75.63,85.58) v12(76.24,89.39) v12(76.17,87.47) v12(76.54,88.42) v12(76.73,84.38) v12(76.99,85.99) v12(77.07,87.11) v12(77.17,121.22) v12(77.79,88.15) v12(77.9,85.29) v12(78.07,122.97) v12(78.81,121.12) v12(78.93,87.12) v12(79.11,124.75) v12(79.83,84.39) v12(80.15,86.07) v12(80.32,125.92) v12(80.82,87.12) v12(81.12,85.24) v12(81.7,88.07) v12(81.79,86.02) v12(81.95,84.37) v12(82.15,85.37) v12(82.54,87.15) v12(82.83,86.07) v12(82.99,88.88) v12(83.08,127.5) v12(83.56,85.25) v12(83.93,88.05) v12(83.88,87.34) v12(84.07,86.43) v12(84.25,84.39) v12(84.26,128.46) v12(85,85.59) v12(85.06,87.31) v12(85.13,86.43) v12(85.17,127.69) v12(86.09,88.08) v12(86.19,88.62) v12(86.15,86.44) v12(86.16,85.66) v12(86.45,87.31) v12(86.72,84.4) v12(87.16,87.89) v12(87.62,127.68) v12(87.83,85.86) v12(87.91,86.84) v12(88.77,84.42) v12(89.11,86.85) v12(89.19,85.85) v12(89.7,87.58) v12(90.16,85.88) v12(90.39,86.82) v12(91.29,85.89) v12(91.34,84.43) v12(91.64,87.58) v12(91.86,86.83) v12(92.51,85.91) v12(92.48,85.25) v12(93.06,97.86) v12(93.15,86.84) v12(93.66,84.39) v12(94.32,98.62) v12(94.33,87.58) v12(94.67,86.81) v12(94.96,84.41) v12(96.02,110.73) v12(96.2,84.39) v12(96.35,85.84) v12(96.49,86.76) v12(96.55,99.35) v12(96.68,87.58) v12(96.73,85.29) v12(96.78,106.08) v12(97.44,84.39) v12(97.52,86.85) v12(97.8,97.47) v12(98.34,103.3) v12(98.29,100.59) v12(98.51,97.19) v12(98.94,84.35) v12(99.27,87.52) v12(99.52,85.62) v12(99.57,98.66) v12(100.57,84.35) v12(100.71,85.24) v12(101.63,87.5) v12(101.57,85.61) v12(101.87,84.28) v12(102,131.72) v12(102.43,86.21) v12(102.45,83.68) v12(102.66,84.74) v12(102.85,87.08) v12(103.33,87.89) v12(103.44,85.16) v12(103.68,85.93) v12(103.98,88.51) v12(104.03,86.94) v12(104.04,83.59) v12(104.61,85.05) v12(105.34,87.88) v12(105.79,83.58) v12(106,86.95) v12(106.14,88.6) v12(106.67,87.84) v12(106.78,86.91) v12(107.11,83.59) v12(107.26,84.98) v12(107.97,87.22) v12(108.83,83.72) v12(109.45,84.07) v12(110.18,131.78) v12(110.4,84.07) v12(111.26,131.53) v12(111.39,132.53) v12(111.59,84.07) v12(112.77,84.06) v12(113.83,84.06) v12(115,136.61) v12(115.06,84.06) v12(116.1,84.06) v12(116.24,136.46) v12(116.58,87.41) v12(117.38,84.03) v12(117.65,87.16) v12(117.86,88.83) v12(118.73,87.45) v12(118.78,84.05) v12(119.7,88.4) v12(119.67,84.11) v12(120.18,85.66) v12(120.5,86.61) v12(120.67,84.06) v12(121.7,85.67) v12(121.94,86.6) v12(122.2,136.45) v12(122.64,87.07) v12(122.64,84.1) v12(122.69,87.75) v12(123.41,86.55) v12(123.46,85.99) v12(124.15,84.16) v12(124.17,87.79) v12(124.56,86.6) v12(124.68,85.12) v12(126.18,86.71) v12(126.81,87.3) v12(127.65,88.92) v12(128.02,88.17) v12(128.75,89.96) v12(128.98,89.15) v12(132.56,89.77) v12(132.67,90.93) v12(133.86,91.55) v12(137.89,90.39) v12(145.38,137.64) v12(148.2,137.4) v12(150.03,137.4) v12(153.75,137.43) v12(154.08,108.97) v12(155.19,137.24) v12(156.22,106.38) v12(157.64,107.91) v12(157.79,106.15) v12(158.58,109.51) v12(161.12,107.35) v12(161.63,136.2) v12(161.87,136.79) v12(162.93,136.83) v12(163.82,136.8) v12(165.47,136.86) v12(166.55,136.83) v12(167.86,136.85) v12(168.7,136.85) v12(171.1,136.86) v12(172.49,136.84) v12(173.91,136.34) v12(174.61,136.13) v12(176.38,136.1) v12(177.39,136.16) v12(178.29,136.16) v12(179.14,136.19) v12(180.55,136.86) v12(181.88,136.84) v12(182.8,136.86) v12(187.52,138.7) v12(187.81,139.31) v12(188.35,137.49) v12(190.3,139.37) v12(191.71,140.62) v12(192.87,142.5) v12(192.92,141.09) v12(193.35,142.2) v12(198.96,119.07) v12(199.19,121.65) v12(199.93,120.87) v12(199.97,120.1) v12(200.17,122.07) v12(201.19,122.94) v12(201.72,122.11) v12(211.84,146.9) v12(230.56,125.59) v14(19.28,74.61) v14(33.53,18.91) v14(50.93,143.39) v14(67.14,79.89) v14(74.45,149.16) v14(78.71,110.99) v14(81.49,80.69) v14(89.77,80.22) v14(102.27,124.19) v14(111.79,132.91) v14(117.42,79.71) v14(138.33,119.03) v14(152.2,134.12) v14(190.43,96.66) v14(197.75,118.25) v15(247.5,135.85) v16(123.98,107.54) v17(118.42,105.33) v17(118.47,102.26) v17(119.06,102.26) v17(119.56,106.62) v17(119.61,102.26) v17(120.15,107.83) v17(120.12,106.64) v17(120.17,100.97) v17(121.27,107.84) v17(121.34,100.97) v17(122.51,100.97) v17(122.97,104.12) v17(124.21,107.09) v17(124.24,105.98) v17(124.16,104.88) v17(124.24,103.74) v17(124.24,102.62) v17(124.24,101.33) v17(126.07,107.92) v17(126.07,106.8) v17(126.07,106.24) v17(126.07,105.13) v17(126.07,104.01) v17(126.07,102.89) v17(126.07,101.77) v17(126.07,100.66) v17(126.7,108.09) v17(127.26,106.88) v17(127.26,105.76) v17(127.26,104.17) v17(127.27,102.98) v20(18.9,97.18) v20(19.37,96.43) v20(19.55,95.89) v20(20.34,98.28) v20(20.29,96.49) v20(20.43,97.24) v20(20.89,99.12) v20(21.01,98.19) v20(21.1,97.37) v20(21.98,98.14) v20(22.31,100.44) v20(24.8,21.56) v20(25.65,23.63) v20(26.08,26.13) v20(26.7,25.95) v20(26.68,20.73) v20(27.51,26.23) v20(27.92,24.15) v20(32.11,41.08) v20(32.7,21.57) v20(33.23,18.75) v20(33.56,39.31) v20(34.35,33.6) v20(34.4,35.94) v20(34.59,30.28) v20(34.89,40.88) v20(34.86,37.32) v20(35.11,28.15) v20(35.43,21.65) v20(35.57,34.96) v20(35.6,31.78) v20(36.76,22.44) v20(38.14,36.47) v20(38.82,41.26) v20(39.22,37.88) v20(39.26,106.89) v20(39.31,105.24) v20(39.64,39.53) v20(39.67,32.96) v20(39.78,106.15) v20(39.91,104.83) v20(39.87,35.92) v20(40.18,106.92) v20(40.56,105.34) v20(64.65,90.15) v20(65.51,89.35) v20(66.38,90.06) v20(68.65,89.28) v20(69.51,90) v20(71.81,89.3) v20(72.87,89.96) v20(75.25,89.2) v20(90.62,136.94) v20(91.95,136.96) v20(93.4,136.93) v20(94.8,136.88) v20(96.27,136.83) v20(97.24,137.4) v20(98.75,137.4) v20(100.54,137.4) v20(101.59,137.45) v20(102.19,137.75) v20(107.78,135.94) v20(109.48,136) v20(110.98,135.81) v20(118.01,129.55) v20(118.12,130.25) v20(123.97,135.72) v20(126.43,135.69) v20(127.55,134.02) v20(127.58,131.76) v20(127.95,130.81) v20(128.3,135.12) v20(128.96,130.15) v20(129.25,133.71) v20(129.6,132.01) v20(130.27,131.06) v20(130.59,133.09) v20(131.59,131.87) v20(132.01,130.91) v20(132.98,131.54) v20(134.17,131.14) v20(135.26,131.52) v20(136.79,131.25) v20(138.17,131.76) v20(139.68,132.14) v20(140.7,133.14) v20(141.08,134.08) v20(141.66,134.77) v20(144.06,136.94) v20(173.86,137.04) v20(174.43,136.28) v20(174.95,136.85) v20(176.47,136.8) v20(176.84,135.89) v20(177.58,136.61) v20(178.03,135.91) v20(178.68,136.67) v20(179.65,137.6)
