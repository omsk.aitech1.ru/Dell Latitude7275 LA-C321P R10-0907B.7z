# Allegro board LAC321PR10-0907B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.2V_VDDQ on TOP (solid shape): 92.98,102.11 93.9,102.11 93.94,102.07 93.94,101.64 93.8,101.49 92.1,101.49 91.99,101.61 91.99,102.29 92.05,102.35 92.73,102.35
+1.2V_VDDQ on BOTTOM (solid shape): 152.57,124.75 152.57,121.95 152.32,121.7 150.67,121.7 150.41,121.95 150.41,124.75 150.79,125.13 152.19,125.13
+1.2V_VDDQ on TOP: 135.17,84.09 131.51,84.09 131.31,84.3 131.31,84.97 131.44,85.1 133.22,85.1 134.6,86.48 135.19,86.48 135.58,86.87 138.23,86.87 138.52,87.16 140.94,87.16 141.03,87.06 141.03,85.51 140.99,85.48 139.92,85.48 139.67,85.22 139.67,84.78 139.51,84.62 138.39,84.62 137.99,85.02 136.1,85.02
+1.2V_VDDQ on TOP: outline of 131 points within 99.39,104.93 138.5,130.01 ; 5 cut-outs
+1.2V_VDDQ on TOP: 101.83,89.31 102.72,89.31 102.98,89.06 102.98,88.04 102.22,87.28 101.58,87.28 101.45,87.41 101.45,88.17 101.71,88.43 101.71,89.19
+1.2V_VDDQ on GND2: 104.99,104.68 101.94,107.73 100.8,107.73 99.55,108.98 99.55,117.66 102.7,120.81 103.21,120.81 106.64,124.24 118.2,124.24 124.8,130.84 126.62,130.84 127.26,130.21 136.4,130.21 137.86,128.75 139.03,128.75 139.54,129.26 141.16,129.26 141.54,128.88 143.7,128.88 144.21,128.37 146.64,128.37 148.23,129.95 150.43,129.95 150.82,129.57 153.05,129.57 153.06,129.57 153.67,129.57 154.03,129.21 154.03,125.79 154.67,125.15 154.67,124.34 153.52,123.2 153.52,119.65 148.97,115.1 135.26,115.1 133.71,113.55 133.71,112.41 129.92,108.62 121.29,108.62 119.61,106.95 119.61,104.91 119.38,104.68
+1.2V_VDDQ_S on BOTTOM (solid shape): 155.05,124.94 155.05,121.06 154.79,120.81 152.51,120.81 152.38,120.94 152.38,121.45 152.76,121.83 152.76,122.4 153.33,122.4 153.33,123.8 152.76,123.8 152.76,124.81 153.14,125.19 154.79,125.19
+1.2V_VDDQ_S on TOP: 149.97,126.02 153.42,126.02 154.9,124.54 154.9,119.62 154.74,119.47 153.72,119.47 153.5,119.69 150.16,119.69 149.92,119.94 149.92,125.97
+1.8V_MEM on TOP (solid shape): 100.69,113.32 100.69,112.68 100.56,112.56 99.17,112.56 99.04,112.68 99.04,113.44 99.17,113.57 100.44,113.57
+1.8V_MEM on TOP (solid shape): 101.45,123.1 101.45,122.33 100.95,121.83 99.68,121.83 99.42,122.08 99.42,122.59 99.68,122.84 100.31,122.84 100.82,123.35 101.2,123.35
+1.8V_MEM on TOP: 176.51,135.54 176.51,134.78 176.38,134.65 176.13,134.65 176.1,134.68 176.1,135.16 176.08,135.19 175.67,135.19 175.65,135.16 175.65,134.68 175.6,134.63 175.37,134.63 175.24,134.76 175.24,134.78 174.73,135.29 174.73,136.43 175.11,136.81 175.75,136.81 176,136.56 176,136.05
+1.8V_MEM on BOTTOM: 120.25,120.56 125.84,120.56 126.09,120.3 126.09,118.65 125.71,118.27 119.74,118.27 119.36,118.65 119.36,119.67
+1.8V_MEM on IN2: 124.34,132.86 122.99,132.86 120.35,130.22 120.35,129.52 116.69,125.87 109.49,125.87 109.34,125.71 109.34,125.69 109.16,125.51 103.99,125.51 102.47,123.99 100.44,123.99 98.91,122.46 98.91,120.05 98.02,119.16 98.02,113.83 99.17,112.68 100.18,112.68 100.56,113.06 100.56,114.21 100.06,114.71 100.06,118.27 101.71,119.92 102.85,119.92 103.36,120.43 103.74,120.43 104.12,120.81 104.12,122.33 106.15,124.37 112.92,124.37 118.5,118.79 119.84,118.79 120.26,119.21 120.26,125.84 124.83,130.4 130.37,130.4 133.67,127.1 133.67,125.87 135.71,123.83 135.71,122.94 136.3,122.35 136.3,118.18 135.77,117.65 135.77,117.57 136.2,117.14 136.72,117.14 137.12,117.53 137.12,118.59 137.88,119.35 137.88,125.28 138.2,125.6 138.2,128.64 136.65,130.18 132.14,130.18 130.38,131.94 128.99,131.94 128.29,132.65 126.61,132.65 126.22,132.25 124.95,132.25
+1.8V_MEM_S on TOP (solid shape): 175.98,135.03 175.98,134.55 176.03,134.5 176.41,134.5 177.4,133.51 177.4,131.35 177.27,131.22 175.49,131.22 175.24,131.48 175.24,132.75 174.35,133.64 173.59,133.64 173.34,133.89 173.34,134.4 173.46,134.53 175.72,134.53 175.77,134.58 175.77,135.03 175.8,135.06 175.95,135.06
+1.8V_PCH_GPP on BOTTOM (solid shape): 133.33,104.68 133.33,104.17 132.95,103.79 132.31,103.79 132.06,104.05 132.06,104.81 132.31,105.06 132.95,105.06
+1.8V_PCH_GPP on TOP: 137.97,107.73 138.07,107.63 138.07,106.83 137.95,106.71 136.12,106.71 135.87,106.97 135.36,106.97 135.24,106.84 135.11,106.84 134.98,106.97 134.98,107.09 135.62,107.73
+1.8V_PRIM on TOP: 139.43,130.08 140.61,130.08 140.72,129.97 140.72,129.06 140.64,128.98 140.37,128.98 140.31,128.93 140.31,128.42 140.12,128.23 139.7,128.23 139.51,128.42 139.51,129.09 139.36,129.24 139.36,130.01
+1.8V_PRIM on TOP: 171.94,136.81 171.94,136.3 172.35,135.9 172.35,135.44 172.29,135.39 171.84,135.39 171.79,135.34 171.79,135.21 171.84,135.16 172.19,135.16 172.32,135.03 172.32,134.78 172.45,134.65 173.21,134.65 173.34,134.78 173.34,136.56 172.89,137 172.13,137
+1.8V_PRIM on TOP: 138.92,106.66 139.43,106.66 139.53,106.76 139.53,107.32 139.53,107.33 139.53,107.51 139.65,107.63 140.16,107.63 140.38,107.41 141.01,107.41 141.27,107.67 141.55,107.67 141.71,107.83 141.71,108.42 141.64,108.49 141.26,108.49 141.02,108.26 139.81,108.26 139.52,107.96 138.89,107.96 138.71,107.77 138.71,106.87
+1.8V_PRIM on BOTTOM: 139.17,107.98 139.55,107.98 139.93,108.36 140.19,108.36 140.7,108.87 141.46,108.87 141.46,108.49 140.7,107.73 139.93,107.73 139.68,107.48 139.68,106.84 139.55,106.71 139.17,106.71 139.05,106.84 139.05,107.86
+1.8VA_S on TOP (solid shape): 172.24,135.8 172.24,135.57 172.19,135.52 171.74,135.52 171.68,135.47 171.68,135.09 171.71,135.06 172.19,135.06 172.24,135.01 172.24,134.58 171.94,134.27 169.78,134.27 169.4,133.89 169.4,133.1 169.24,132.94 167.05,132.94 166.73,133.26 166.73,135.42 167.49,136.18 171.86,136.18
+1.8VS on TOP: 141.25,125.76 142.52,125.76 142.74,125.54 142.74,124.99 142.64,124.89 141.33,124.89 141.22,125 141.22,125.73
+1.8VS_AUDIO on IN3: 12.56,60.54 11.13,60.54 10.94,60.35 10.94,60.06 11.06,59.94 12.59,59.94 12.64,59.99 12.64,60.47
+1.8VS_AUDIO_AMP on TOP: 197.16,122.92 197.72,122.92 197.92,123.12 197.97,123.12 198.46,123.6 198.99,123.6 199.12,123.48 199.12,122.97 199.08,122.93 199.12,122.89 199.12,122.72 198.81,122.41 198.3,122.41 197.97,122.08 197.97,121.72 197.67,121.42 196.98,121.42 196.96,121.45 196.96,122.72
+1.8VS_AUDIO_AMP on IN1: 199.12,124.11 200.26,124.11 200.44,123.93 200.44,123.7 199.66,122.92 198.46,122.92 198.35,123.02 198.35,123.35
+3.3V_PCH_GPP on TOP: 135.11,109.13 137.01,109.13 137.14,109 137.99,109 138.07,108.92 138.07,108.1 137.95,107.98 135.62,107.98 135.49,107.86 135.36,107.86 134.98,108.24 134.98,109
+3.3V_PCH_GPP on TOP: 135.36,103.67 137.04,103.67 137.27,103.89 137.65,103.89 137.78,103.76 137.78,103.03 137.65,102.9 135.74,102.9 135.62,103.03 135.11,103.03 134.98,103.16 134.98,103.28
+3.3V_PCH_GPP on TOP: 135.03,105.88 135.31,105.88 135.49,105.7 136.79,105.7 136.89,105.6 136.89,104.83 136.66,104.6 135.44,104.6 134.98,105.06 134.98,105.16 135.11,105.29 135.11,105.55 134.98,105.67 134.98,105.82
+3.3VDX_SSD on TOP: 194.67,106.84 194.67,106.46 194.42,106.21 193.02,106.21 192.77,106.46 192.77,107.48 193.5,108.21 193.51,108.21 193.67,108.38 193.68,108.38 193.86,108.56 194.65,108.56 194.95,108.25 194.95,107.12
+3.3VDX_SSD on TOP: 200.39,106.08 199.75,105.44 199.75,103.54 200.51,102.78 202.29,102.78 202.8,102.27 202.8,101.25 202.16,100.62 200.89,100.62 200.26,101.25 200.26,102.27 199.88,102.65 198.61,102.65 198.23,103.03 198.23,105.82 199.75,107.35 203.56,107.35 204.45,108.24 204.96,108.24 205.3,108.58 205.3,110.61 205.85,111.16 206.99,111.16 207.24,110.9 207.24,110.27 207.25,110.26 207.25,107.4 206.78,106.93 204.75,106.93 203.9,106.08
+3.3VDX_SSD on BOTTOM: 197.97,107.6 196.96,107.6 196.07,108.49 194.08,108.49 193.53,107.94 193.53,101.63 193.78,101.38 195.94,101.38 196.83,100.49 202.29,100.49 202.8,101 202.8,102.52 202.42,102.9 200.64,102.9 199.88,103.67 199.88,105.7
+3.3VDX_SSD on BOTTOM: 198.69,88.04 198.69,89.14 198.74,89.19 200.03,89.19 201.05,88.17 201.48,88.17 201.73,88.43 202.42,88.43 202.8,88.04 202.8,83.98 202.29,83.47 201.02,83.73 200.89,83.98
+3.3VDX_SSD on VCC: 197.59,80.81 197.59,101.76 198.35,102.52 202.93,102.52 202.93,101.44 202.93,101.44 202.93,83.44 202.93,83.44 202.93,83.19 202.89,83.07 202.8,82.98 202.43,82.25 202.95,81.61 202.95,81.04 202.72,80.81
+3V_1.8V_HDA on TOP: 141.65,110.33 140.95,110.33 140.82,110.21 140.82,109.43 140.39,109 140.32,109 140.25,108.94 140.25,108.43 140.32,108.36 140.89,108.36 140.95,108.43 140.95,108.72 141.36,109.13 141.59,109.13 141.78,109.32 141.78,110.21
+3V_PRIM on TOP (solid shape): 182.62,118.47 183.86,118.47 183.99,118.35 183.99,117.65 183.86,117.52 182.25,117.52 181.58,118.19 181.58,118.8 181.67,118.89 182.2,118.89
+3V_PRIM on BOTTOM (solid shape): 138.62,103.01 138.62,102.44 138.75,102.31 140.02,102.31 140.13,102.21 140.13,101.98 140.04,101.89 139.3,101.89 139.21,101.8 139.21,100.72 139.19,100.69 138.82,100.69 138.79,100.72 138.79,101 138.54,101.25 138.16,101.25 138.03,101.38 138.03,102.42 138.16,102.55 138.16,102.99 138.2,103.03 138.6,103.03
+3V_PRIM on IN3 (solid shape): 150.62,104.67 150.62,104.49 150.38,104.24 150.03,104.24 148.41,102.62 148.25,102.62 148.03,102.84 148.03,103.04 148.61,103.62 148.61,103.91 149.6,104.9 150.39,104.9
+3V_PRIM on TOP: 102.88,98.18 101.57,98.18 101.5,98.24 101.5,99.3 101.64,99.44 102.85,99.44 102.99,99.3 102.99,98.29
+3V_PRIM on TOP: 140.19,110.59 138.98,110.59 138.79,110.4 138.79,110.17 139.24,109.73 139.24,109.44 138.73,108.94 138.73,108.11 138.79,108.05 139.43,108.05 140.14,108.76 140.14,109.01 140.51,109.38 140.51,110.27
+3V_PRIM on TOP: 202.76,138.9 203.71,138.9 203.75,138.85 203.75,138.73 203.94,138.54 205.87,138.54 206.23,138.18 206.23,136.08 206.07,135.91 205.41,135.91 205.02,135.52 203.77,135.52 203.64,135.64 203.64,136.3 203.71,136.38 204.73,136.38 204.78,136.43 204.78,137.18 204.69,137.27 202.6,137.27 202.52,137.35 202.52,138.4 202.72,138.6 202.72,138.85
+3V_PRIM on BOTTOM: 182.23,117.64 182.1,117.76 182.1,118.27 182.72,118.89 183.91,118.89 184.08,118.73 184.08,118.39 184.27,118.19 185.05,118.19 185.12,118.11 185.12,117.73 185.02,117.64
+3V_PRIM on IN1: 141.59,109.19 139.74,109.19 139.43,108.87 139.43,108.62 139.68,108.36 141.4,108.36 141.71,108.68 141.71,109.06
+3V_SKYCAM on TOP: 194.29,148.62 194.67,148.62 194.93,148.37 194.93,145.19 194.8,145.07 194.29,145.07 193.99,145.37 193.99,148.56 194.06,148.62 194.29,148.62
+3V_SKYCAM on TOP: 94.54,129.23 94.54,127.67 94.44,127.58 93.98,127.58 93.52,128.04 92.23,128.04 92.14,128.12 92.14,128.36 92.91,129.13 92.91,129.54 92.96,129.59 94.17,129.59
+3V_SKYCAM on BOTTOM: 195.98,140.88 194.04,140.88 193.91,141 193.91,142.27 194.04,142.4 195.05,142.4 195.31,142.65 195.31,143.16 195.94,143.16 195.94,143.8 195.81,143.92 194.8,143.92 194.42,143.54 193.91,143.54 193.66,143.8 193.66,145.28 193.96,145.59 196.77,145.59 196.92,145.44 196.92,142.62 196.92,142.61 196.92,141.82
+3V_TBT on TOP: 18.68,31.05 19.82,31.05 20.16,31.39 20.71,31.39 20.8,31.3 20.8,31.04 20.75,30.99 20.54,30.99 20.39,30.84 20.39,30.62 20.32,30.55 20.15,30.55 19.32,29.73 16.15,29.73 15.88,29.99 15.88,32.18 15.27,32.79 15.27,33.56 15.29,33.58 16.12,33.58 16.17,33.52 16.17,32.67 16.62,32.23 16.62,31.61 16.85,31.38 17.38,31.38 17.51,31.25 17.51,31.15 17.76,30.89 18.52,30.89
+3V_TBT on BOTTOM: 18.56,31.05 19.51,31.05 19.7,30.86 19.7,29.86 19.88,29.68 19.88,25.73 17.67,23.52 16.87,23.52 16.72,23.68 16.72,25.32 18.42,27.02 18.42,30.91
+3V_TBT on GND1: 18.98,23.15 18.59,23.15 17.69,24.05 17.69,24.21 17.93,24.45 18.11,24.45 18.2,24.54 18.44,24.54 19.28,23.69 19.28,23.45
+3V_TBT on IN3: 28.98,37.26 28.77,37.29 28.58,37.18 28.5,37.15 28.18,37.3 27.85,37.15 27.53,37.3 27.2,37.15 27.13,37.18 27.1,37.21 27.06,37.29 27.21,37.61 27.06,37.94 27.1,38.01 26.88,38.59 26.66,38.01 26.69,37.94 26.55,37.61 26.7,37.29 26.66,37.21 26.65,36.73 27.13,36.75 27.2,36.78 27.28,36.75 27.31,36.72 27.34,36.64 27.31,36.56 27.22,36.43 27.2,36.26 27.2,36.23 26.74,35.77 25.12,35.77 24.63,35.27 24.6,35.25 24.2,34.85 24.2,36.3 23.69,36.3 23.69,34.37 23.72,34.37 23.52,34.16 23.52,33.95 23.49,33.93 23.49,33.83 23.48,33.82 23.48,32.8 20.39,29.71 18.56,29.71 18.41,29.86 18.41,33.49 19.22,34.3 19.22,37.92 21.21,39.9 21.61,40.3 24.81,40.3 25.24,40.73 31.04,40.73 33.72,38.05 33.72,28.6 33.18,28.05 30.82,28.05 30.62,28.26 30.62,36.79 30.15,37.26 ; 5 cut-outs
+3V_TBT on GND4: 18.41,24.55 18.22,24.55 18.17,24.5 17.36,24.5 17.06,24.2 17.06,23.69 17.11,23.63 17.92,23.63 18.52,24.23 18.52,24.43
+3V_TBT_SX on TOP: 20.66,25.2 20.54,25.08 20.54,24.35 20.73,24.16 20.73,22.19 20.76,22.16 21.34,22.16 21.41,22.22 21.41,22.86 21.6,23.05 21.9,23.05 21.96,23.11 21.96,24.89 21.65,25.2
+3V_TBT_SX on BOTTOM: 20.68,30.4 22.08,30.4 22.21,30.27 22.21,29.69 22.12,29.6 21.09,29.6 20.66,30.03 20.66,30.37
+3VA_S on TOP (solid shape): 183.56,123.85 183.56,122.32 183.7,122.18 183.7,121.94 183.56,121.8 183.56,119.57 183.74,119.39 183.74,118.64 183.71,118.61 183.42,118.61 183.42,119.12 183.04,119.12 183.04,118.61 182.65,118.61 182.16,119.1 182.16,120.54 181.92,120.78 179.84,120.78 179.75,120.87 179.75,121.41 179.88,121.53 180.64,121.53 180.89,121.79 180.89,123.82 181.11,124.04 183.37,124.04
+3VALW on TOP (solid shape): 235.62,138.15 235.62,137.27 235.13,136.79 235.13,136.14 235.06,136.06 234.23,136.06 233.67,136.62 233.67,137.16 233.55,137.28 233.33,137.28 233.32,137.3 233.32,137.98 233.65,138.31 235.45,138.31
+3VALW on TOP: 24.87,66.45 24.87,67.08 24.8,67.15 24.43,67.15 24.29,67.29 24.29,68.17 24.21,68.25 21.43,68.25 21.19,68 21.19,66.71 21.38,66.52 23.27,66.52 23.41,66.38 24.8,66.38
+3VALW on TOP: 192.51,102.27 193.66,102.27 194.42,101.51 194.42,100.87 194.29,100.74 193.53,100.74 193.47,100.8 192.44,100.8 192.26,100.99 192.26,102.01
+3VALW on TOP: 190.99,101.04 190.92,100.98 190.92,100.64 190.65,100.36 190.35,100.36 190.23,100.49 190.23,102.14 190.23,102.15 190.23,102.25 190.27,102.3 190.9,102.3 190.99,102.21
+3VALW on TOP: 33.13,95.92 33.25,95.79 33.25,95.41 33.59,95.08 33.59,94.19 33.51,94.12 32.77,94.12 32.62,94.27 32.62,94.38 31.71,95.3 31.71,95.66 31.96,95.92
+3VALW on TOP: 169.78,103.72 169.78,101.1 169.65,100.97 166.25,100.97 165.97,101.25 165.97,101.74 166.1,101.87 167.22,101.87 167.29,101.93 167.29,103.17 167.56,103.44 168.26,103.44 168.74,103.92 169.58,103.92
+3VALW on TOP: 192.89,129.45 193.78,129.45 193.91,129.32 193.91,127.67 193.78,127.54 193.38,127.54 193.02,127.19 192.79,127.19 192.72,127.29 192.39,128.07 192.39,128.94
+3VALW on TOP: 98.53,88.55 99.93,88.55 100.18,88.3 100.18,87.54 99.93,87.28 99.29,87.28 98.91,87.66 98.53,87.66 98.28,87.92 98.28,88.3
+3VALW on TOP: 180.57,106.97 181.05,107.44 185.42,107.44 187,105.86 187,105.47 187.02,105.44 187.81,105.44 187.94,105.32 187.94,104.94 187.81,104.81 186.6,104.81 185.97,105.44 180.96,105.44 180.57,105.82
+3VALW on TOP: 34.96,94.17 34.96,95.64 35.54,96.22 36,96.22 36.02,96.2 36.02,95.84 36.46,95.41 36.46,94.79 36.25,94.59 36.25,94.34 36.02,94.12 35.01,94.12
+3VALW on GND1: 190.95,100.19 190.68,99.92 190.22,99.92 190.04,100.1 190.04,100.25 190.29,100.5 190.29,100.63 190.29,100.63 190.29,100.78 190.67,101.16 192.16,101.16 192.68,101.68 193.19,101.68 193.34,101.53 193.34,100.92 192.61,100.19
+3VALW on GND1: 31.64,96.16 33.84,96.16 33.93,96.07 33.93,95.49 33.83,95.39 33.66,95.39 33.46,95.18 31.62,95.18 31.53,95.27 31.53,96.05
+3VALW on IN3: 17.34,50.07 17.34,56.6 17.39,56.78 17.34,56.95 17.34,57.29 17.36,57.39 17.34,57.48 17.34,57.89 17.36,57.98 17.34,58.08 17.34,58.52 17.34,58.56 17.34,58.6 17.34,64.47 20.56,67.69 20.59,67.69 21.13,68.23 21.63,68.23 21.64,68.23 21.89,68.23 22.28,67.84 22.28,67 18.54,63.26 18.54,51.86 19.41,50.99 19.41,50.06 19.18,49.83 17.59,49.83
+3VALW on IN3: 193.15,128.43 195.31,126.27 197.21,126.27 198.74,127.8 200.77,127.8 202.04,126.53 202.04,122.84 201.91,122.72 201.16,122.72 199,124.87 194.93,124.87 192.51,127.29 192.51,128.3 192.64,128.43
+3VALW on GND4: 33.99,96.62 31.79,96.62 31.69,96.52 31.69,95.6 31.82,95.47 33.76,95.47 34.07,95.78 34.07,96.54
+3VALW on VCC: outline of 128 points within 12.17,58.45 255.38,150.65 ; 2 cut-outs
+3VALW_DSW on TOP (solid shape): 199.92,138.15 199.92,137.81 200.08,137.65 200.47,137.65 200.52,137.6 200.52,137.28 200.33,137.08 199.75,137.08 199.33,136.67 199.04,136.67 198.96,136.75 198.96,138.08 199.08,138.2 199.86,138.2
+3VALW_DSW on TOP: 192.89,134.53 193.66,134.53 193.91,134.27 193.91,133.64 193.53,133.26 192.26,133.26 192,133 192,131.35 192.89,130.46 192.89,129.57 192.64,129.32 192.13,129.32 191.25,130.81 190.99,131.43 190.99,133.38 191.5,133.89 192.64,133.89 192.77,134.02 192.77,134.4
+3VALW_DSW on TOP: 224.26,125.89 226.42,125.89 226.68,125.64 226.68,124.75 226.29,124.37 224.39,124.37 224.14,124.62 224.14,125.76
+3VALW_DSW on TOP: 63.75,142.21 62.68,142.21 62.57,142.1 62.57,141.52 62.71,141.38 62.85,141.38 63.21,141.02 63.21,140.47 63.73,139.95 63.73,139.37 63.96,139.14 65.12,139.14 65.22,139.24 65.22,140.18 64.73,140.67 64.73,141.23 64.56,141.4 64.01,141.4 63.94,141.47 63.94,142.02
+3VALW_DSW on BOTTOM: 196.96,128.05 199.37,128.05 199.5,127.92 199.5,127.16 197.47,125.13 196.07,125.13 196.07,127.16
+3VALW_DSW on IN2: 199.75,138.16 196.75,138.16 192.72,134.12 192.72,133.05 192.94,132.82 194.19,132.82 195.46,134.09 195.46,134.83 197.26,136.63 199.73,136.63 199.93,136.84 199.93,137.98
+3VALW_DSW on IN3: 192.51,130.59 193.02,130.59 193.85,129.76 195.12,129.76 197.08,127.8 197.47,127.8 197.59,127.67 197.59,127.03 197.34,126.78 195.05,126.78 192.26,129.57 192.26,130.34
+3VALW_DSW on IN3: 143.01,111.08 143.01,110.55 141.99,109.53 141.56,109.53 141.43,109.66 141.43,109.81 142.73,111.11 142.98,111.11
+3VALW_DSW on IN3: 224.68,124.29 225.61,124.29 226,124.68 226,125.31 225.84,125.47 225.38,125.47 224.59,124.68 224.59,124.38
+3VALW_EC on TOP: 233.03,131.1 232.9,130.97 232.39,130.97 232.26,131.1 232.26,131.35 231.76,131.86 230.74,131.86 230.49,132.11 230.49,133.38 230.61,133.51 231.76,133.51 232.52,132.75 232.52,132.51 233.03,132
+3VALW_EC on BOTTOM: 228.26,117.39 226.99,118.65 226.99,120.49 225.67,121.82 225.29,121.82 224.79,121.32 223.13,121.32 223.12,121.31 220.3,121.31 220.25,121.37 220.25,122.44 221.04,123.23 225.8,123.23 226.8,124.24 226.8,129.7 226.61,129.89 226.61,131.66 227.27,132.32 229.98,132.32 230.3,132.63 230.3,133.32 230.61,133.64 231.63,133.64 232.01,133.26 232.01,132.19 232.84,131.36 234.69,131.36 236.9,129.15 240.69,129.15 241.53,128.3 241.53,121.32 237.6,117.39 ; 1 cut-out
+3VALW_EC on VCC: 234.02,122.38 237.08,125.45 237.99,125.45 239.82,123.62 239.82,118.94 239.46,118.59 237.06,118.59 237.03,118.63 237.03,119.34 234.02,122.35
+3VALW_S on TOP (solid shape): 185.91,112.3 191.62,112.3 191.88,112.05 191.88,109.63 191.75,109.51 186.67,109.51 185.53,108.36 185.53,108.11 184.97,107.55 184.51,107.55 184.46,107.6 184.46,108.06 184.41,108.11 183.75,108.11 183.72,108.09 183.72,107.6 183.7,107.58 183.32,107.58 183.28,107.58 183.27,107.59 183.27,108.09 183.24,108.11 182.56,108.11 182.53,108.09 182.53,107.6 182.51,107.58 180.8,107.58 180.57,107.35 179.81,107.35 179.69,107.48 179.69,111.29 179.81,111.41 180.83,111.41 182.48,113.06 185.15,113.06
+3VS on TOP (solid shape): 211.42,112.3 211.42,110.34 211.21,110.12 210.12,110.12 209.91,110.32 209.91,112.64 210.08,112.8 210.92,112.8
+3VS on TOP: 100.31,82.84 100.69,82.84 100.95,82.58 100.95,81.69 100.56,81.31 98.33,81.31 97.64,82 97.64,83.18 97.83,83.36 97.83,83.59 98.01,83.77 98.9,83.77 99.32,83.35 99.8,83.35
+3VS on TOP: 160.89,103.16 162.67,103.16 163.18,102.65 163.18,99.6 162.67,99.09 160.89,99.09 160.64,99.35 160.64,102.9
+3VS on TOP: 234.5,133.34 233.64,133.34 233.32,133.65 233.32,134.07 233.93,134.68 235.08,134.68 235.15,134.61 235.15,133.99
+3VS on TOP: 50.42,93.08 49.28,93.08 48.57,93.79 48.57,94.96 49.17,95.56 49.74,95.56 50.46,94.84 50.46,93.12
+3VS on BOTTOM: 138.16,101.13 138.54,101.13 138.66,101 138.66,100.62 138.77,100.52 139.17,100.52 139.24,100.45 139.24,99.67 139.17,99.6 138.79,99.6 138.66,99.47 138.66,99.35 138.79,99.22 139.17,99.22 139.3,99.09 139.3,98.33 139.05,98.08 136.63,98.08 136.51,98.2 136.51,99.8 136.57,99.87 137.89,99.87 137.9,99.87 137.99,99.87 138.09,99.98 138.09,101.06
+3VS on BOTTOM: 99.17,83.73 101.33,81.57 101.33,81.25 101.14,81.06 96.75,81.06 96.5,81.31 75.42,81.31 75.16,81.57 75.16,82.58 75.55,82.96 81.26,82.96 82.02,83.73
+3VS on BOTTOM: 57.77,88.93 58.53,89.7 58.53,93.12 58.78,93.38 59.54,93.38 62.08,90.84 62.08,84.36 60.45,82.72 53.18,82.72 46.21,89.7 46.21,98.17 45.42,98.96 45.42,102.77 44.65,103.53 44.65,106.81 45.49,107.64 45.49,108.28 47.6,110.39 47.6,126.27 50.27,128.94 50.27,137.7 60.69,148.12 73.85,148.12 74.08,147.89 74.08,144.48 73.91,144.31 64.24,144.31 56.33,136.39 55.84,136.39 54.72,135.26 54.72,126.65 52.17,124.1 52.17,114.83 51.03,113.7 51.03,104.17 50,103.14 50,89.28 50.35,88.93
+3VS on BOTTOM: 44.23,86.34 45.37,86.34 47.52,84.2 47.52,83.45 47.3,83.23 46.62,83.23 45.94,83.9 45.62,83.9 44.2,85.33 44.2,86.32
+3VS on IN3: 45.83,84.11 47.35,84.11 47.99,83.47 47.99,82.84 47.61,82.46 45.7,82.46 45.45,82.71 45.45,83.73
+3VS on IN3: 98.41,84.11 100.44,84.11 100.95,83.6 100.95,81.57 100.44,81.06 55.61,81.06 55.35,81.31 55.35,83.75 55.58,83.97 60.19,83.97 61.45,82.71 91.17,82.71 91.42,82.46 96.75,82.46
+3VS_CAM on BOTTOM (solid shape): 97.24,132.74 99.55,132.74 101.83,130.46 102.6,130.46 102.85,130.21 102.85,129.19 102.6,128.94 100.18,128.94 99.04,130.08 98.58,130.08 97,131.66 95.48,131.66 94.88,132.27 94.88,133.31 95.27,133.7 96.28,133.7
+3VS_CAM on IN2 (solid shape): 229.72,145.7 229.72,145.07 229.65,144.99 228.02,144.99 227.72,145.3 227.72,145.64 227.87,145.79 228.54,145.79 228.71,145.96 229.47,145.96
+3VS_CAM on IN3 (solid shape): 240.23,144.96 240.23,142.95 240.08,142.8 239.23,142.8 238.92,143.11 238.92,145.01 239.03,145.12 240.07,145.12
+3VS_CAM on TOP: 101.58,129.33 101.39,129.14 100.69,129.14 100.56,129.28 99.58,129.28 99.54,129.31 99.54,129.86 100.02,130.34 101.42,130.34 101.58,130.18
+3VS_CAM on TOP: 243.19,132.55 243.12,132.49 242.46,132.49 242.25,132.29 241.24,132.29 241.15,132.37 241.15,132.89 240.85,133.2 239.32,133.2 239.08,133.45 239.08,134.62 239.14,134.68 239.66,134.68 239.75,134.59 239.75,134.07 239.9,133.92 241.09,133.92 241.31,133.7 243.05,133.7 243.19,133.56
+3VS_CAM on TOP: 96.17,132.1 95.28,132.1 94.9,132.48 94.9,133.2 95.03,133.33 96.19,133.33 96.24,133.28 96.24,132.18
+3VS_CAM on BOTTOM: 198.29,146.54 199.51,146.54 199.62,146.43 199.62,145.32 199.23,144.93 198.33,144.93 197.81,145.45 197.81,146.06
+3VS_CAM on IN2: 238.07,145.49 240.09,145.49 240.38,145.2 240.38,144.46 240.12,144.2 238.02,144.2 237.92,144.3 237.92,145.33
+3VS_CAM on IN3: 198.23,146.85 199.75,146.85 199.88,146.72 199.88,145.96 199.75,145.83 198.35,145.83 198.1,146.08 198.1,146.72
+3VS_CAM on IN3: 241.79,134.02 243.31,134.02 243.69,133.64 243.69,132.62 243.44,132.37 241.92,132.37 241.53,132.75 241.53,133.76
+3VS_CAM on IN3: 228.71,144.43 228.45,144.43 227.06,145.83 227.06,146.21 227.44,146.59 228.2,146.59 229.22,145.58 229.22,144.94
+3VS_CR on TOP: 29.43,83.94 29.43,83.46 29.06,83.09 28.94,83.09 28.43,82.58 28.3,82.58 28.17,82.71 28.17,82.96 28.56,83.35 28.56,83.85 28.3,84.11 28.3,84.74 27.92,85.12 27.92,85.63 28.17,85.89 29.32,85.89 29.44,85.76 29.44,83.96
+3VS_CR on TOP: 36.42,89.95 36.56,89.82 36.56,88.55 36.43,88.43 35.72,88.43 35.6,88.31 35.6,88.24 35.2,87.83 34.74,87.83 34.69,87.88 34.19,87.88 34.02,88.04 34.02,88.43 35.55,89.95
+3VS_CR on BOTTOM: 35.41,88.55 35.67,88.3 35.67,87.97 34.48,86.78 33.43,85.73 30.62,85.73 29.51,84.62 29.51,74.32 29.24,74.05 25.9,74.05 24.24,75.71 24.24,86.77 25.34,87.88 30.76,87.88 31.43,88.55
+3VS_TS on TOP: 187.81,107.22 190.48,107.22 190.61,107.09 190.61,106.46 190.35,106.21 187.81,106.21 187.56,106.46 187.56,106.97
+3VS_WLAN on TOP (solid shape): 245.55,108.94 245.54,108.92 245.55,108.78 245.64,108.67 245.64,108.57 245.54,108.37 245.64,108.17 245.64,108.12 245.86,107.9 245.86,106.06 245.62,105.82 244.21,105.82 244.16,105.87 244.16,107.01 243.97,107.19 243.97,108.16 243.95,108.3 243.87,108.41 243.87,108.96 243.95,109.03 245.46,109.03
+3VS_WLAN on TOP: 246.06,133.06 245.94,132.94 245.94,130.63 246.08,130.48 247,130.48 247.03,130.51 247.03,131.1 247.21,131.29 247.22,131.29 247.27,131.34 247.27,132.02 247.42,132.17 247.42,133.02 247.38,133.06
+3VS_WLAN on TOP: 238.91,136.49 238.82,136.58 238.82,137.49 238.56,137.74 238.56,138.6 239.8,139.83 243.54,139.83 243.66,139.71 243.66,138.51 243.31,138.17 240.65,138.17 240.39,137.9 240.39,136.64 240.25,136.49
+3VS_WLAN on VCC: 246.61,104.75 246.61,104.76 244.12,104.76 244.01,104.86 244.01,108.51 244.58,109.08 244.58,124.5 241.53,127.55 241.53,137.37 241.53,137.37 241.53,139.24 242.98,140.69 255.38,140.69 255.38,130.22 255.38,130.21 255.38,129.87 254.89,129.63 254.69,129.12 254.69,128.77 254.61,128.6 254.44,128.53 251.11,128.53 250.98,128.56 250.89,128.65 249.71,128.81 249.86,127.62 249.95,127.53 249.99,127.41 249.99,126.12 249.36,126.12 249.36,116.49 249.99,116.49 249.99,114.03 249.63,114.03 249.63,109.02 249.99,109.02 249.99,107.84 249.95,107.72 249.86,107.63 249.5,106.85 250.09,106.23 250.09,104.75
+3VS_WWAN on TOP: 33.13,90.08 33.25,89.95 33.25,89.19 32.99,88.92 30.89,88.92 30.75,89.06 30.6,89.06 29.83,89.84 28.06,89.84 27.77,90.13 27.77,91.04 28.1,91.37 30.56,91.37 30.98,90.95 30.98,90.19 31.09,90.08
+3VS_WWAN on TOP: 37.89,106.71 37.95,106.65 37.95,104.94 37.7,104.68 36.49,104.68 36.14,105.04 36.14,106.57 36.28,106.71
+3VS_WWAN on TOP: 10.75,100.77 11.16,100.36 14.08,100.36 14.39,100.05 14.39,99.86 14.59,99.67 14.59,98.03 14.69,97.93 14.69,95.87 14.66,95.84 14.2,95.84 14.08,95.97 14.08,96.58 13.72,96.93 11.54,96.93 10,98.48 10,98.72 8.76,99.96 8.76,101.63 8.82,101.68 10.67,101.68 10.75,101.6
+3VS_WWAN on BOTTOM: 34.14,100.36 32.37,102.14 32.37,103.54 31.73,104.17 31.73,104.51 31.86,104.51 31.86,104.68 32.11,104.94 32.11,105.19 32.49,105.57 33,105.57 33.51,105.06 33.51,103.41 34.14,102.78 35.67,102.78 36.43,103.54 36.43,105.34 36.61,105.52 37.13,105.52 37.36,105.29 37.36,101.04 36.68,100.36
+3VS_WWAN on IN1: 14.33,103.67 13.7,104.3 13.7,105.82 13.82,105.95 33.25,105.95 33.51,105.7 33.51,104.68 32.87,104.05 15.98,104.05 15.6,103.67
+3VS_WWAN on IN2: 10.52,92.74 9.12,94.14 9.12,100.62 9.51,101 11.03,101 13.7,103.67 13.7,105.32 14.33,105.95 33.38,105.95 33.89,105.44 34.52,105.44 34.87,105.79 36.1,105.79 36.28,105.96 36.7,105.96 36.75,105.91 36.75,104.82 36.61,104.68 34.27,104.68 33.38,103.79 33.38,103.03 33,102.65 31.48,102.65 31.41,102.71 31.35,102.65 15.6,102.65 15.6,101.89 15.54,101.82 15.54,100.94 13.57,98.97 13.57,97.96 17.07,94.46 17.07,93.28 16.96,93.17 16.41,93.17 15.98,92.74
+3VS_WWAN on IN3: 14.08,104.05 13.88,104.24 13.88,105.76 14.08,105.95 33,105.95 33.13,105.82 33.13,104.43 32.75,104.05
+3VS_WWAN on IN3: 25.37,89.44 18.52,89.44 14.71,93.25 14.71,94.9 14.97,95.16 16.49,95.16 17.89,93.76 23.15,93.76 24.54,92.36 28.7,92.36 29.38,91.68 29.38,89.16 29.09,88.87 25.94,88.87
+5VALW on TOP (solid shape): 235.93,112.45 235.93,111.16 235.74,110.98 234.73,110.98 234.55,111.16 234.55,112.58 234.6,112.63 235.74,112.63
+5VALW on TOP (solid shape): 85.45,115.22 85.96,115.22 86.21,114.97 86.21,114.33 85.83,113.95 84.94,113.95 84.56,114.33 84.56,115.48 84.69,115.6 85.07,115.6
+5VALW on TOP: 249.54,140.57 251.07,140.57 251.2,140.44 251.2,139.81 251,139.61 250.29,139.61 250.24,139.6 250.19,139.59 250.01,139.41 249.58,138.98 248.57,138.98 247.81,139.75 247.31,139.75 247.2,139.86 247.2,140.17 247.02,140.35 246.52,140.35 246.5,140.37 246.5,140.87 247.61,140.87 247.91,140.57 248.25,140.57 248.62,140.2 249.17,140.2
+5VALW on TOP: 91.21,102.38 89.56,102.38 88.89,101.72 88.89,99.17 89,99.06 89.6,99.06 89.89,99.35 89.89,101.25 90.14,101.5 91.19,101.5 91.28,101.59 91.28,102.32
+5VALW on TOP: 85.45,104.55 87.36,104.55 87.48,104.43 87.48,103.67 87.36,103.54 85.45,103.54 85.32,103.67 85.32,104.43
+5VALW on TOP: 18.38,56.4 16.39,56.4 16.14,56.65 16.14,58.68 16.36,58.91 18.38,58.91 18.52,58.77 18.52,56.54
+5VALW on TOP: 23.03,63.89 22.88,64.04 22.88,64.5 22.92,64.54 23.53,64.54 24.01,65.02 24.83,65.02 24.89,64.97 24.89,64.21 24.57,63.89
+5VALW on TOP: 186.42,123.29 187.75,123.29 187.75,123.8 189.39,123.8 189.39,123.29 190.04,123.29 191.81,121.51 191.81,119.99 191.69,119.86 186.86,119.86 186.63,120.09 186.63,120.64 186.23,121.05 186.23,123.1
+5VALW on TOP: 195.21,129.47 194.72,129.47 194.65,129.4 194.65,127.29 194.8,127.14 195.64,127.14 195.69,127.19 195.69,128.13 195.76,128.2 196.09,128.2 196.27,128.02 196.27,127.19 196.32,127.14 196.42,127.14 196.5,127.21 196.5,128.3 196.25,128.56 195.56,128.56 195.33,128.79 195.33,129.34
+5VALW on BOTTOM: 195.47,127.8 193.88,127.8 193.76,127.92 193.76,128.62 193.81,128.67 195.59,128.67 195.71,128.54 195.71,128.04
+5VALW on BOTTOM: 38.5,61.73 32.7,61.73 27.55,66.87 23.4,66.87 23.06,66.53 23.06,64.07 23.37,63.75 25.53,63.75 32.71,56.57 38.42,56.57 38.72,56.87 38.72,61.51
+5VALW on BOTTOM: 235.57,140.1 237.47,140.1 237.62,139.95 237.62,139.2 237.5,139.07 236.15,139.07 235.9,139.33 235.45,139.33 235.39,139.39 235.39,139.92
+5VALW on IN1: 139.49,128.37 140.98,128.37 141.18,128.17 141.18,127.82 140.87,127.5 139.36,127.5 139.3,127.56 139.3,128.19
+5VALW on IN1: 23.84,66.23 24.1,65.97 24.1,64.11 23.64,63.65 22.99,63.65 17.32,57.97 17.32,56.65 17.16,56.5 16.22,56.5 16.21,56.52 15.25,56.52 15.06,56.71 15.06,59.39 21.89,66.23
+5VALW on IN2: 240.58,135.73 240.52,135.67 239.01,135.67 238.22,136.47 238.22,139.51 238.83,140.12 246.49,140.12 247.76,141.38 249.92,141.38 250.3,141 250.3,138.72 247.31,135.73
+5VALW on IN2: 141.99,126.73 141.47,126.73 141.43,126.78 141.43,128.36 141.42,128.36 140.68,129.11 139.66,129.11 138.5,127.95 138.5,126.11 138.8,125.81 142.02,125.81 142.18,125.97 142.18,126.54
+5VALW on IN3: 239.16,136.44 239.47,136.76 239.47,137.24 237.41,139.3 237.41,139.78 237.31,139.89 236.26,139.89 235.86,139.49 235.86,137 236.43,136.44
+5VALW on IN3: 141.33,126.91 141.89,126.91 142.13,126.67 142.13,125.09 142.98,124.24 142.98,122.84 142.73,122.59 142.09,122.59 141.84,122.84 141.84,123.86 140.82,124.87 140.82,126.4
+5VALW on VCC: 31.33,55.79 31.1,56.02 31.1,81.08 36.28,86.27 55.2,86.27 61.45,92.51 61.45,114.61 71.33,124.49 118.24,124.49 120.78,121.95 166.88,121.95 170.92,117.91 170.92,111.31 177.04,105.19 185.51,105.19 186.8,106.48 186.8,127.82 189.19,130.21 196.42,130.21 196.58,130.06 196.58,123.71 193.78,120.92 193.78,103.26 189.99,99.47 170.14,99.47 165.82,103.79 165.08,103.79 165.08,111.01 164.04,112.05 151.44,112.05 151.44,113.22 150.84,113.83 148.08,113.83 147.83,113.57 116.67,113.57 112.61,117.64 88.39,117.64 87.86,117.11 87.86,103.92 83.7,103.92 82.78,103.01 82.78,89.7 79.5,89.7 78.97,89.17 78.97,78.59 45.06,78.59 44.15,78.84 43.51,79.52 43.5,79.54 42.94,80.25 39.15,79.78 40.06,76.07 40.74,75.43 41,74.52 41,55.79 ; 3 cut-outs
+5VALW_S on TOP (solid shape): 187.69,129.95 187.69,127.03 188.19,126.53 188.19,125.76 188.45,125.51 189.85,125.51 190.23,125.13 190.23,123.48 190.16,123.41 189.5,123.41 189.5,123.9 188.85,123.9 188.85,123.41 188.3,123.41 188.3,123.9 187.65,123.9 187.65,123.41 186.1,123.41 185.96,123.27 184.85,123.27 184.77,123.35 184.77,124.06 184.6,124.23 180.94,124.23 180.59,124.58 180.59,125.18 180.57,125.19 180.57,126.7 180.88,127.01 184.02,127.01 184.32,127.31 184.32,127.33 184.99,128 184.99,129.93 185.21,130.15 187.5,130.15
+5VS on TOP: 140.13,123.47 140.88,123.47 141.03,123.63 141.77,123.63 141.89,123.75 141.89,124.5 141.82,124.57 140.15,124.57 140.04,124.46 140.04,123.57
+5VS_AUDIO on TOP: 36.3,23.53 37.06,23.53 37.19,23.4 37.19,23.15 37.45,22.89 38.33,22.89 38.59,22.64 38.59,22 38.33,21.75 37.32,21.75 37.19,21.62 37.19,21.24 37.57,20.86 37.57,19.97 37.45,19.85 35.79,19.85 35.67,19.97 35.67,20.86 36.05,21.24 36.05,23.27
+5VS_AUDIO_AMP on BOTTOM: 213.61,123.88 214.33,123.88 214.61,123.6 214.61,118.6 214.46,118.45 212.46,118.45 212.17,118.74 212.17,121.65 212.59,121.65 213.4,122.46 213.4,123.68
+5VS_AUDIO_AMP on BOTTOM: 196.7,123.22 195.69,123.22 194.67,122.21 194.67,121.45 194.8,121.32 196.58,121.32 200.13,124.87 209.89,124.87 210.04,125.03 210.04,125.79 210.46,126.21 211.37,126.21 211.79,126.63 211.79,127.77 211.41,128.15 209.89,128.15 208.56,126.82 201.83,126.82 201.02,126.02 199.5,126.02
+AVDD1 on TOP: 37.51,19.46 37.57,19.4 37.57,18.58 37.45,18.45 36.81,18.45 36.56,18.19 36.56,16.16 36.3,15.91 35.67,15.91 35.16,16.42 34.65,16.42 34.52,16.54 34.52,17.18 35.67,18.32 35.67,19.4 35.73,19.46
+DVDD on BOTTOM: 29.32,22.39 35.29,22.39 37.06,24.16 37.06,25.54 36.95,25.66 36.46,25.66 36.39,25.59 36.39,24.45 35.93,23.99 29.44,23.99 29.19,23.74 29.19,22.51
+PVDD on TOP: 210.15,122.6 210.15,122.58 210.11,122.53 209.5,122.53 209.02,122.06 207.11,122.06 207.02,122.14 207.02,122.23 207.07,122.28 208.27,122.28 209.02,123.03 209.02,123.11 209.39,123.48 210.13,123.48 210.19,123.41 210.19,123.13 210.15,123.09
+PVDD on TOP: 212.45,120.43 212.45,118.14 212.2,117.89 210.69,117.89 210.52,118.06 210.52,118.95 210.73,119.16 210.73,119.82 210.64,119.9 210.26,119.9 209.34,120.82 208.1,120.82 208.04,120.88 207.05,120.88 207.01,120.93 207.01,121.05 207.05,121.08 208.08,121.08 208.24,121.25 209.93,121.25 210.15,121.02 211.86,121.02
+PVDD on IN3: 211.05,118.91 211.05,118.14 210.8,117.89 210.29,117.89 209.91,118.27 209.15,118.27 207.75,119.67 207.75,123.1 208.13,123.48 210.1,123.48 210.23,123.35 210.23,119.73
+V0.85A_S on TOP (solid shape): 170.41,115.18 170.41,111.56 168.94,110.09 166.45,110.09 165.87,109.51 165.08,109.51 164.93,109.66 164.93,110.04 164.95,110.07 165.46,110.07 165.49,110.09 165.49,110.52 165.46,110.55 164.95,110.55 164.93,110.57 164.93,111.01 165.33,111.41 167.24,111.41 167.37,111.54 167.37,113.7 167.49,113.83 168,113.83 168.26,114.08 168.26,115.1 168.51,115.35 170.25,115.35
+VCC_CORE on TOP (solid shape): 94.21,110.14 94.21,104.8 93.97,104.55 89.64,104.55 89.26,104.94 89.26,105.44 88.91,105.8 88.91,107.93 88.97,108 90.54,108 90.77,108.22 90.77,110.14 91.01,110.38 93.98,110.38
+VCC_CORE on GND1 (solid shape): 125.47,108.36 125.47,108.14 125.33,107.99 124.76,107.99 124.6,108.04 124.44,107.99 123.77,107.99 123.67,108.01 123.57,107.99 123.07,107.99 122.98,108.09 122.98,108.3 123.12,108.44 125.39,108.44
+VCC_CORE on IN2 (solid shape): outline of 1600 points within 106.69,98.71 126.78,108.48
+VCC_CORE on GND4 (solid shape): 124.2,100.52 124.2,100.08 124.02,99.9 122.09,99.9 122,99.99 122,100.16 122.12,100.27 122.26,100.27 122.66,100.67 124.05,100.67
+VCC_CORE on GND4 (solid shape): 126.84,101.34 126.84,100.85 126.47,100.48 126.25,100.48 126.17,100.56 126.17,100.77 126.37,100.97 126.37,101.25 126.18,101.44 126.11,101.44 125.97,101.58 125.97,101.81 126.04,101.89 126.3,101.89
+VCC_CORE on TOP: 116.92,101.17 116.92,101.28 116.97,101.33 118.24,101.33 118.32,101.25 118.32,101.14 118.46,101 118.46,100.85 118.32,100.71 118.32,100.47 118.48,100.31 118.48,100.24 118.43,100.19 117.48,100.19 117.11,99.82 117.01,99.82 116.93,99.9 116.93,100.05 117.06,100.18 117.06,100.37 116.9,100.53 116.9,100.67 117.07,100.84 117.07,101.02
+VCC_CORE on TOP: 101.3,102.22 102.69,100.83 103.1,100.83 103.65,100.29 104.31,100.29 104.5,100.1 104.5,99.59 104.59,99.5 105.64,99.5 106.1,99.96 106.56,99.96 106.69,100.08 106.69,100.64 107.17,101.13 109.07,101.13 109.3,100.9 109.3,100.19 109.51,99.98 110.34,99.98 110.47,100.11 114.03,100.11 115.2,101.28 115.86,101.28 116.45,101.28 116.49,101.24 116.49,100.85 116.6,100.73 116.6,100.5 116.49,100.39 116.49,100.2 116.6,100.08 116.6,99.84 116.49,99.73 116.49,99.49 116.54,99.44 116.54,99.13 116.49,99.08 116.49,98.89 116.53,98.85 116.53,98.59 116.49,98.55 116.49,98.42 116.53,98.38 116.53,98.12 116.49,98.08 116.49,97.96 116.54,97.91 116.54,97.72 116.49,97.67 116.49,97.54 116.67,97.37 116.67,97.21 116.41,96.96 115.8,96.96 115.3,97.47 115.3,97.82 114.79,98.33 110.55,98.33 110.29,98.59 106.62,98.59 106.55,98.66 103.31,98.66 103.21,98.76 103.21,99.21 103.2,99.21 103.2,99.23 102.89,99.54 101.61,99.54 101.49,99.65 101.49,100.36 101.26,100.59 100.13,100.59 99.73,101 99.73,102.09 99.85,102.22
+VCC_CORE on BOTTOM: 124.75,99.6 124.49,99.86 119.84,99.86 118.83,98.84 115.55,98.84 115.3,99.09 115.04,99.09 114.66,98.71 108.69,98.71 107.93,99.47 103.08,99.47 102.33,100.22 100.39,100.22 99.66,100.95 99.66,101.51 99.89,101.74 102.53,101.74 102.64,101.63 105.26,101.63 106.03,100.87 114.53,100.87 114.92,100.49 115.93,100.49 116.19,100.24 117.46,100.24 117.58,100.36 122.05,100.36 122.36,100.67 122.79,100.67 123.42,101.3 123.42,107.86 123.45,107.88 123.88,107.88 123.93,107.83 123.93,100.54 124.03,100.44 124.67,100.44 124.72,100.39 124.72,100.13 125.05,99.8 126.35,99.8 126.47,99.93 126.47,107.6 126.6,107.73 126.85,107.73 126.98,107.6 126.98,99.86 126.6,99.47 125.36,99.47 125.25,99.37 125.25,98.99 125.13,98.86 124.9,98.86 124.75,99.02
+VCC_CORE on IN1: 123.27,101.03 123.27,108.25 123.46,108.44 126.52,108.44 126.71,108.25 126.71,100.74 126.59,100.62 126.6,100.62 126.6,99.22 125.96,98.59 122.66,98.59 121.52,99.73 121.14,99.73 120.93,99.52 120.76,99.69 118.37,99.69 117.9,99.22 116.31,99.22 116.06,99.47 115.42,99.47 114.79,98.84 107.93,98.84 107.68,99.09 106.91,99.09 106.53,99.47 106.53,100.24 107.55,101.25 116.31,101.25 116.44,101.38 118.6,101.38 119.61,100.36 122.6,100.36 ; 3 cut-outs
+VCC_CORE on IN3: 122.79,108.49 126.09,108.49 126.35,108.24 126.35,101.63 126.6,101.38 126.6,100.62 126.47,100.49 126.09,100.49 125.84,100.74 125.84,107.48 125.46,107.86 123.68,107.86 123.3,107.48 123.3,101.63 124.19,100.74 124.19,100.36 124.09,100.27 122.76,100.27 122.41,100.62 122.41,108.11
+VCC_CORE on GND4: 123.91,108.54 122.79,108.54 122.74,108.49 122.74,108.34 123.09,107.98 123.3,107.98 123.37,108.06 124.01,108.06 124.06,108.01 124.26,108.01 124.36,108.11 125.05,108.11 125.15,108.01 125.96,108.01 126.09,107.88 126.32,107.88 126.4,107.96 126.4,108.19 126.3,108.29 125.48,108.29 125.28,108.49 124.31,108.49 124.24,108.42 124.03,108.42
+VCC_CORE on VCC: outline of 111 points within 88.37,90.33 127.35,109.63
+VCC_GT on TOP (solid shape): 94.34,121.95 94.34,117.13 94.6,116.87 94.6,114.71 94.44,114.56 92.21,114.56 91.41,115.36 89.15,115.36 88.32,116.19 88.32,117.71 89.26,118.65 90.05,118.65 90.35,118.96 90.35,119.57 90.53,119.74 91.29,119.74 91.37,119.82 91.37,120.33 91.32,120.38 90.46,120.38 90.4,120.43 90.4,121.9 90.58,122.08 94.21,122.08
+VCC_GT on GND4 (solid shape): 122.5,103.79 122.5,103.4 122.46,103.36 119.58,103.36 119.42,103.51 119.42,103.74 119.6,103.91 122.38,103.91
+VCC_GT on GND4 (solid shape): 122.52,104.84 122.52,104.66 122.4,104.54 118.38,104.54 118.19,104.72 118.19,104.84 118.3,104.95 122.41,104.95
+VCC_GT on GND4 (solid shape): 122.57,106.19 122.57,105.9 122.51,105.84 118.95,105.84 118.86,105.93 118.86,106.14 118.98,106.26 122.5,106.26
+VCC_GT on GND4 (solid shape): 122.72,101.72 122.72,101.61 122.5,101.39 118.99,101.39 118.85,101.53 118.85,101.74 118.95,101.83 122.61,101.83
+VCC_GT on GND4 (solid shape): 121.23,108.44 121.91,108.44 121.96,108.49 122.48,108.49 122.57,108.41 122.57,108.23 122.42,108.08 120.21,108.08 120.09,108.2 120.09,108.36 120.16,108.43 120.79,108.43 120.85,108.49 121.17,108.49
+VCC_GT on GND4 (solid shape): 122.59,102.96 122.59,102.77 122.35,102.54 120.54,102.54 120.45,102.55 120.37,102.54 119.61,102.54 119.39,102.75 119.39,102.86 119.54,103.01 122.53,103.01
+VCC_GT on TOP: 118.15,101.74 116.42,101.74 116.32,101.63 115.43,101.63 115.05,102.02 115.04,102.01 113.11,102.01 112.76,102.37 112.49,102.63 111.2,102.63 110.7,102.14 107.68,102.14 106.79,103.03 106.79,104.55 107.09,104.86 110.8,104.86 111.49,104.17 112.58,104.17 112.69,104.06 113.4,104.06 113.67,104.33 113.67,104.73 113.7,104.77 114.89,104.77 114.97,104.69 117.98,104.69 117.98,104.69 118.08,104.69 118.27,104.49 118.27,104.4 118.47,104.2 118.47,104.11 118.29,103.93 118.29,103.72 118.44,103.57 118.44,103.38 118.33,103.28 118.33,103.1 118.49,102.94 118.49,102.82 118.29,102.63 118.29,102.42 118.49,102.23 118.49,102.17 118.27,101.95 118.27,101.86 ; 1 cut-out
+VCC_GT on TOP: 101.07,106.53 101.07,108.3 101.17,108.4 101.83,108.4 103.02,107.22 103.02,106.68 102.52,106.18 102.51,106.18 101.42,105.09 99.9,105.09 99.79,105.2 99.79,105.91 99.89,106.02 100.56,106.02
+VCC_GT on BOTTOM: 122.47,108.68 122.6,108.56 122.6,108.24 122.54,108.17 118.21,108.17 118.14,108.11 118.14,107.55 118.22,107.48 123.25,107.48 123.3,107.42 123.3,106.99 123.25,106.94 118.17,106.94 118.12,106.89 118.12,106.36 118.22,106.26 123.25,106.26 123.3,106.21 123.3,105.7 123.25,105.65 118.17,105.65 118.12,105.6 118.12,105.06 118.14,105.04 123.25,105.04 123.3,104.99 123.3,104.48 123.25,104.43 118.17,104.43 118.14,104.4 118.14,103.82 118.19,103.77 123.25,103.77 123.3,103.72 123.3,102.62 123.25,102.57 118.22,102.57 118.17,102.52 118.17,101.99 118.22,101.94 122.64,101.94 122.71,101.86 122.71,101.33 122.64,101.25 118.83,101.25 118.78,101.2 118.78,100.72 118.8,100.69 122,100.69 122.06,100.64 122.06,100.51 122.01,100.47 117.51,100.47 117.41,100.36 117.02,100.36 117.02,100.8 116.57,101.25 106.15,101.25 102.72,104.68 101.58,104.68 101.2,105.06 101.2,107.73 101.58,108.11 106.91,108.11 108.44,106.59 109.07,106.59 111.17,108.68
+VCC_GT on IN1: 120.3,100.49 119.78,101.02 119.58,101.02 118.93,101.67 116.68,101.67 116.67,101.66 116.34,101.66 116.27,101.59 111.57,101.59 111.49,101.51 106.06,101.51 105.56,101.01 102.36,101.01 101.33,102.04 101.33,107.73 101.58,107.98 101.91,107.98 102.6,107.3 104.43,107.3 105.9,105.82 111.52,105.82 112.63,104.71 119.1,104.71 119.44,105.05 119.44,106.46 119.54,106.46 119.54,106.88 119.54,106.88 119.54,108.02 119.94,108.42 123.06,108.42 123.14,108.34 123.14,101.03 122.61,100.49
+VCC_GT on GND1: 119.68,105.25 119.49,105.25 119.36,105.13 119.36,105 119.81,104.55 122.41,104.55 122.66,104.81 122.66,105 122.6,105.06 119.87,105.06
+VCC_GT on GND1: 101.76,106.46 101.58,106.64 101.58,107.55 101.76,107.73 102.29,107.73 102.85,107.17 102.85,106.64 102.67,106.46
+VCC_GT on GND1: 119.74,101.89 122.54,101.89 122.66,101.76 122.66,101.51 122.54,101.38 119.74,101.38 119.61,101.51 119.61,101.76
+VCC_GT on GND1: 119.41,105.7 119.41,105.8 119.64,106.03 119.64,106.13 119.78,106.27 122.54,106.27 122.66,106.14 122.66,105.95 122.54,105.82 119.87,105.82 119.67,105.62 119.49,105.62
+VCC_GT on GND1: 119.61,102.84 119.61,102.65 119.74,102.52 122.6,102.52 122.66,102.59 122.66,102.78 122.47,102.97 119.74,102.97
+VCC_GT on IN2: 121.19,108.46 121.33,108.46 121.4,108.4 121.77,108.4 121.91,108.53 122.23,108.53 122.56,108.2 122.56,101.28 122.47,101.28 122.36,101.17 122.36,101.16 121.55,100.35 121.3,100.35 120.8,100.85 119.9,100.85 119.38,101.37 119.36,101.37 119.23,101.5 116.82,101.5 116.31,102.01 115.3,102.01 115.3,102.01 114.79,101.5 110.53,101.5 110.34,101.68 107.55,101.68 104.43,104.81 103.61,104.81 102.85,104.05 101.83,104.05 101.33,104.55 101.33,107.48 101.83,107.98 103.74,107.98 105.81,105.91 105.81,105.86 106.69,104.99 114.13,104.99 114.31,104.81 117.81,104.81 118.12,104.5 118.61,104.5 119.14,105.03 119.14,107.05 119.66,107.57 119.66,108.24 119.86,108.43 120.68,108.43 120.79,108.55 121.11,108.55
+VCC_GT on VCC: 117.86,100.45 117.38,100.94 117.41,100.97 117.41,101.18 117.03,101.56 103.13,101.56 94.55,110.14 88.37,110.14 88.37,116.9 88.61,117.13 112.4,117.13 119.87,109.66 119.87,109.28 120,109.15 120,108.82 120.4,108.42 122.57,108.42 122.57,108.1 118.34,108.1 118.18,107.93 118.18,107.65 118.34,107.49 123.08,107.49 123.08,107.12 122.89,106.93 118.32,106.93 118.15,106.77 118.15,106.51 118.34,106.32 119.89,106.32 119.94,106.27 120.17,106.27 120.23,106.32 123.06,106.32 123.06,105.66 118.27,105.66 118.15,105.55 118.15,105.21 118.29,105.08 123.06,105.08 123.06,104.44 118.32,104.44 118.18,104.3 118.18,103.97 118.32,103.83 123.11,103.83 123.11,102.54 118.34,102.54 118.21,102.4 118.21,102.12 118.34,101.98 123.11,101.98 123.11,101.42 123.02,101.42 122.87,101.27 118.98,101.27 118.79,101.08 118.79,100.87 118.95,100.71 122.03,100.71 122.04,100.69 122.04,100.49 122,100.45
+VCC_SA on TOP (solid shape): 88.25,101.38 88.25,94.39 88.12,94.27 82.53,94.27 82.52,94.27 82.22,94.27 82.07,94.43 82.07,95.2 83.55,96.68 83.55,99.98 84.05,100.49 85.58,100.49 86.72,101.63 87.99,101.63
+VCC_SA on TOP: 128.2,95.49 127.11,95.49 126.93,95.31 126.93,93.4 127.01,93.33 128.17,93.33 128.23,93.38 128.23,95.46
+VCC_SA on TOP: 136.81,89.27 134.55,89.27 134.54,89.27 133.9,89.27 133.89,89.28 133.14,89.28 133.09,89.33 133.09,90.56 133.29,90.75 136.27,90.75 136.91,90.1 136.91,89.37
+VCC_SA on TOP: 104.63,95.79 104.37,96.05 104.37,96.93 104.6,97.16 107.92,97.16 107.99,97.09 110.69,97.09 110.85,96.92 110.85,96.17 110.47,95.79
+VCC_SA on BOTTOM: 128.05,107.68 128.12,107.6 128.12,101 127.74,100.62 127.62,100.74 127.62,107.63 127.67,107.68
+VCC_SA on BOTTOM: 106.28,97.19 106.66,96.81 106.66,95.79 105.14,94.27 104.25,94.27 103.36,93.38 103.36,90.84 102.6,90.08 102.6,88.93 102.34,88.68 101.33,88.68 101.07,88.93 101.07,93.76 101.83,94.52 101.83,96.81 102.22,97.19
+VCC_SA on IN1: 126.94,99.94 126.66,100.22 126.66,100.44 126.79,100.57 126.79,107.97 126.87,108.06 127.62,108.06 127.71,107.98 127.71,100.74 127.24,100.28 127.24,100.03 127.15,99.94
+VCC_SA on GND1: 133.32,90.19 133.49,90.19 134.24,90.94 134.24,91.11 134.14,91.21 133.49,91.21 133.05,90.77 133.05,90.45
+VCC_SA on IN2: 126.86,101.38 126.81,101.43 126.81,101.64 126.89,101.72 126.89,105.79 126.89,105.79 126.89,107.64 127.11,107.86 127.36,107.86 127.62,107.6 127.62,104.17 128.76,103.03 128.76,101.51 127.74,100.49 126.98,100.49 126.85,100.62 126.85,100.74 126.86,100.75
+VCC_SA on IN3: 127.41,107.27 127.25,107.43 126.95,107.43 126.88,107.34 126.88,101.78 126.79,101.69 126.79,101.44 127.13,101.1 127.13,100.88 127.28,100.73 127.56,100.73 127.78,100.95 127.78,101.48 127.42,101.84 127.41,101.84
+VCC_SA on VCC: 90.15,84.87 85.33,89.7 83.29,89.7 83.29,102.8 83.91,103.41 87.86,103.41 87.86,97.72 95.76,89.82 124.04,89.82 126.63,92.41 126.63,97.78 126.5,97.9 126.5,98.89 126.7,99.09 126.7,99.18 127.48,99.96 127.48,101.63 127.55,101.71 127.55,102.4 127.4,102.55 127.4,102.75 127.53,102.88 127.53,103.51 127.37,103.67 127.37,103.92 127.5,104.05 127.5,104.3 127.35,104.45 127.35,105.32 127.5,105.47 127.5,105.88 127.4,105.98 127.4,106.18 127.5,106.28 127.5,106.98 127.43,107.06 127.43,107.32 127.58,107.48 128.12,107.48 128.12,106.64 128.07,106.59 128.07,106.48 128.12,106.43 128.12,104.24 128.75,103.61 128.75,99.84 128.68,99.78 128.68,98.74 133.28,94.14 139.58,94.14 139.58,91.85 137.09,91.85 135.46,90.22 132.61,90.22 127.26,84.87
+VCCCLK on TOP (solid shape): 131.17,102.78 131.17,102.01 131.04,101.89 130.79,101.89 130.66,101.76 130.66,101 130.54,100.87 129.39,100.87 129.27,101 129.27,101.13 129.39,101.25 130.16,101.25 130.28,101.38 130.28,101.76 130.16,101.89 129.39,101.89 129.27,102.01 129.27,102.78 129.39,102.9 131.04,102.9
+VCCCLK on BOTTOM (solid shape): 130.92,102.78 130.92,101.89 130.66,101.63 130.03,101.63 129.9,101.76 129.9,102.78 130.03,102.9 130.79,102.9
+VCCCLK on VCC: 142.6,91.73 142.6,92.36 144.38,94.14 144.38,96.99 143.42,97.95 142.02,97.95 136.81,103.16 132.72,103.16 132.03,102.47 131.58,102.47 130.99,101.89 130.64,101.89 130,102.52 130,102.7 130.66,103.36 130.66,103.79 132.29,103.79 132.41,103.67 138.23,103.67 142.55,99.35 148.32,99.35 148.32,95.97 145.9,93.56 145.9,92.42 145.22,91.73
+VCCCOREG0 on BOTTOM (solid shape): 125.71,104.15 125.71,99.93 125.69,99.91 125.25,99.91 125.18,99.98 125.18,100.34 125,100.52 124.67,100.52 124.62,100.57 124.62,101.48 124.72,101.58 125.03,101.58 125.13,101.68 125.13,102.09 125.03,102.19 124.75,102.19 124.62,102.32 124.62,103.23 124.67,103.28 125.08,103.28 125.2,103.41 125.2,104.12 125.26,104.17 125.69,104.17
+VCCCOREG0 on IN1: 124.31,103.8 124.31,103.81 124.31,103.89 124.35,103.93 125.68,103.93 125.72,103.89 125.72,100.91 125.68,100.87 124.35,100.87 124.31,100.91
+VCCCOREG0 on IN3: 123.93,104.17 125.2,104.17 125.46,103.92 125.46,101.51 125.2,101.25 124.06,101.25 123.81,101.51 123.81,104.05
+VCCCOREG0 on GND4: 124.14,101.24 123.95,101.43 123.95,101.61 124.11,101.77 124.95,101.77 125.06,101.89 125.06,102.37 124.92,102.51 124.06,102.51 123.95,102.63 123.95,102.75 124.06,102.87 124.29,102.87 124.47,103.04 124.75,103.04 124.91,103.21 124.91,103.46 124.77,103.6 124.11,103.6 123.97,103.74 123.97,103.87 124.09,103.98 124.72,103.98 124.85,104.11 125.56,104.11 125.65,104.02 125.65,103.69 125.39,103.44 125.39,103.13 125.6,102.93 125.6,102.5 125.42,102.32 125.42,101.99 125.6,101.81 125.6,101.66 125.18,101.24
+VCCCOREG0 on VCC: 125.31,99.97 125.22,100.06 125.22,100.39 124.98,100.63 124.82,100.63 124.77,100.68 124.58,100.68 124.58,101.36 124.48,101.46 124.48,104.1 124.56,104.17 124.56,104.29 125.71,104.29 125.72,104.27 125.72,99.97
+VCCCOREG1 on BOTTOM: 125.28,108.69 125.69,108.69 125.71,108.67 125.71,104.38 125.68,104.34 125.29,104.34 125.03,104.61 124.67,104.61 124.62,104.66 124.62,104.99 124.67,105.04 125.05,105.04 125.15,105.13 125.15,105.63 125.05,105.72 124.72,105.72 124.62,105.82 124.62,106.74 124.72,106.84 125.08,106.84 125.15,106.92 125.15,107.4 125.08,107.48 124.69,107.48 124.62,107.55 124.62,107.91 124.69,107.98 125.08,107.98 125.2,108.11 125.2,108.62
+VCCCOREG1 on IN1: 124.31,107.8 124.35,107.84 125.67,107.84 125.72,107.8 125.72,104.82 125.68,104.78 124.35,104.78 124.31,104.82
+VCCCOREG1 on IN3: 123.93,107.35 125.46,107.35 125.58,107.22 125.58,105.06 125.2,104.68 124.06,104.68 123.81,104.94 123.81,107.22
+VCCCOREG1 on GND4: 124.11,104.69 124,104.81 124,105.04 124.11,105.15 124.9,105.15 125.06,105.32 125.06,105.5 124.85,105.71 124.21,105.71 123.97,105.95 123.97,106.13 124.11,106.27 124.26,106.27 124.4,106.41 124.4,106.79 124.24,106.95 124.11,106.95 123.97,107.1 123.97,107.25 124.16,107.44 125.56,107.44 125.62,107.37 125.62,106.92 125.39,106.69 125.39,106.51 125.62,106.28 125.62,105.8 125.39,105.57 125.39,105.37 125.6,105.16 125.6,104.94 125.35,104.69
+VCCCOREG1 on VCC: 124.52,104.41 124.4,104.53 124.4,104.91 124.45,104.96 124.45,105.87 124.48,105.9 124.48,107.17 124.38,107.27 124.38,107.4 124.5,107.53 124.5,108.42 125.23,108.42 125.43,108.62 125.67,108.62 125.67,104.41
+VCCPRIM_1P0 on IN2: 129.9,108.49 130.92,108.49 131.55,107.86 131.55,107.6 132.57,106.59 132.57,105.44 132.31,105.19 131.81,105.19 131.55,104.94 131.55,104.55 132.06,104.05 132.19,104.05 132.57,103.67 132.57,103.28 132.19,102.9 131.55,102.9 130.92,103.54 129.9,103.54 129.65,103.79 129.65,104.94 130.28,105.57 130.28,107.6 129.77,108.11 129.77,108.36
