# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_CLK2_R: length 2.4
  TOP w0.119: RA54.2 30.86,24.38 31.71,23.54 UA1.2
DMIC_DATA1: length 230.8
  TOP w0.119: JDMIC1.3 v10(86.48,137.33) ; RA52.1 35.59,25.5 35,26.09 v7(34.78,26.09)
  IN1 w0.089: v1(95.69,129.32) 95.69,130.54 v3(95.87,130.72)
  GND1 w0.119: v10(86.48,137.33) 86.48,136.36 v4(86.36,136.24)
  IN2 w0.084: v4(9.86,88.86) 9.99,88.99 10.81,88.99 12.21,87.59 12.21,80.46 10.7,78.96 10.7,74.72 8.03,72.05 8.02,72.05 5.42,69.45 5.42,60.1 6.21,59.31 6.21,48.09 6.73,47.57 6.73,47.17 11.87,42.03 11.87,37.21 12.75,36.32 12.75,32.01 13.57,31.2 13.57,29.8 16.81,26.56 18.39,26.56 19.23,25.72 19.23,25.09 20.78,23.54 24.2,23.54 25.87,25.21 33.89,25.21 v7(34.78,26.09) ; v3(95.87,130.72) 95.51,130.72 94.52,131.71 89.68,131.71 v4(88.56,130.59) 88.44,130.47 82.07,130.47 80.76,129.15 79.06,129.15 74.17,124.26 73.73,124.26 72.63,123.17 70.63,123.17 70.38,122.92 68.33,122.92 64.88,119.46 64.88,118.36 62.26,115.74 62.26,112.02 59.21,108.97 59.21,106.68 59.52,106.36 59.52,105.53 59.97,105.08 59.97,103.64 59.44,103.11 58.57,103.11 58.13,103.55 53.2,103.55 52.59,104.15 52.59,104.9 47.31,110.19 40.27,110.19 38.66,108.58 38.43,108.58 v4(38.11,108.25)
  IN3 w0.084: v4(38.11,108.25) 38.11,107.42 38.17,107.36 38.17,105.46 37.52,104.81 37.52,104.61 36.79,103.88 35.12,102.22 32.11,102.22 31.13,103.2 18.84,103.2 18.76,103.12 16.12,103.12 9.93,96.94 9.93,91.73 9.05,90.85 9.05,90.58 9.05,89.52 9.71,88.86 v4(9.86,88.86)
  GND4 w0.119: v4(86.36,136.24) 86.42,136.18 v9(86.42,135.46) ; v9(88.96,131.15) 88.68,130.87 88.68,130.7 v4(88.56,130.59)
  BOTTOM w0.119: v9(88.96,131.15) 88.96,131.66 87.53,133.08 87.53,134.35 v9(86.42,135.46) ; v14(34.78,26.86) v7(34.78,26.09) CA36.1
DMIC_DATA1_R: length 5.5
  TOP w0.119: UA1.54 33.39,20.63 33.94,21.18 33.94,23.49 34.28,23.83 34.28,24.87 RA52.2
DMIC_DATA2: length 226.2
  TOP w0.119: RA55.1 28.93,25.58 v7(29.44,26.09) ; C283.1 96.04,127.89 96.04,129.9 v2(96.2,130.06) ; JDMIC1.9 v10(87.67,137.33)
  GND1 w0.119: v4(87.66,136.22) 87.67,136.23 v10(87.67,137.33)
  IN2 w0.084: v7(29.44,26.09) 28.93,25.58 25.71,25.58 24.05,23.91 20.94,23.91 19.6,25.25 19.6,25.87 18.55,26.93 16.97,26.93 13.94,29.96 13.94,31.35 13.12,32.16 13.12,38.33 13.36,38.56 13.36,41.07 7.1,47.33 7.1,47.73 6.58,48.25 6.58,59.47 5.79,60.26 5.79,69.24 11.07,74.52 11.07,78.8 12.62,80.34 12.62,87.99 10.66,89.96 v4(9.84,89.96) ; v2(96.2,130.06) 95.65,130.06 94.38,131.32 90.55,131.32 v4(89.82,130.59) 89.2,129.96 87.75,129.96 87.62,130.1 82.22,130.1 80.88,128.75 79.2,128.75 74.28,123.83 73.82,123.83 72.73,122.74 70.72,122.74 70.51,122.53 70.13,122.53 70.08,122.47 68.51,122.47 65.3,119.26 65.3,118.26 62.69,115.65 62.69,111.79 59.58,108.68 59.58,106.83 59.89,106.52 59.89,105.68 60.99,104.58 60.99,102.83 60.69,102.53 52.95,102.53 52.22,103.26 52.22,104.75 47.15,109.82 40.42,109.82 39.14,108.54 v4(39.14,108.31)
  IN3 w0.084: v4(9.84,89.96) 9.43,90.36 9.43,90.7 10.3,91.58 10.3,96.77 16.28,102.75 18.91,102.75 18.99,102.83 30.97,102.83 32.02,101.78 35.23,101.78 37.89,104.44 37.89,104.6 38.55,105.26 38.55,106.81 39.14,107.4 v4(39.14,108.31)
  GND4 w0.119: v4(89.82,130.59) v9(89.82,131.17) ; v4(87.66,136.22) 87.66,136.15 87.31,135.8 v9(87.3,135.8)
  BOTTOM w0.119: v7(29.44,26.09) CA40.1 ; v9(89.82,131.17) 89.82,131.76 88.58,133 v14(88.58,133.23) 88.58,133.88 87.3,135.16 v9(87.3,135.8)
DMIC_DATA2_R: length 3.7
  TOP w0.119: RA55.2 29.77,23.67 30.71,23.67 30.91,23.47 UA1.4
DP_CFG0: length 2.8
  TOP w0.119: U23.59 59.48,92.78 60,93.3 60,93.7 R183.2
DP_MUX_SEL: length 248.7
  TOP w0.119: U23.18 51.43,95.16 51.35,95.23 v1(51.34,95.23)
  IN1 w0.089: v8(230.12,138.5) 229.99,138.5 229.67,138.82 224.41,138.82 223.92,139.31 223.18,139.31 221.68,140.81 221.18,140.81 220.66,140.29 219.83,140.29 219.42,139.88 216.31,139.88 215.69,140.51 212.48,140.51 212.42,140.57 212.13,140.57 211.73,140.98 209,140.98 208.29,140.27 207.68,140.27 206.51,139.1 206.51,138.84 205.18,137.52 204.48,137.52 202.27,135.31 191.87,135.31 188.07,131.5 186.77,131.5 185.05,129.77 185.05,125.97 184.79,125.71 180.37,125.71 180.14,125.94 180.14,128.08 178.18,130.05 173.93,130.05 173.47,130.51 172.45,130.51 170.95,132.01 164.31,132.01 163.9,132.42 163.23,132.42 162.69,132.95 159.99,132.95 159.76,132.72 156.12,132.72 155.89,132.95 154.3,132.95 154.09,132.75 149.73,132.75 148.67,131.69 145.26,131.69 143.87,130.3 142.34,130.3 141.54,129.5 141.54,127.96 140.64,127.07 138.32,127.07 138.21,126.96 136.12,126.96 134.16,128.92 132.03,128.92 130.2,130.75 123.34,130.75 122.95,130.37 120.45,130.37 120.05,130.77 116.54,130.77 116.18,130.41 116.18,128.77 115.43,128.02 114.28,128.02 113.62,127.36 111.61,127.36 109.91,129.07 109.91,130.05 108.5,131.46 105.19,131.46 105.06,131.59 104.28,131.59 104.1,131.76 101.84,131.76 100.9,130.82 99.96,130.82 96.41,127.27 94.42,127.27 93.38,126.23 89.21,126.23 88.81,126.63 86.82,126.63 86.22,126.02 81.58,126.02 75.86,120.3 72.73,120.3 70.42,117.99 69.04,117.99 67.75,116.7 67.75,115.93 65.76,113.94 65.76,111.43 64.4,110.07 64.4,101.54 60.34,97.48 51.75,97.48 51.02,96.75 51.02,95.67 51.34,95.35 v1(51.34,95.23)
  GND1 w0.119: v4(230.51,138.36) 230.25,138.36 v8(230.12,138.5)
  IN2 w0.084: v2(229.81,122.25) 229.95,122.11 v4(229.95,121.88)
  IN3 w0.084: v4(229.95,121.88) 229.95,122.3 230.61,122.97 230.61,123.38 232.11,124.87 232.11,125.27 232.7,125.86 232.7,126.75 233.1,127.15 233.1,131.52 232.51,132.12 232.51,134.31 231.98,134.83 231.98,136.89 v4(230.51,138.36)
DPRC_RBIAS: length 4.6
  TOP w0.119: RT3.1 26.16,28.84 v1(26.02,28.98)
  IN1 w0.089: v1(25.9,32.74) 26.02,32.63 26.02,31.49 25.8,31.28 25.8,29.19 v1(26.02,28.98)
DPSNK1_AUX_N: length 4.3
  IN2 w0.084: v2(28.5,35.34) 28.71,35.55 28.71,35.67 30.04,37 v2(32.05,37)
DPSNK1_AUX_P: length 4.4
  IN2 w0.084: v2(29.15,35.34) 29.06,35.34 28.87,35.53 28.87,35.6 30.11,36.84 31.66,36.84 31.72,36.79 31.72,36.65 31.77,36.6 31.88,36.6 v2(32.05,36.43)
DPSNK1_ML0_N: length 3
  TOP w0.076: UT1.AC15 30.24,36.72 30.17,36.79 30.17,36.89 30.23,36.95 30.49,36.95 30.67,36.77
  TOP w0.081: 30.7,36.77 30.67,36.77
  TOP w0.152: 30.7,36.77 30.83,36.77 31.14,37.08 31.14,37.45 31.69,38.01 31.9,38.01 C1262.1
DPSNK1_ML0_P: length 3
  TOP w0.076: UT1.AB15 30.08,36.49 31.03,36.49
  TOP w0.152: C1261.1 31.94,37.67 31.83,37.67 31.48,37.31 31.48,36.94 31.03,36.49
DPSNK1_ML1_N: length 3
  TOP w0.076: UT1.AC17 30.17,37.64 30.12,37.59 30.12,37.49 30.2,37.41 30.49,37.41 30.73,37.65
  TOP w0.081: 30.78,37.65 30.73,37.65
  TOP w0.152: C1264.1 31.89,38.85 31.78,38.85 31.62,38.69 31.62,38.47 30.8,37.65 30.8,37.66 30.78,37.66 30.78,37.65
DPSNK1_ML1_P: length 3
  TOP w0.076: 30.52,37.87 30.08,37.87 UT1.AB17
  TOP w0.081: 30.58,37.9 30.56,37.9 30.52,37.87
  TOP w0.152: 30.58,37.9 31.29,38.61 31.29,38.83 31.64,39.19 31.93,39.19 C1263.1
DPSNK1_ML2_N: length 3.2
  TOP w0.076: 30.55,38.33 30.19,38.33 30.13,38.39 30.13,38.5 30.19,38.56 UT1.AC19
  TOP w0.081: 30.55,38.33 30.79,38.57 31.03,38.81 31.03,38.98 31.05,39 31.05,39.04 31.15,39.14
  TOP w0.152: 31.15,39.14 31.59,39.58 31.59,39.78 31.76,39.94 31.95,39.94 C1266.1
DPSNK1_ML2_P: length 3.2
  TOP w0.076: 30.58,38.79 30.09,38.79 UT1.AB19
  TOP w0.081: 30.58,38.79 30.77,38.98 30.77,39.09 30.79,39.11 30.79,39.24 30.91,39.36 30.91,39.38
  TOP w0.152: 30.91,39.38 31.25,39.72 31.25,39.92 31.62,40.28 31.88,40.28 C1265.1
DPSNK1_ML3_N: length 3.6
  TOP w0.076: 30.63,39.38 30.5,39.25 30.22,39.25 30.14,39.33 30.14,39.44 30.18,39.48 UT1.AC21
  TOP w0.081: 30.63,39.38 30.63,39.47 30.92,39.76 30.92,40.23 30.97,40.28
  TOP w0.152: C1268.1 31.81,41 31.71,41.11 31.33,41.11 30.97,40.74 30.97,40.28
DPSNK1_ML3_P: length 3.7
  TOP w0.076: 30.65,39.87 30.49,39.71 30.08,39.71 UT1.AB21
  TOP w0.081: 30.63,40.28 30.65,40.26 30.65,39.87
  TOP w0.152: C1267.1 31.9,41.44 31.19,41.44 30.63,40.88 30.63,40.28
DPSNK_RBIAS: length 10.5
  IN1 w0.089: v1(29.15,37.94) 29.47,38.26 29.47,40.19 30.1,40.81 30.1,41.82 29.58,42.34 29.58,44.72 29.06,45.23 28.11,45.23 27.83,44.95 27.83,44.26 v1(27.59,44.03)
DPWROK: length 134.9
  IN1 w0.06: 164.06,123.15 165,123.15 165.15,123 166.99,123 v1(167.19,122.8)
  IN1 w0.089: v3(146.06,130.7) 146.06,130.21 146.49,129.78 146.49,124.98 147.07,124.39 147.07,122.35 147.34,122.08 147.68,122.08 148.6,122.99 149.06,122.99 151.38,120.67 158.17,120.67 159.45,121.96 159.45,122.39 159.77,122.7 161.83,122.7 162.46,123.34 162.9,123.34 163.09,123.15 164.06,123.15 ; v3(104.25,137.37) 104.62,137.74 129.8,137.74 129.98,137.56 v3(129.98,137.5)
  IN2 w0.084: v2(56.81,148.69) 57.7,149.58 72.25,149.58 77.42,144.41 77.42,141.21 80.29,138.34 103.28,138.34 v3(104.25,137.37) ; v3(146.06,130.7) 145,131.76 141.86,131.76 141.52,131.42 131.98,131.42 130.36,133.04 130.36,133.59 129.22,134.73 129.22,135.17 129.98,135.94 v3(129.98,137.5)
EC_ALWON: length 1.8
  TOP w0.119: R184.1 233.58,126.97 U27.E1
EC_IN_VOLUMEDOWN#: length 291.2
  TOP w0.119: R1072.1 v1(11.47,94.06)
  IN1 w0.089: v1(11.47,94.06) 11.58,94.06 11.86,94.34 15.63,94.34 15.79,94.18 16.84,94.18 17.44,94.78 19.71,94.78 20.5,95.56 24.66,95.56 25.63,94.59 26.4,94.59 28.85,97.04 29.19,97.04 31.48,99.32 34.19,99.32 34.65,98.86 39.29,98.86 40.66,100.23 43.67,100.23 46.53,103.09 46.53,104.98 48.03,106.48 48.03,110.71 50.28,112.97 50.87,112.97 52.36,114.46 52.36,116.79 54.5,118.93 59.07,118.93 59.45,118.55 60.43,118.55 63.88,122 63.88,122.72 65.63,124.47 65.97,124.47 68.1,126.6 70.89,126.6 71.83,127.54 74.84,127.54 75.31,128.01 75.66,128.01 76.14,128.49 76.14,129.17 79.34,132.36 81.89,132.36 v3(82.23,132.02) ; v5(147.48,116.34) 147.6,116.22 149.96,116.22 150.34,115.84 150.6,115.84 153.8,112.63 157.92,112.63 158.34,113.05 163.21,113.05 163.26,113 164.21,113 168.02,109.19 168.54,109.19 170.72,107.01 172.75,107.01 173.11,106.64 175.02,106.64 175.29,106.38 178.11,106.38 178.58,106.84 179.15,106.84 179.78,107.48 185.66,107.48 188.42,110.24 188.42,111.64 193.73,116.95 193.73,120.8 194.1,121.18 194.1,122.07 196.04,124.01 197.79,124.01 198.87,125.09 202.8,125.09 203.11,125.4 203.54,125.4 204.55,126.4 205.04,126.4 210.68,132.04 211,132.04 213.78,134.82 227.94,134.82 229.37,133.39 229.37,130 230.02,129.34 231.76,129.34 232.04,129.62 234.22,129.62 234.75,129.09 234.75,128.43 233.84,127.52 233.84,126.69 234.04,126.49 234.04,126.03 234.13,125.94 234.13,125.74 233.9,125.51 233.73,125.51 233.53,125.31 233.53,125.18 233.75,124.96 233.75,124.35 233.94,124.16 233.94,123.05 234.04,122.94 234.04,121.48 v10(233.81,121.25)
  GND1 w0.119: v10(233.81,121.25) 233.99,121.25 v4(234.17,121.06) ; v5(147.48,116.34) 147.45,116.31 147.12,116.31 v4(147.1,116.29)
  IN2 w0.084: v3(82.23,132.02) 82.42,132.22 v4(82.42,132.35)
  GND3 w0.119: v4(147.1,116.29) 146.75,116.29 145.45,115 143.07,115 142.56,114.48 141.46,114.48 140.92,115.02 139.15,115.02 138.79,114.67 138.17,114.67 137.82,115.02 137.14,115.02 137.09,114.97 134.74,114.97 134.34,114.58 122,114.58 117.38,119.2 114.61,119.2 113.55,120.25 112.75,120.25 111.6,121.39 102.12,121.39 98.42,125.1 97.19,125.1 96.2,126.09 90.15,126.09 86.77,129.47 85.66,129.47 83.52,131.61 83.17,131.61 v4(82.42,132.35)
  GND4 w0.119: v4(234.17,121.06) 233.97,120.86 v9(233.97,120.71)
  BOTTOM w0.119: R1057.1 233.97,121.13 v9(233.97,120.71)
EC_IN_VOLUMEUP#: length 285.1
  TOP w0.119: v1(13.35,94.06) R1071.1
  IN1 w0.089: v10(233.81,121.75) 233.81,122.8 233.54,123.07 233.54,124.96 233.34,125.16 233.34,125.39 233.56,125.61 233.56,125.84 233.41,125.99 233.18,125.99 233.05,126.12 233.05,127.44 231.8,128.68 229.75,128.68 229.52,128.91 229.52,129.57 229.18,129.92 229.18,131.9 226.45,134.63 213.86,134.63 210.97,131.75 210.66,131.75 205.12,126.21 204.63,126.21 203.62,125.2 203.19,125.2 202.77,124.79 202.13,124.79 201.81,124.47 200.97,124.47 200.54,124.9 198.94,124.9 197.8,123.76 196.09,123.76 194.29,121.96 194.29,121.1 193.92,120.72 193.92,116.87 188.63,111.57 188.63,110.18 185.74,107.29 179.86,107.29 179.23,106.65 178.66,106.65 178.19,106.19 175.21,106.19 174.94,106.45 173.01,106.45 172.7,106.76 170.69,106.76 168.48,108.97 167.96,108.97 164.13,112.81 163.18,112.81 162.8,112.43 161.37,112.43 160.94,112.86 158.42,112.86 157.98,112.43 153.72,112.43 150.51,115.65 150.26,115.65 149.88,116.03 147.75,116.03 v5(147.45,115.73) ; v1(13.35,94.06) 13.4,94.12 15.5,94.12 15.63,93.99 16.92,93.99 17.52,94.59 19.79,94.59 20.57,95.37 24.58,95.37 25.55,94.39 26.48,94.39 28.89,96.81 29.23,96.81 30.31,97.89 31.68,97.89 32.91,99.12 34.12,99.12 34.56,98.67 39.37,98.67 40.74,100.04 43.75,100.04 46.72,103.01 46.72,104.9 48.22,106.4 48.22,110.63 50.34,112.75 50.92,112.75 52.55,114.38 52.55,116.71 54.58,118.74 58.99,118.74 59.39,118.35 60.53,118.35 64.08,121.89 64.08,122.64 65.68,124.24 66.02,124.24 68.18,126.4 70.97,126.4 71.89,127.32 74.89,127.32 75.39,127.82 75.93,127.82 78.47,130.36 78.47,130.95 79.69,132.17 81.56,132.17 v3(81.69,132.04)
  GND1 w0.119: v5(147.45,115.73) 147.05,115.73 v4(147.05,115.73) ; v4(233.94,122.11) 233.81,121.97 v10(233.81,121.75)
  IN2 w0.084: v4(81.9,132.37) 81.9,132.24 v3(81.69,132.04)
  GND3 w0.119: v4(147.05,115.73) 146.5,115.73 145.55,114.78 143.16,114.78 142.65,114.26 141.37,114.26 140.83,114.8 139.24,114.8 138.89,114.45 138.08,114.45 137.72,114.8 137.23,114.8 137.18,114.75 134.83,114.75 134.44,114.36 121.9,114.36 117.29,118.97 114.52,118.97 113.5,120 112.57,120 111.45,121.12 102.09,121.12 98.41,124.8 97.02,124.8 96.06,125.76 90.15,125.76 86.77,129.14 85.53,129.14 84.94,129.73 83.9,129.73 81.9,131.73 v4(81.9,132.37)
  GND4 w0.119: v9(234.14,122.47) 234.14,122.33 233.94,122.13 v4(233.94,122.11)
EC_PROCHOT#: length 6.2
  TOP w0.119: v1(228.21,118.93) Q25.2
  IN1 w0.089: v1(228.21,118.93) 228.21,118.93 228.21,119.12 230.02,120.93 230.02,121.34 230.18,121.51 230.41,121.51 230.57,121.67 230.57,122.4 230.68,122.5 230.89,122.5 231.06,122.66 231.06,122.86 231.31,123.1 v1(231.31,123.25)
EC_REST#: length 13.8
  TOP w0.119: U715.5 239.39,131.28 239.01,131.66 v2(239.01,131.73) 239.01,132.22 C56.1 ; D22.1 229.35,134.04 232.99,134.04 v1(233.15,134.21)
  IN1 w0.089: v1(233.15,134.21) 233.15,133.28 233.94,132.49 236.02,132.49 v3(236.24,132.71)
  IN2 w0.084: v3(236.24,132.71) 237.05,132.71 238.03,131.73 v2(239.01,131.73)
EC_SLP_S0IX#: length 5.7
  TOP w0.119: R166.2 R165.2 231.45,117.54 v1(230.92,118.07)
  IN1 w0.089: v1(230.92,118.07) 231.08,118.23 231.08,118.68 230.83,118.93 230.83,119.31 231.01,119.49 231.01,120.39 231.28,120.66 231.59,120.66 231.81,120.87 v1(231.81,121.25)
EC_WAKE#_L: length 19.9
  TOP w0.119: RH82.2 142.79,121.6 v2(142.63,121.6)
  IN2 w0.06: v2(131.9,110.41) 132,110.51 132,110.73 132.14,110.87 132.34,110.87 132.62,111.15 132.98,111.15 133.61,111.78 134.03,111.78 134.74,112.48
  IN2 w0.084: 134.74,112.48 136.45,114.19 137.31,114.19 138.03,114.91 138.03,115.63 139.06,116.66 139.06,117.99 138.73,118.32 138.73,118.89 139.06,119.21 139.06,120.89 139.88,121.71 142.51,121.71 v2(142.63,121.6)
EDP_AUXN: length 77.1
  IN2 w0.06: v4(121.29,95.09) 121.53,95.09 122.75,96.31 122.75,98.34 123.09,98.68 123.09,98.91 123.01,98.99 123.01,99.16 123.21,99.36 v2(123.21,99.57)
  IN3 w0.084: v6(175.62,95.88) 175.52,95.98 175.52,96.12 175.21,96.44 168.82,96.44 168.33,95.95 168.33,95.67 164.55,91.88 161.51,91.88 161.02,91.39 161.02,90.37 160.93,90.28 160.7,90.28 160.59,90.38 160.59,90.73 160.4,90.92 160.03,90.92 159.85,90.75 159.85,90.36 159.76,90.28 159.6,90.28 159.51,90.36 159.51,90.75 159.33,90.92 159.03,90.92 158.85,90.75 158.85,90.36 158.77,90.28 158.6,90.28 158.52,90.36 158.52,90.75 158.34,90.92 158.03,90.92 157.86,90.75 157.86,90.36 157.77,90.28 157.6,90.28 157.52,90.36 157.52,90.75 157.34,90.92 157.04,90.92 156.86,90.75 156.86,90.36 156.78,90.28 156.61,90.28 156.52,90.36 156.52,90.75 156.35,90.92 156.04,90.92 155.86,90.75 155.86,90.36 155.78,90.28 155.61,90.28 155.53,90.36 155.53,90.75 155.35,90.92 155.05,90.92 154.87,90.75 154.87,90.36 154.78,90.28 154.62,90.28 154.53,90.36 154.53,90.75 154.35,90.92 150.42,90.92 147.8,88.31 141.38,88.31 139.18,86.11 129.67,86.11 128.55,87.24 127.15,87.24 124.66,89.73 124.35,89.73 122.77,91.31 122.77,92.86 122.43,93.21 122.43,94.38 121.81,94.99 121.39,94.99 v4(121.29,95.09)
EDP_AUXN_CONN: length 1.7
  TOP w0.152: JLVDS1.35 175.65,94.81 175.53,94.93 175.53,95.49 L61.4
EDP_AUXN_R: length 1.8
  TOP w0.152: v7(175.6,97.42) 175.47,97.29 175.47,96.91 175.58,96.8 L61.1
  BOTTOM w0.152: v7(175.6,97.42) 175.46,97.29 175.46,96.62 C45.2
EDP_AUXP: length 77.1
  IN2 w0.06: v2(123.21,99.07) 123.21,99.07 123.21,98.63 122.87,98.29 122.87,96.26 121.48,94.87 121.48,94.69 121.37,94.58 v4(121.28,94.58)
  IN3 w0.084: v6(174.99,95.88) 175.27,95.88 175.36,95.97 175.36,96.05 175.14,96.27 168.89,96.27 168.5,95.88 168.5,95.6 164.62,91.72 161.58,91.72 161.18,91.32 161.18,90.3 160.99,90.11 160.63,90.11 160.43,90.32 160.43,90.66 160.33,90.76 160.09,90.76 160.01,90.68 160.01,90.29 159.83,90.11 159.53,90.11 159.35,90.29 159.35,90.68 159.27,90.76 159.1,90.76 159.01,90.68 159.01,90.29 158.84,90.11 158.53,90.11 158.35,90.29 158.35,90.68 158.27,90.76 158.1,90.76 158.02,90.68 158.02,90.29 157.84,90.11 157.54,90.11 157.36,90.29 157.36,90.68 157.27,90.76 157.11,90.76 157.02,90.68 157.02,90.29 156.84,90.11 156.54,90.11 156.36,90.29 156.36,90.68 156.28,90.76 156.11,90.76 156.03,90.68 156.03,90.29 155.85,90.11 155.55,90.11 155.37,90.29 155.37,90.68 155.28,90.76 155.12,90.76 155.03,90.68 155.03,90.29 154.85,90.11 154.55,90.11 154.37,90.29 154.37,90.68 154.29,90.76 150.48,90.76 147.87,88.15 141.45,88.15 139.25,85.95 129.61,85.95 128.48,87.08 127.08,87.08 124.59,89.57 124.29,89.57 122.61,91.24 122.61,92.8 122.27,93.14 122.27,94.31 121.75,94.83 121.53,94.83 v4(121.28,94.58)
EDP_AUXP_CONN: length 1.7
  TOP w0.152: JLVDS1.36 175.15,94.81 175.19,94.85 175.19,95.39 L61.3
EDP_AUXP_R: length 1.8
  TOP w0.152: L61.2 175.13,96.9 175.13,97.32 v7(175.04,97.42)
  BOTTOM w0.152: C44.2 175.16,96.64 175.16,97.3 v7(175.04,97.42)
EDP_DISP: length 2.9
  TOP w0.119: UC1.A40 124.19,97.24 124.19,97.04 124.75,96.48 TC17.1 124.52,95.92 124.15,95.55 RC2.2
EDP_HPD: length 56.7
  TOP w0.089: 137.32,95.66 137.08,95.91 136.53,95.91 136.09,96.34 136.09,96.65 135.28,97.47 134.97,97.47 134.75,97.25 134.23,97.25 134.05,97.43 UC1.A7
  TOP w0.119: JLVDS1.24 181.15,94.79 v2(181.24,94.88) ; 137.32,95.66 137.83,95.16 138.53,95.16 139.13,94.55 RC3.2 139.01,94.39 v1(138.69,94.39)
  IN1 w0.089: v3(181.21,92.93) 181.21,92.8 178.49,90.08 170.21,90.08 169.8,90.48 167.57,90.48 165.27,92.78 163,92.78 162.43,93.35 158.16,93.35 157.75,93.75 155.21,93.75 154.97,93.99 153.85,93.99 153.68,93.81 152.38,93.81 152.08,94.11 150.47,94.11 149.61,93.25 147.12,93.25 146.82,93.56 145.9,93.56 145.81,93.46 139.83,93.46 139.5,93.78 139.41,93.78 138.8,94.39 v1(138.69,94.39)
  IN2 w0.084: v3(181.21,92.93) 181.21,94.85 v2(181.24,94.88)
EDP_I2C_CLK: length 19
  TOP w0.119: v2(181.87,96.36) 181.87,96.33 182.76,95.43 184.01,95.43 184.65,94.8 JLVDS1.17 ; v2(178.31,98.94) 178.12,99.14 178.12,102.42 178.79,103.1 180.4,103.1 180.63,103.33 180.63,104.3 180.85,104.53 181.97,104.53 182.3,104.2 Q346.4
  IN2 w0.084: v2(178.31,98.94) 178.31,98.44 179.17,97.59 179.17,97.27 180.08,96.36 v2(181.87,96.36)
EDP_I2C_DAT: length 16.5
  TOP w0.119: Q346.1 181,102.39 180.51,102.88 178.89,102.88 178.34,102.33 178.34,99.32 178.67,98.99 v2(178.67,98.94) ; JLVDS1.16 185.15,94.61 184.11,95.65 183.14,95.65 v2(182.43,96.36)
  IN2 w0.084: v2(178.67,98.94) 178.67,98.35 179.36,97.66 179.36,97.35 180.07,96.63 182.16,96.63 v2(182.43,96.36)
EDP_I2C_DELAY: length 66.2
  TOP w0.06: 229.32,122.78 229.53,123 229.97,123 230.06,123.09 230.06,123.5 U27.M7
  TOP w0.119: Q346.5 v1(181.65,101.97) ; 229.32,122.78 228.29,121.75 R5743.2 R5743.1 v1(226.28,121.75)
  IN1 w0.089: v1(181.65,101.97) 181.7,101.97 182.05,101.61 183.08,101.61 183.34,101.88 184.54,101.88 185.16,102.5 187.76,102.5 188.11,102.85 189.23,102.85 190.3,103.92 190.3,105.05 191.57,106.32 191.57,106.81 192.49,107.74 192.49,110.05 199.06,116.62 199.06,117.03 200.47,118.44 203.64,118.44 204.1,118.91 205.49,118.91 208.97,122.39 211.04,122.39 213.53,124.87 216.16,124.87 216.98,125.69 220.93,125.69 221.68,124.94 222.05,124.94 223.09,123.9 223.09,123.35 224.7,121.75 v1(226.28,121.75)
EDP_TXN_P0: length 76
  IN2 w0.06: v2(122.24,99.32) 122.18,99.26 122.18,99.05 122.04,98.91 122.04,98.72 122.04,98.72 122.04,98.65 121.98,98.59 121.98,97.13 119.67,94.82 119.61,94.82 119.16,94.37 118.26,94.37 118.05,94.57 117.87,94.57 v4(117.69,94.75)
  IN3 w0.084: v6(173.59,95.88) 173.83,95.64 173.83,94.18 168.71,89.06 164.26,89.06 163.26,88.06 154.26,88.06 153.32,87.12 150.31,87.12 149.25,86.06 142.29,86.06 140.08,83.85 127.87,83.85 127.51,84.22 126.49,84.22 123.5,87.21 123.02,87.21 119.32,90.91 119.32,91.54 118.75,92.11 118.75,92.41 118.23,92.94 118.23,94.38 118.05,94.56 117.88,94.56 v4(117.69,94.75)
EDP_TXN_P0_CONN: length 1.7
  TOP w0.152: L58.3 173.73,95.45 173.73,94.89 173.65,94.81 JLVDS1.39
EDP_TXN_P0_R: length 1.9
  TOP w0.152: L58.2 173.63,96.93 173.73,97.04 173.73,97.42 v7(173.69,97.47)
  BOTTOM w0.152: C42.2 173.79,96.66 173.79,97.37 v7(173.69,97.47)
EDP_TXN_P1: length 76.4
  IN2 w0.06: 119.96,94.14 119.96,94.15 119.98,94.17 119.98,94.78 122.24,97.04 122.24,98.51 122.44,98.71 122.44,98.91 122.36,98.99 122.36,99.16 122.56,99.36 v2(122.56,99.57)
  IN2 w0.084: v4(118.6,93.8) 118.84,93.56 119.47,93.56 119.96,94.04 119.96,94.14
  IN3 w0.084: v6(172.07,95.88) 172.3,95.64 172.3,95.27 172.22,95.18 172.09,95.18 171.9,94.99 171.9,94.69 172.06,94.52 172.22,94.52 172.3,94.44 172.3,93.64 169.88,91.22 169.38,91.22 168.95,91.65 168.59,91.65 167.83,90.89 167.83,90.62 168.02,90.42 168.29,90.42 168.65,90.78 168.77,90.78 168.89,90.66 168.89,90.55 168.37,90.03 163.73,90.03 162.32,88.62 153.87,88.62 152.92,87.68 150.09,87.68 149.04,86.63 142.07,86.63 139.86,84.43 128.34,84.43 127.86,84.91 126.56,84.91 123.48,87.99 123.17,87.99 120.22,90.94 120.22,92.01 119.18,93.05 119.18,93.4 118.94,93.64 118.76,93.64 118.6,93.8 v4(118.6,93.8)
EDP_TXN_P1_CONN: length 1.7
  TOP w0.152: JLVDS1.42 172.15,94.81 172.23,94.89 172.23,95.43 L57.3
EDP_TXN_P1_R: length 1.8
  TOP w0.152: v7(172.12,97.44) 172.11,97.43 L57.2
  BOTTOM w0.152: C39.2 172.24,96.64 172.24,97.32 v7(172.12,97.44)
EDP_TXN_P2: length 75.8
  IN2 w0.06: v2(121.92,99.57) 121.92,99.36 121.72,99.16 121.72,98.99 121.8,98.91 121.8,98.75 121.73,98.68 121.73,97.27 120.5,96.04 119.87,96.04 118.96,95.13 118.88,95.13 118.7,94.95 118.7,94.75 118.62,94.67 v4(118.52,94.67)
  IN3 w0.084: v6(170.54,95.88) 170.54,94.84 169.16,93.46 169.16,93.21 169.37,92.99 169.63,92.99 170.69,94.05 170.8,94.05 170.92,93.94 170.92,93.82 169.56,92.45 169.44,92.45 168.92,92.97 168.67,92.97 166.38,90.69 162.49,90.69 162.19,90.39 162.19,89.64 161.73,89.17 153.64,89.17 152.7,88.24 149.73,88.24 148.68,87.19 141.83,87.19 139.63,84.98 128.88,84.98 128.17,85.69 126.52,85.69 123.39,88.82 123.24,88.82 121,91.06 121,92.3 119.77,93.53 119.77,94.75 119.14,95.37 118.8,95.37 118.56,95.13 118.56,94.71 v4(118.52,94.67)
EDP_TXN_P2_CONN: length 1.7
  TOP w0.152: JLVDS1.45 170.65,94.81 170.73,94.89 170.73,95.44 L60.3
EDP_TXN_P2_R: length 1.8
  TOP w0.152: v7(170.57,97.44) 170.62,97.39 L60.2
  BOTTOM w0.152: v7(170.57,97.44) 170.71,97.3 170.71,96.63 C412.2
EDP_TXN_P3: length 76.7
  IN2 w0.06: v2(122.89,99.32) 122.89,99.11 122.68,98.91 122.68,98.61 122.49,98.42 122.49,96.92 120.85,95.27 120.85,94.54 120.79,94.48 120.61,94.48 120.51,94.58 v4(120.51,94.67)
  IN3 w0.084: v4(120.51,94.67) 120.68,94.5 120.86,94.5 121.15,94.2 121.74,94.2 121.94,94.01 121.94,93.55 121.74,93.36 121.19,93.36 121.11,93.27 121.11,93.16 121.19,93.07 121.73,93.07 121.91,92.89 121.91,92.55 121.62,92.26 121.62,91.73 124.12,89.23 124.12,88.84 126.51,86.45 128.47,86.45 129.39,85.54 139.4,85.54 141.61,87.75 148.02,87.75 150.64,90.37 153.41,90.37 153.61,90.16 153.61,89.93 153.81,89.73 161.46,89.73 161.57,89.83 161.57,91.01 161.87,91.31 164.77,91.31 165.58,92.11 165.83,92.11 166.35,91.59 166.46,91.59 169.07,94.2 169.07,94.31 168.95,94.43 168.83,94.43 166.53,92.14 166.28,92.14 166.06,92.35 166.06,92.6 168.84,95.37 169.22,95.37 169.32,95.47 169.32,95.82 169.25,95.88 v6(169.08,95.88)
EDP_TXN_P3_CONN: length 1.7
  TOP w0.152: L59.3 169.23,95.45 169.23,94.89 169.15,94.81 JLVDS1.48
EDP_TXN_P3_R: length 1.8
  TOP w0.152: L59.2 169.12,97.45 v7(169.12,97.46)
  BOTTOM w0.152: v7(169.12,97.46) 169.23,97.35 169.23,96.61 C410.2
EDP_TXP_P0: length 76
  IN2 w0.06: v2(122.24,98.83) 122.24,98.8 122.16,98.72 122.16,98.6 122.1,98.54 122.1,97.08 119.72,94.7 119.66,94.7 119.21,94.25 118.21,94.25 118.01,94.45 117.89,94.45 v4(117.68,94.24)
  IN3 w0.084: v4(117.68,94.24) 117.84,94.4 117.98,94.4 118.07,94.31 118.07,92.87 118.59,92.35 118.59,92.04 119.16,91.47 119.16,90.84 122.95,87.04 123.44,87.04 126.42,84.06 127.44,84.06 127.8,83.69 140.15,83.69 142.36,85.9 149.32,85.9 150.38,86.96 153.38,86.96 154.33,87.9 163.33,87.9 164.32,88.9 168.78,88.9 173.99,94.11 173.99,95.64 v6(174.22,95.88)
EDP_TXP_P0_CONN: length 1.7
  TOP w0.152: L58.4 174.06,95.43 174.06,94.89 174.15,94.81 JLVDS1.38
EDP_TXP_P0_R: length 1.8
  TOP w0.152: L58.1 174.07,96.91 174.07,97.26 v7(174.25,97.45)
  BOTTOM w0.152: v7(174.25,97.45) 174.12,97.32 174.12,96.57 C43.2
EDP_TXP_P1: length 76.4
  IN2 w0.06: 120.12,94.14 120.12,94.15 120.1,94.17 120.1,94.73 122.36,96.99 122.36,98.46 122.56,98.66 122.56,98.96 122.56,98.97 v2(122.56,99.07)
  IN2 w0.084: 120.12,94.14 120.12,93.97 119.54,93.39 118.7,93.39 v4(118.59,93.28)
  IN3 w0.084: v6(172.7,95.88) 172.46,95.64 172.46,95.2 172.29,95.02 172.16,95.02 172.06,94.92 172.06,94.75 172.13,94.68 172.29,94.68 172.46,94.5 172.46,93.57 169.95,91.06 169.32,91.06 168.89,91.49 168.65,91.49 167.99,90.82 167.99,90.68 168.09,90.59 168.23,90.59 168.59,90.95 168.84,90.95 169.05,90.73 169.05,90.48 168.44,89.86 163.8,89.86 162.39,88.46 153.93,88.46 152.99,87.51 150.15,87.51 149.11,86.47 142.14,86.47 139.93,84.26 128.27,84.26 127.79,84.74 126.5,84.74 123.41,87.83 123.1,87.83 120.06,90.87 120.06,91.94 119.02,92.98 119.02,93.33 118.88,93.47 118.73,93.47 118.59,93.34 v4(118.59,93.28)
EDP_TXP_P1_CONN: length 1.7
  TOP w0.152: L57.4 172.56,95.45 172.56,94.89 172.65,94.81 JLVDS1.41
EDP_TXP_P1_R: length 1.8
  TOP w0.152: L57.1 172.66,97.43 v7(172.68,97.45)
  BOTTOM w0.152: v7(172.68,97.45) 172.55,97.31 172.55,96.62 C40.2
EDP_TXP_P2: length 75.7
  IN2 w0.06: v2(121.92,99.07) 121.92,98.96 121.92,98.96 121.92,98.7 121.85,98.63 121.85,97.22 120.55,95.92 119.92,95.92 119.01,95.01 118.93,95.01 118.82,94.9 118.82,94.74 118.88,94.67 v4(119.03,94.67)
  IN3 w0.084: v4(119.03,94.67) 119.02,94.67 118.72,94.97 118.72,95.06 118.87,95.21 119.08,95.21 119.6,94.68 119.6,93.46 120.83,92.24 120.83,90.99 123.17,88.65 123.32,88.65 126.45,85.53 128.1,85.53 128.81,84.82 139.69,84.82 141.9,87.03 148.75,87.03 149.79,88.07 152.76,88.07 153.7,89.01 161.79,89.01 162.35,89.57 162.35,90.32 162.56,90.52 166.45,90.52 168.74,92.81 168.85,92.81 169.37,92.29 169.63,92.29 171.09,93.75 171.09,94 170.87,94.22 170.62,94.22 169.56,93.16 169.44,93.16 169.32,93.28 169.32,93.39 170.7,94.78 170.7,95.66 170.81,95.77 170.81,95.78 170.92,95.88 v6(171.24,95.88)
EDP_TXP_P2_CONN: length 1.7
  TOP w0.152: JLVDS1.44 171.15,94.81 171.06,94.89 171.06,95.44 L60.4
EDP_TXP_P2_R: length 1.8
  TOP w0.152: L60.1 171.17,97.4 v7(171.13,97.45)
  BOTTOM w0.152: C413.2 171.05,96.66 171.05,97.37 v7(171.13,97.45)
EDP_TXP_P3: length 76.6
  IN2 w0.06: v4(120.5,94.16) 120.5,94.14 120.48,94.14 120.48,94.23 120.61,94.36 120.84,94.36 120.97,94.49 120.97,95.22 121.75,96.01 122.61,96.87 122.61,98.37 122.8,98.56 122.8,98.74 v2(122.89,98.83)
  IN3 w0.084: v4(120.5,94.16) 120.68,94.33 120.79,94.33 121.08,94.04 121.67,94.04 121.77,93.94 121.77,93.62 121.67,93.52 121.12,93.52 120.95,93.34 120.95,93.09 121.12,92.91 121.66,92.91 121.75,92.82 121.75,92.62 121.46,92.33 121.46,91.66 123.96,89.16 123.96,88.78 126.45,86.29 128.4,86.29 129.32,85.38 139.47,85.38 141.68,87.59 148.09,87.59 150.71,90.2 153.34,90.2 153.45,90.1 153.45,89.86 153.75,89.56 161.53,89.56 161.73,89.77 161.73,90.94 161.94,91.14 164.84,91.14 165.64,91.95 165.76,91.95 166.28,91.43 166.53,91.43 169.23,94.13 169.23,94.38 169.02,94.6 168.76,94.6 166.46,92.3 166.35,92.3 166.23,92.42 166.23,92.53 168.9,95.21 169.29,95.21 169.48,95.4 169.48,95.8 169.56,95.88 v6(169.72,95.88)
EDP_TXP_P3_CONN: length 1.7
  TOP w0.152: JLVDS1.47 169.65,94.81 169.56,94.89 169.56,95.44 L59.4
EDP_TXP_P3_R: length 1.8
  TOP w0.152: v7(169.68,97.47) 169.67,97.46 L59.1
  BOTTOM w0.152: C411.2 169.57,96.61 169.57,97.36 v7(169.68,97.47)
EMMC_RCOMP: length 2.4
  TOP w0.254: RC61.2 137.15,109.57 136.78,109.94 UC1.BC1
EMMC_RST_N: length 3.6
  IN2 w0.06: v2(132.93,105.43) 133.11,105.43 133.35,105.67 133.47,105.67 133.58,105.56 133.77,105.56 134.14,105.93 134.64,105.93 v4(134.7,105.99)
  IN3 w0.084: v4(134.7,105.99) 134.7,106.03 135.13,106.46 135.49,106.46 135.52,106.43 v6(135.54,106.43)
  BOTTOM w0.119: TC23.1 135.77,106.21 v6(135.54,106.43)
EN_CAM: length 156.5
  TOP w0.119: v2(233.42,134.73) 233.65,134.96 U30.5
  IN1 w0.06: 139.81,112.75 139.76,112.75 139.49,112.48 139.27,112.26 138.65,112.26 v3(138.61,112.3)
  IN1 w0.089: v3(225.65,119.53) 225.65,119.86 225.22,120.29 224.72,120.29 221.96,123.05 221.96,123.17 220.45,124.68 218.91,124.68 217.97,123.74 214.92,123.74 213.87,122.69 213.52,122.69 212.52,121.69 211.69,121.69 210.91,120.91 208.84,120.91 205.88,117.95 204.53,117.95 204.04,117.47 203.3,117.47 200.17,114.34 198.16,114.34 196.02,112.21 196.02,110.73 193.47,108.17 193.47,107.3 192.54,106.37 192.54,104.98 192.02,104.45 192.02,103.95 191.13,103.06 191.13,102.81 190.93,102.61 190.44,102.61 189.44,101.61 188.4,101.61 188.2,101.4 185.41,101.4 184.93,100.93 183.74,100.93 183.44,100.63 181.43,100.63 180.99,101.07 179.97,101.07 179.52,101.51 167.35,101.51 167.09,101.25 163.97,101.25 163.79,101.07 159.21,101.07 158.9,101.39 156.26,101.39 156.04,101.61 153.92,101.61 151.59,103.94 151.59,104.83 151.28,105.15 150.21,105.15 149.94,105.42 149.94,107.93 149.66,108.21 149.66,108.84 146.7,111.79 146.04,111.79 145.57,112.26 144.91,112.26 144.7,112.48 144.03,112.48 143.44,113.08 140.69,113.08 140.36,112.75 139.81,112.75
  IN2 w0.06: v3(138.61,112.3) 138.49,112.43 137.47,112.43 136.33,111.29 136.2,111.29 135.54,110.63 133.81,110.63 133.2,110.02 133.2,109.94 132.74,109.47 132.57,109.47 132.54,109.51 132.35,109.51 132.31,109.47 132.25,109.47 132.01,109.22 131.82,109.22 131.7,109.34 131.7,109.55 v2(131.58,109.67)
  IN2 w0.084: v3(225.65,119.53) 226.2,119.53 227.75,117.98 230.01,117.98 230.37,118.34 232.41,118.34 232.78,117.97 232.78,117.61 232.95,117.44 233.36,117.44 235.78,119.86 236.35,119.86 237.17,120.67 237.17,123.45 238.94,125.22 240.49,125.22 241.08,125.81 241.08,130.46 239.25,132.29 238.05,132.29 236.77,133.56 235.31,133.56 234.14,134.73 v2(233.42,134.73)
EN_INVPWR: length 62.9
  TOP w0.089: v7(188.04,99.83) 187.18,99.83 186.76,100.25 R29.1 186.8,100.53 U711.2
  IN2 w0.084: v2(231.81,122.25) v4(232.25,122.69)
  IN3 w0.084: v7(188.04,99.83) 189.13,99.83 191.04,101.74 191.04,102.56 192.82,104.34 192.82,107.22 194.84,109.24 197.87,109.24 199.24,110.61 205.86,110.61 206.31,111.06 212.18,111.06 214.44,113.31 215.37,113.31 218.29,116.23 219.85,116.23 221.73,118.11 227.42,118.11 227.83,117.7 230.82,117.7 232.31,119.2 232.31,119.49 232.06,119.74 232.06,122.31 232.25,122.5 v4(232.25,122.69)
  GND4 w0.119: v4(232.25,122.69) 231.95,122.69 v9(231.87,122.77)
  BOTTOM w0.119: v9(231.87,122.77) 231.58,122.47 R161.2
EN_PD_HV_1: length 379.3
  TOP w0.119: v10(41.28,127.24) 40.7,127.82 40.7,128.53 41.49,129.33 PU101.1 ; v10(41.74,98.18) 41.27,97.71 PR159.2 ; R1432.2 7.55,59.29 10.84,59.29 v1(10.88,59.25)
  TOP w0.254: PD402.2 54.9,137.79 54.9,139.71 54.24,140.37 53.28,140.37 52.81,140.84 52.81,142.15 v1(52.98,142.32)
  IN1 w0.089: v1(10.88,59.25) 10.88,60.4 10.11,61.17 5.32,61.17 4.64,61.85 4.64,70.92 11.59,77.87 11.59,79.56 13.28,81.25 13.28,87.75 15.1,89.57 18.72,89.57 19.4,88.9 22.83,88.9 23.59,88.14 25.55,88.14 27.19,89.78 30.05,89.78 30.37,90.1 30.37,93.12 31.64,94.39 36.45,94.39 38.52,96.45 39.97,96.45 41.7,98.18 v10(41.74,98.18) ; v3(67.35,142.15) 67.35,142.08 65.56,140.29 61.87,140.29 60.79,141.37 58.92,143.25 57.42,143.25 56.86,142.69 54.13,142.69 53.76,142.32 v1(52.98,142.32)
  IN1 w0.254: v1(52.98,142.32) 52.66,142.32 v1(51.64,143.34) 51.64,143.9 51.28,144.26 49.27,144.26 47.64,142.63 43.57,142.63 41.62,140.69 41.62,139.07 40.81,138.26 40.81,127.71 v10(41.28,127.24)
  GND1 w0.119: v10(41.74,98.18) 41.33,98.59 v4(41.18,98.59) ; v10(41.28,127.24) 41.08,127.03 v4(40.75,127.03)
  IN2 w0.084: v4(238.3,123.1) 238.25,123.05 v2(238.25,122.26) ; v3(67.35,142.15) v4(67.67,142.46)
  IN3 w0.084: v4(67.67,142.46) 67.67,140.56 68.43,139.8 68.44,139.8 70.78,137.45 79.26,137.45 79.7,137 89.78,137 90.42,136.36 96.59,136.36 v6(96.9,136.67) ; v6(142.29,133.57) 142.29,133.68 144.56,135.96 148.87,135.96 149.23,136.31 154.49,136.31 155.36,137.18 158.45,137.18 159.07,136.56 160.64,136.56 160.81,136.39 163.61,136.39 163.93,136.71 172.37,136.71 174.06,135.02 176.05,135.02 176.28,135.25 177.73,135.25 180.11,137.63 186.15,137.63 187.27,138.75 187.72,138.75 188.69,139.72 188.69,144.11 193.64,149.07 206.36,149.07 206.79,148.63 226.3,148.63 227.88,147.04 228.23,147.04 229.36,145.91 229.36,144.46 231.36,142.46 232.39,142.46 233.66,141.19 233.66,140.81 235.73,138.74 235.73,137.67 235.15,137.09 235.15,131.76 235.48,131.43 238.36,131.43 238.78,131.01 238.78,129.64 238.3,129.16 v4(238.3,123.1)
  GND4 w0.119: v4(40.75,127.03) v9(40.75,126.27) ; v4(41.18,98.59) 41.13,98.64 40.34,98.64 v6(40.27,98.56)
  BOTTOM w0.119: v6(40.27,98.56) 40.27,100.9 38.91,102.25 38.91,109.23 41.5,111.82 41.5,125.52 v9(40.75,126.27) ; v6(96.9,136.67) 97.12,136.89 101.06,136.89 101.16,136.99 125.53,136.99 127.7,134.81 127.7,131.69 128.36,131.03 140.09,131.03 142.29,133.22 v6(142.29,133.57)
EN_PD_HV_1_R: length 1.8
  TOP w0.119: R160.1 237.33,122.07 237.01,121.75 U27.A11
EN_PD_HV_2: length 381.2
  TOP w0.119: PR160.2 40.46,91.96 41.07,91.35 43.42,91.35 43.73,91.66 44.57,91.66 45.51,90.71 45.51,89 45.95,88.55 45.95,85.37 46.46,84.87 47.3,84.87 v10(47.66,84.51) ; v1(41.71,130.28) 42.09,129.9 42.09,129.38 PU101.2 42.14,129.01 PR135.1 ; R179.1 v2(231.69,115.6)
  TOP w0.254: PD403.2 55.99,138.86 56.93,139.8 56.93,140.79 55.92,141.79 v1(55.92,142.29) ; v10(38.03,97.98) 39.58,96.43 39.58,94.37 39.9,94.05 39.9,92.48 PR160.2
  IN1 w0.089: v5(47.34,83.47) 47.21,83.35 46.08,83.35 45.16,82.42 45.16,81.79 v7(45.19,81.76) ; v1(41.71,130.28) 41.63,130.2 41.63,113.26 38.79,110.42 37.55,110.42 37.4,110.27 v5(36.67,110.27)
  IN1 w0.254: v1(41.71,130.28) 41.19,130.81 41.19,131.47 41.66,131.94 41.66,134.11 41.18,134.59 41.18,138.13 42.01,138.95 42.01,140.53 43.25,141.78 47.45,141.78 49.45,143.78 49.89,143.78 v1(50.33,143.34) 50.33,143.52 50.61,143.81 51.05,143.81 51.25,143.6 51.25,143.16 52.53,141.87 54.38,141.87 54.8,142.29 v1(55.92,142.29)
  GND1 w0.119: v4(36.23,110.27) v5(36.67,110.27) ; v10(47.66,84.51) 47.34,84.2 v5(47.34,83.47)
  GND1 w0.254: v10(38.03,97.98) v4(38.03,98.4)
  IN2 w0.084: v4(233.66,113) 233.66,113.64 v2(231.69,115.6) ; v4(18.98,91.42) 18.98,89.48 19.79,88.67 19.79,87.52 17.32,85.05 17.32,79.76 18.14,78.94 18.14,66.66 21.08,63.71 21.08,61.65 22.58,60.16 22.58,57.58 23.23,56.93 v2(24.77,56.93)
  GND4 w0.119: v4(38.03,98.4) 37.88,98.55 v9(37.88,98.99) ; v4(233.66,113) v9(233.66,112.56) ; v4(18.98,91.42) 19.01,91.42 19.11,91.52 v9(19.11,91.98) ; v9(36.66,110.27) v4(36.23,110.27)
  BOTTOM w0.119: v7(45.19,81.76) 45.67,81.28 45.67,80.24 46.04,79.87 103.06,79.87 103.6,79.33 109,79.33 109.26,79.59 119.17,79.59 119.47,79.89 131.35,79.89 131.69,80.23 134.08,80.23 137.39,83.54 140.63,83.54 141.4,82.77 142.41,82.77 143.73,84.09 145.83,84.09 148.43,86.69 162.57,86.69 164.65,84.61 171.55,84.61 173.21,86.27 174.03,86.27 180.67,92.9 183.32,92.9 186.99,96.57 186.99,100.19 191.27,104.47 191.27,108.17 193.14,110.04 201.19,110.04 202.8,108.43 212.18,108.43 219.7,115.95 223.31,115.95 224.09,116.72 225.74,116.72 226.52,115.95 230.47,115.95 233.66,112.75 v9(233.66,112.56) ; 37.6,100.87 37.12,101.35 37.12,107.48 36.66,107.93 v9(36.66,110.27) ; 37.6,100.87 37.71,100.87 38.18,100.4 38.18,99.68 37.88,99.37 v9(37.88,98.99) ; 37.6,100.87 35,98.27 31.49,98.27 29.95,96.73 24.16,96.73 19.41,91.98 v9(19.11,91.98)
EN_PD_HV_2_R: length 7.9
  TOP w0.119: R179.2 v1(233.29,117.1)
  IN1 w0.06: 233.09,120.94 233.09,121.41 232.75,121.75 v1(232.31,121.75)
  IN1 w0.089: 233.09,120.94 233.09,120.21 233.72,119.58 233.72,119.26 234.18,118.8 234.18,117.46 233.83,117.1 v1(233.29,117.1)
ENBKL: length 63.9
  TOP w0.119: v2(177.51,98.94) 177.51,99.14 177.66,99.29 177.66,103.95 D2.2
  IN1 w0.06: 137.31,97.24 136.66,97.24 136.48,97.42 135.81,97.42 134.8,98.43 v1(134.56,98.43)
  IN1 w0.089: 137.31,97.24 137.47,97.24 138.16,96.55 138.64,96.55 139.01,96.19 139.46,96.19 139.99,95.66 139.99,95.31 140.21,95.08 141.99,95.08 142.34,94.73 142.34,94.53 142.84,94.03 144.79,94.03 144.89,94.13 146.08,94.13 146.41,94.46 149.99,94.46 150.44,94.9 152.37,94.9 152.51,95.04 153.08,95.04 153.22,94.9 154.73,94.9 155.5,94.13 158.65,94.13 158.89,93.89 162.48,93.89 163.2,93.16 165.43,93.16 167.73,90.86 169.96,90.86 170.28,90.55 178.11,90.55 v3(180.49,92.92)
  IN2 w0.084: v3(180.49,92.92) 180.49,95.02 178.64,96.86 178.64,97.59 177.51,98.72 v2(177.51,98.94)
ENVDD: length 77
  IN1 w0.089: v3(182.16,104.14) 182.08,104.22 179.39,104.22 179.09,103.92 v1(173.69,103.92)
  IN2 w0.084: v4(232.4,124.53) 232.4,125.2 232.81,125.61 v2(232.81,125.75) ; v4(182.59,104.33) 182.4,104.14 v3(182.16,104.14)
  IN3 w0.084: v4(232.4,124.53) 231.13,123.26 231.13,122.18 231.53,121.78 231.53,119.67 231.48,119.62 231.48,119.16 230.21,117.89 227.9,117.89 227.5,118.29 221.65,118.29 219.77,116.42 218.21,116.42 215.29,113.5 214.36,113.5 212.11,111.24 206.15,111.24 205.74,110.83 199.2,110.83 197.8,109.43 194.76,109.43 192.63,107.3 192.63,104.42 190.85,102.64 190.85,101.81 189.94,100.89 187.15,100.89 183.72,104.33 v4(182.59,104.33)
  vias: v13(172.55,105.34)
EXT_PWR_GATE#: length 24.9
  IN1 w0.06: 141.07,110.16 140.44,110.16 140.25,109.96 138.15,109.96 138.12,109.94 137.86,109.94 137.6,109.67 137.21,109.67 136.81,110.08 135.48,110.08 135.31,110.24 134.73,110.24 134.68,110.29 134.27,110.29 v1(133.91,109.94)
  IN1 w0.089: v1(152.71,100.62) 152.3,100.62 148.24,104.68 148.24,106.81 145.53,109.52 145.24,109.52 144.32,110.45 143.53,110.45 143.4,110.57 142.27,110.57 142.14,110.44 141.66,110.44 141.38,110.16 141.07,110.16
EXT_PWR_GATE#_R: length 9.7
  TOP w0.119: v10(153.66,99.58) 152.84,99.58 R1043.2 ; U40.5 155.93,94.97 v10(156.01,94.9)
  GND1 w0.119: v4(156.42,94.93) 156.42,94.93 156.04,94.93 v10(156.01,94.9) ; v10(153.66,99.58) 153.68,99.58 153.96,99.86 v4(153.96,99.91)
  GND4 w0.119: v9(153.73,99.5) 153.96,99.73 v4(153.96,99.91) ; v9(156.39,95.56) 156.38,95.55 156.38,94.97 v4(156.42,94.93)
  BOTTOM w0.119: R1225.2 154.01,99.78 v9(153.73,99.5) 153.9,99.5 156.39,97.01 v9(156.39,95.56)
G_S1: length 6.7
  TOP w0.119: PQ204.5 66.58,138.26 66.24,138.6 PU201.4 64.46,138.6 63.71,137.85 63.71,135.64 PU204.1
G_S3: length 17.3
  TOP w0.254: PU205.1 63.17,137.46 63.4,137.7 63.4,138.46 v7(63.68,138.74) ; v11(58.55,146.35) 58.55,146.92 58.23,147.25 PQ210.1
  TOP w0.356: PQ205.5 58.38,140.37 58.59,140.58 58.59,141.21 v7(58.97,141.59) 59.06,141.68 PR251.2
  IN3 w0.254: v7(63.68,138.74) 60.83,141.6 58.99,141.6 v7(58.97,141.59) 58.62,141.94 58.62,142.35 59.04,142.78 59.04,145.4 58.55,145.89 v11(58.55,146.35)
GNSS_CTS_RESET_N: length 3.2
  IN2 w0.06: v2(133.42,105.43) 133.82,105.43 134.07,105.68 134.85,105.68 v4(135.21,106.04)
  GND4 w0.119: v6(135.49,105.75) 135.49,105.76 v4(135.21,106.04)
  BOTTOM w0.119: v6(135.49,105.75) 135.49,105.62 TC26.1
GNSS_IRQ: length 165.6
  IN1 w0.06: v8(139,106.76) 138.7,106.47 138.16,106.47 138.16,106.47 135.59,106.47 135.46,106.6 134.9,106.6 134.78,106.72 134.2,106.72 133.88,106.4 v1(133.67,106.4)
  IN1 w0.089: v3(83.79,132.74) 83.59,132.53 82.26,132.53 82.05,132.74 79.18,132.74 75.04,128.61 75.04,128.28 74.72,127.95 73.52,127.95 72.95,128.53 72.57,128.53 72,127.95 70.97,127.95 69.99,126.98 67.94,126.98 65.89,124.93 65.52,124.93 63.49,122.9 63.49,122.19 60.29,118.99 59.56,118.99 59.23,119.32 54.35,119.32 51.6,116.58 50.28,116.58 49.59,115.88 49.59,113.53 49.26,113.2 49.26,112.48 47.64,110.87 47.64,106.64 46.15,105.14 46.15,103.25 43.52,100.62 40.51,100.62 39.15,99.26 34.83,99.26 34.38,99.72 22.8,99.72 v3(22.75,99.67)
  GND1 w0.119: v8(139,106.76) 139,106.71 v4(139.24,106.47)
  IN2 w0.084: v3(83.79,132.74) 84,132.52 v4(84,132.39) ; v3(22.75,99.67) 22.51,99.91 v4(21.6,99.91)
  GND3 w0.119: v4(84,132.39) 84,132.18 84.73,131.45 86.08,131.45 88.45,129.08 94.46,129.08 95.35,128.18 96.65,128.18 102.1,122.73 104.89,122.73 105.49,122.13 111.83,122.13 113.01,120.95 113.85,120.95 114.95,119.86 117.66,119.86 122.27,115.24 134.03,115.24 134.76,115.97 136.83,115.97 137.34,115.46 138.23,115.46 v4(138.39,115.3)
  IN3 w0.084: v4(138.39,115.3) 138.21,115.12 138.21,112.79 139.33,111.67 139.33,108.48 139.66,108.16 139.66,106.89 v4(139.24,106.47)
  GND4 w0.119: v4(139.24,106.47) 139.76,106.99 139.76,107.12 v9(139.88,107.25) ; v4(21.6,99.91) 21.6,100.21 v9(21.76,100.38)
  BOTTOM w0.119: v9(21.76,100.38) 21.77,100.39 21.8,100.39 22.79,101.38 R58.2 ; RH118.1 139.93,107.3 v9(139.88,107.25)
GNSS_IRQ_L: length 3.1
  BOTTOM w0.089: 22.05,104.05 JNGFF1.36
  BOTTOM w0.119: 22.05,104.05 22.05,103.52 R58.1
GNSS_OFF#: length 166.4
  TOP w0.119: v1(24.6,94.72) Q89.3
  IN1 w0.06: v1(132.68,106.4) 132.68,106.76 132.92,107 132.92,107.08 133.17,107.32 133.17,107.39 133.41,107.64 133.41,107.71 133.65,107.96 134.17,107.96 134.27,107.86 134.28,107.86 134.44,107.69 135.14,107.69 135.42,107.41 136.23,107.41 136.37,107.27 136.92,107.27 136.98,107.33 139.01,107.33 139.15,107.48 139.68,107.48 v10(139.88,107.27)
  IN1 w0.089: v3(81.28,131.69) 80.99,131.98 80.36,131.98 76.01,127.63 75.47,127.63 74.97,127.13 71.96,127.13 71.05,126.21 68.26,126.21 66.07,124.02 65.72,124.02 64.27,122.57 64.27,121.81 60.61,118.14 59.32,118.14 58.91,118.55 54.66,118.55 52.74,116.63 52.74,114.3 51,112.56 50.42,112.56 48.41,110.55 48.41,106.32 46.91,104.82 46.91,102.93 43.81,99.84 40.8,99.84 39.45,98.48 34.47,98.48 34.16,98.17 32.34,98.17 31.79,97.61 30.3,97.61 29.27,96.58 28.93,96.58 26.56,94.2 25.11,94.2 v1(24.6,94.72)
  GND1 w0.119: v10(139.88,107.27) 139.96,107.35 140.25,107.35 v4(140.32,107.29)
  IN2 w0.084: v4(81.36,132.32) 81.28,132.23 v3(81.28,131.69)
  GND3 w0.119: v4(143.07,112.86) 142.41,112.86 142.23,113.03 141.23,113.03 140.89,112.69 139.27,112.69 139.08,112.88 138.17,112.88 137.28,113.77 135.31,113.77 135.01,113.47 121.54,113.47 117.17,117.84 113.29,117.84 111.03,120.1 101.56,120.1 98.66,122.99 97.06,122.99 94.98,125.08 90.18,125.08 87.69,127.57 86.44,127.57 84.51,129.5 83.72,129.5 81.36,131.86 v4(81.36,132.32)
  IN3 w0.076: v4(143.07,112.86) 143.28,112.65 143.28,110.56 141.41,108.69 141.41,108 140.7,107.29 v4(140.32,107.29)
GNSS_OFF#_R: length 18.1
  TOP w0.119: Q89.4 27.54,94.72 27.74,94.93 28.63,94.93 29.22,94.34 30.04,94.34 R52.2 30.27,95.03 29.6,95.7 29.6,96.96 29.28,97.28 v10(27.95,97.28)
  GND1 w0.119: v4(27.34,97.33) 27.89,97.33 v10(27.95,97.28)
  GND4 w0.119: v9(26.88,97.95) 27.34,97.49 v4(27.34,97.33)
  BOTTOM w0.076: 26.55,103.92 JNGFF1.18
  BOTTOM w0.119: 26.55,103.92 28.25,102.22 28.25,99.32 v9(26.88,97.95)
GNSS_SCL: length 162.2
  IN1 w0.089: v5(89.94,133.94) 89,133 87.6,133 87.39,133.21 86.37,133.21 85.86,132.7 84.93,132.7 84.62,133.01 83.67,133.01 83.39,132.72 82.34,132.72 82.13,132.93 79.1,132.93 74.89,128.72 72.49,128.72 71.99,128.22 70.97,128.22 69.92,127.17 67.86,127.17 66.79,126.09 65.57,126.09 65.26,125.78 65.26,124.93 63.3,122.97 63.3,122.26 61.16,120.12 60.02,120.12 59.42,119.53 54.29,119.53 51.52,116.77 50.18,116.77 49.39,115.98 49.39,113.61 49.05,113.27 49.05,112.55 47.45,110.95 47.45,106.71 45.96,105.22 45.96,103.33 43.44,100.81 40.43,100.81 39.07,99.45 34.92,99.45 34.41,99.96 26.68,99.96 v5(26.55,100.08)
  GND1 w0.089: v4(26.68,100.47) 26.65,100.44 26.65,100.19 v5(26.55,100.08) ; v4(90.3,133.71) 90.07,133.94 v5(89.94,133.94)
  IN2 w0.06: v4(136.66,108.64) 136.46,108.85 136.03,108.85 135.98,108.9 135.45,108.9 134.6,108.06 134.59,108.06 134.54,108.01 133.42,108.01 v2(133.42,108.01)
  GND3 w0.084: v4(90.3,133.71) 90.3,132.82 91.26,131.87 94.03,131.87 95.2,130.7 97.39,130.7 100.84,127.25 100.84,126.72 102.97,124.58 111.82,124.58 113.07,123.33 115.59,123.33 116.79,122.12 119.67,122.12 121.37,120.43 121.37,119.15 122.94,117.58 124.88,117.58 125.51,116.94 126.36,116.94 126.93,117.51 131.2,117.51 131.72,118.03 137.38,118.03 v4(138.21,117.2)
  IN3 w0.084: v4(138.21,117.2) 138.21,116.95 137.13,115.87 136.41,115.87 135.85,115.3 135.85,113.19 136.25,112.78 136.25,111.95 136.41,111.79 136.41,108.89 v4(136.66,108.64)
  GND4 w0.089: v9(26.36,100.95) 26.68,100.63 v4(26.68,100.47) ; v9(136.66,108.14) v4(136.66,108.64)
  BOTTOM w0.152: v9(26.36,100.95) 26.36,101.05 26.03,101.38 R55.2 ; RH71.1 137.52,106.28 136.66,107.15 v9(136.66,108.14)
GNSS_SCL_L: length 3.2
  BOTTOM w0.152: R55.1 24.87,102.09 23.11,103.86 23.11,104.35 JNGFF1.32
GNSS_SDA: length 170.1
  IN1 w0.089: v5(90.25,135.09) 90.05,135.29 86.9,135.29 86.63,135.56 84.51,135.56 83.45,136.62 81.82,136.62 81.5,136.3 80.56,136.3 80.13,135.87 78.94,135.87 74.74,131.66 74.03,131.66 73.41,131.04 70.78,131.04 69.56,129.82 68.37,129.82 68.05,129.5 63.9,129.5 62.3,127.9 62.3,126.26 61.37,125.33 61.37,124.94 59.12,122.7 57.44,122.7 57.23,122.91 53.19,122.91 52.99,122.71 50.49,122.71 46.92,119.14 46.92,115.3 46.02,114.4 45.29,114.4 44.71,113.82 44.71,111.87 43.33,110.49 41.36,110.49 39.06,108.19 38.49,108.19 38.32,108.02 38.32,107.06 39.26,106.12 39.26,105.82 39.94,105.15 39.94,102.55 38.35,100.96 35.77,100.96 35.05,101.68 34.14,101.68 33.46,102.37 32.57,102.37 31.63,101.43 30.71,101.43 29.97,102.18 28.5,102.18 v3(28.48,102.2)
  GND1 w0.089: v4(90.79,134.25) 90.79,134.55 v5(90.25,135.09)
  IN2 w0.06: v4(136.05,106.54) 135.86,106.72 133.92,106.72 v2(133.91,106.72)
  IN2 w0.084: v4(25.37,100.97) 24.95,101.39 24.95,102.01 25.2,102.27 28.42,102.27 v3(28.48,102.2)
  GND3 w0.084: v4(90.79,134.25) 90.89,134.15 90.89,132.88 91.48,132.28 94.1,132.28 95.33,131.05 97.51,131.05 101.17,127.39 101.17,126.86 103.02,125.01 111.87,125.01 112.85,124.02 115.64,124.02 117.2,122.46 119.89,122.46 121.73,120.62 121.73,119.27 123.08,117.91 125.02,117.91 125.65,117.28 126,117.28 126.64,117.91 129.75,117.91 130.2,118.36 137.55,118.36 v4(138.21,117.71)
  IN3 w0.084: v4(138.21,117.71) 137.79,117.29 137.79,117.01 136.99,116.21 136.27,116.21 135.48,115.41 135.48,111.9 136.04,111.34 136.04,109.7 135.21,108.87 135.21,107.76 135.72,107.25 135.72,106.69 135.84,106.57 136.01,106.57 v4(136.05,106.54) 136.59,106.54 v6(136.61,106.55)
  GND4 w0.089: v4(25.37,100.97) v9(24.57,100.97)
  BOTTOM w0.152: v6(136.61,106.55) 136.89,106.27 RH70.1 ; v9(24.57,100.97) 24.24,101.3 R57.2
GNSS_SDA_L: length 3.9
  BOTTOM w0.076: JNGFF1.34 22.55,103.96
  BOTTOM w0.152: R57.1 22.55,103.65 22.55,103.96
GNSS_SYSCLK: length 3.8
  BOTTOM w0.076: JNGFF1.38 21.55,103.94
  BOTTOM w0.119: T22.1 21.55,102.11 21.55,103.94
GPD11: length 14.8
  TOP w0.119: RH116.2 142.18,115.64 v1(141.94,115.88)
  IN1 w0.06: v1(131.9,109.92) 131.9,110.12 132.21,110.43 132.28,110.43 132.53,110.67 132.6,110.67 132.75,110.82 132.75,110.99 132.67,111.07 132.67,111.23 132.75,111.31 132.75,111.48 132.67,111.56 132.67,112.23 132.78,112.34 133.12,112.34 133.18,112.4 133.18,112.64 134.13,113.59 136.61,113.59 137.91,114.89 138.32,114.89 138.55,115.13 138.91,115.13 139.59,115.81 139.81,115.81
  IN1 w0.089: 139.81,115.81 141.87,115.81 v1(141.94,115.88)
GPIO170: length 70.1
  TOP w0.119: JDEG1.6 209.23,144.94 v1(209.29,144.88)
  IN1 w0.06: 235.24,120.94 235.03,121.14 235.03,121.39 234.81,121.62 v1(234.81,121.75)
  IN1 w0.089: v3(236.94,141.79) 236.94,142.07 236.33,142.68 235.2,142.68 234.3,143.58 231.86,143.58 229.79,145.65 229.79,146.57 227.35,149 224.29,149 223.94,148.65 214.4,148.65 213.16,147.42 211.6,147.42 209.29,145.11 v1(209.29,144.88) ; v3(237.24,119.73) 236.44,119.73 235.24,120.94
  IN2 w0.084: v3(236.94,141.79) 236.94,140.7 236.99,140.65 236.99,137.17 238.89,135.28 241.24,135.28 242.15,134.37 242.7,134.37 244.77,132.3 244.77,126.23 244.16,125.63 244.16,124.19 242.55,122.58 241.18,122.58 240.9,122.3 238.99,122.3 238.27,121.58 238.27,120.75 v3(237.24,119.73)
GPIO171: length 71.6
  TOP w0.119: v2(235.41,116.58) 235.41,115.82 R5671.2 ; v1(233.56,122.64) 233.81,122.39 U27.E10 ; v1(208.71,144.88) 208.73,144.9 JDEG1.7
  IN1 w0.06: v1(233.56,122.64) 233.56,120.98 233.6,120.94
  IN1 w0.089: 233.6,120.94 234.2,120.33 234.2,119.61 234.73,119.08 234.73,117.97 234.94,117.75 234.94,117.05 v2(235.41,116.58) ; v3(228.25,143.92) 228.25,144.4 227.53,145.12 227.53,145.83 226.32,147.04 225.13,147.04 224.57,146.48 215.65,146.48 214.42,145.25 212.81,145.25 211.97,144.41 209.18,144.41 v1(208.71,144.88)
  IN2 w0.084: v2(235.41,116.58) 235.41,118.34 238.08,121 238.08,121.65 239.44,123.01 239.44,124.05 239.84,124.45 240.75,124.45 241.81,125.5 241.81,128.24 242.4,128.82 242.4,131.24 242.14,131.5 240.95,131.5 239.2,133.25 238.38,133.25 235.2,136.43 235.2,136.95 234.53,137.62 234.53,140.12 232.59,142.06 230.69,142.06 228.83,143.92 v3(228.25,143.92)
GPP_B5: length 6.4
  TOP w0.119: TC62.1 137.59,111.35 v2(137.24,111.69)
  IN2 w0.06: v2(137.24,111.69) 136.53,110.98 136.23,110.98 135.61,110.36 134.97,110.36 134.51,109.91 133.67,109.91 133.46,109.7 133.25,109.7 v2(133.17,109.62)
GPP_B18: length 11.3
  TOP w0.119: TC70.1 142.09,110.33 142.22,110.21 RC84.2 142.22,109.89 142.35,109.76 v1(143.36,109.76)
  IN1 w0.06: 141.84,109.76 141.71,109.76 141.53,109.58 139.72,109.58 139.17,109.04 135.24,109.04 v1(134.65,109.62)
  IN1 w0.089: 141.84,109.76 141.95,109.87 142.38,109.87 142.51,110 143.12,110 v1(143.36,109.76)
GPP_B22: length 9.3
  TOP w0.119: RC85.2 TC95.1 140.32,112.06 140.1,111.84 139.36,111.84 v2(139.08,111.56)
  IN2 w0.06: v2(133.67,108.98) 133.67,109.06 133.84,109.23 134.74,109.23 135.24,109.73 135.95,109.73 136.31,110.1 137.87,110.1 138.45,110.68 138.53,110.68 138.93,111.07 138.93,111.41 v2(139.08,111.56)
GPP_D16: length 4.9
  IN2 w0.06: v2(133.42,102.21) 133.57,102.07 134.27,102.07 134.32,102.01 134.67,102.01 134.74,101.94 134.78,101.9 135.02,101.9 135.36,101.56 136.01,101.56 136.3,101.26 136.79,101.26 v4(136.82,101.24)
  GND4 w0.119: v9(137.27,101.13) 136.93,101.13 v4(136.82,101.24)
  BOTTOM w0.119: v9(137.27,101.13) 137.52,100.87 RC86.2
