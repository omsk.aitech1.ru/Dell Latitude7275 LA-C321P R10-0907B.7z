# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_SNK1_ML0_N: length 177.8
  IN1 w0.06: v1(123.21,97.57) 123.21,96.85 120.33,93.97 118.67,93.97 118.54,94.1 116.89,94.1 116.7,93.9 116.7,93.83 116.66,93.8
  IN1 w0.089: 116.66,93.8 115.99,93.13 113.27,93.13 112.82,92.68 110.67,92.68 110.37,92.98 107.59,92.98 107.51,92.9 107.51,92.73 v3(107.61,92.63)
  IN2 w0.084: v2(32.62,38.15) 32.89,38.15 32.95,38.08 32.95,37.79 33,37.74 33.16,37.74 34.18,38.75 34.18,42 33.09,43.08 33.09,50.22 31.07,52.25 31.07,60.78 28.59,63.26 28.59,65.62 21.13,73.08 21.13,79.49 23.26,81.62 23.26,95.46 24.53,96.73 29.13,96.73 30.12,97.72 32.39,97.72 32.9,98.23 35.19,98.23 35.95,97.47 43.57,97.47 44.86,98.76 48.94,98.76 49.31,98.39 60.81,98.39 65.68,93.52 74.98,93.52 76.23,92.26 88.79,92.26 89.24,91.81 91.76,91.81 91.94,91.64 91.94,91.4 92.02,91.32 92.28,91.32 92.36,91.4 92.36,91.64 92.54,91.81 93.47,91.81 93.65,91.64 93.65,91.16 93.73,91.08 93.99,91.08 94.07,91.16 94.07,91.64 94.25,91.81 94.63,91.81 94.81,91.64 94.81,91.16 94.9,91.08 95.15,91.08 95.23,91.16 95.23,91.64 95.41,91.81 95.98,91.81 96.74,91.06 101.22,91.06 101.58,91.42 105.21,91.42 106.86,93.07 107.36,93.07 107.5,92.93 107.5,92.74 v3(107.61,92.63)
TBT_SNK1_ML0_P: length 177.8
  IN1 w0.06: 116.5,93.95 116.52,93.96 116.58,93.96 116.84,94.22 118.59,94.22 118.72,94.09 120.28,94.09 123.09,96.9 123.09,97.41 123.01,97.49 123.01,97.65 123.21,97.85 v1(123.21,98.09)
  IN1 w0.089: v3(107.25,92.63) 107.29,92.67 107.29,92.99 107.5,93.2 110.46,93.2 110.76,92.9 112.73,92.9 113.18,93.35 115.9,93.35 116.5,93.95
  IN2 w0.084: v3(107.25,92.63) 107.34,92.72 107.34,92.86 107.29,92.91 106.93,92.91 105.27,91.26 101.65,91.26 101.29,90.9 96.67,90.9 95.92,91.65 95.48,91.65 95.4,91.57 95.4,91.09 95.22,90.91 94.83,90.91 94.65,91.09 94.65,91.57 94.57,91.65 94.32,91.65 94.23,91.57 94.23,91.09 94.05,90.91 93.67,90.91 93.49,91.09 93.49,91.57 93.4,91.65 92.61,91.65 92.52,91.57 92.52,91.33 92.35,91.16 91.95,91.16 91.78,91.33 91.78,91.57 91.69,91.65 89.17,91.65 88.72,92.1 76.16,92.1 74.91,93.35 65.61,93.35 60.74,98.23 49.24,98.23 48.87,98.6 44.93,98.6 43.63,97.31 35.88,97.31 35.12,98.06 32.96,98.06 32.46,97.56 30.19,97.56 29.2,96.57 24.6,96.57 23.43,95.4 23.43,81.55 21.29,79.42 21.29,73.14 28.75,65.68 28.75,63.33 31.23,60.85 31.23,52.31 33.25,50.29 33.25,43.15 34.34,42.06 34.34,38.68 33.23,37.57 v2(32.62,37.57)
TBT_SNK1_ML1_N: length 177.8
  IN1 w0.06: v1(122.56,97.57) 122.56,97.06 120.33,94.83 119.61,94.83 119.49,94.7 116.04,94.7 115.94,94.6 115.94,94.53 115.93,94.52
  IN1 w0.089: v3(104.96,92.69) 104.86,92.8 104.86,93.34 104.72,93.48 104.72,94.46 104.93,94.67 110.27,94.67 110.46,94.86 111.14,94.86 111.68,94.33 115.74,94.33 115.93,94.52
  IN2 w0.084: v3(104.96,92.69) 104.87,92.6 104.87,92.37 104.39,91.89 100.76,91.89 100.35,91.47 98.45,91.47 97.63,92.3 96.26,92.3 96.23,92.33 95.2,92.33 94.38,93.15 94.12,93.15 94.04,93.07 94.04,92.46 93.86,92.28 93.3,92.28 93.12,92.46 93.12,93.07 93.04,93.15 92.61,93.15 92.53,93.07 92.53,92.46 92.35,92.28 91.79,92.28 91.61,92.46 91.61,93.07 91.53,93.15 90.01,93.15 89.93,93.07 89.93,92.85 89.71,92.63 89.23,92.63 89.01,92.85 89.01,93.07 88.93,93.15 76.47,93.15 75.85,93.77 75.3,93.77 74.95,94.13 65.75,94.13 61.07,98.81 49.57,98.81 49.23,99.16 43.61,99.16 42.32,97.87 36.1,97.87 34.88,99.09 33.04,99.09 32.07,98.12 28.76,98.12 28.68,98.04 26.33,98.04 25.61,97.32 24.52,97.32 22.83,95.62 22.83,81.74 20.72,79.63 20.72,72.93 28.2,65.45 28.2,63.08 30.68,60.6 30.68,52.06 32.7,50.04 32.7,42.92 33.79,41.84 33.79,39.54 33.37,39.13 33.03,39.13 32.95,39.05 32.95,38.78 32.89,38.72 v2(32.61,38.72)
TBT_SNK1_ML1_P: length 177.9
  IN1 w0.06: v1(122.56,98.09) 122.48,98.01 122.48,97.77 122.36,97.65 122.36,97.49 122.44,97.41 122.44,97.11 120.28,94.95 119.57,94.95 119.44,94.82 115.99,94.82 115.95,94.78 115.86,94.68 115.79,94.68 115.78,94.67
  IN1 w0.089: v3(104.6,92.69) 104.64,92.73 104.64,93.25 104.5,93.39 104.5,94.55 104.84,94.89 110.18,94.89 110.37,95.08 111.23,95.08 111.77,94.55 115.65,94.55 115.78,94.67
  IN2 w0.084: v3(104.6,92.69) 104.71,92.59 104.71,92.44 104.32,92.05 100.7,92.05 100.28,91.64 98.52,91.64 97.7,92.46 96.33,92.46 96.3,92.49 95.27,92.49 94.45,93.31 94.06,93.31 93.88,93.13 93.88,92.53 93.79,92.44 93.37,92.44 93.28,92.53 93.28,93.13 93.11,93.31 92.55,93.31 92.37,93.13 92.37,92.53 92.28,92.44 91.86,92.44 91.78,92.53 91.78,93.13 91.6,93.31 89.94,93.31 89.77,93.13 89.77,92.92 89.64,92.79 89.3,92.79 89.17,92.92 89.17,93.13 88.99,93.31 76.54,93.31 75.91,93.94 75.37,93.94 75.02,94.29 65.82,94.29 61.13,98.98 49.64,98.98 49.3,99.32 43.54,99.32 42.26,98.04 36.17,98.04 34.95,99.26 32.97,99.26 32,98.28 28.69,98.28 28.62,98.2 26.27,98.2 25.54,97.48 24.45,97.48 22.67,95.69 22.67,81.8 20.56,79.7 20.56,72.87 28.04,65.39 28.04,63.01 30.52,60.53 30.52,52 32.54,49.97 32.54,42.85 33.63,41.77 33.63,39.61 33.31,39.29 v2(32.62,39.29)
TBT_SNK1_ML2_N: length 177.7
  IN1 w0.06: v1(123.53,97.84) 123.53,97.66 123.53,97.66 123.53,96.77 120.75,94 120.75,93.58 120.8,93.53 120.8,93.51
  IN1 w0.089: 120.8,93.51 120.8,93.3 119.68,92.18 119.08,92.18 118.42,91.52 116.26,91.52 116.11,91.37 113.2,91.37 113,91.56 108.17,91.56 108.1,91.49 106.41,91.49 105.59,92.31 105.59,92.59 v3(105.49,92.69)
  IN2 w0.084: v2(32.62,39.86) 32.89,40.13 33.05,40.13 33.22,40.29 33.22,41.63 32.15,42.69 32.15,49.72 30.13,51.75 30.13,60.34 27.65,62.82 27.65,65.23 20.16,72.72 20.16,85.13 22.26,87.23 22.26,95.85 24.3,97.9 25.39,97.9 26.09,98.6 28.43,98.6 28.89,99.06 32.15,99.06 32.79,99.69 35.07,99.69 36.01,98.75 40.8,98.75 41,98.96 41.73,98.96 42.49,99.71 49.68,99.71 50,99.39 61.51,99.39 65.68,95.22 65.98,95.22 66.07,95.14 66.07,94.92 66.25,94.74 66.6,94.74 66.78,94.92 66.78,95.26 66.91,95.39 67.14,95.39 67.27,95.26 67.27,95.1 67.49,94.88 67.81,94.88 68.03,95.1 68.03,95.33 68.15,95.46 69.4,95.46 69.53,95.33 69.53,95.23 69.72,95.03 70,95.03 70.2,95.23 70.2,95.37 70.32,95.49 70.48,95.49 70.6,95.37 70.6,94.98 70.81,94.77 71.11,94.77 71.32,94.98 71.32,95.1 71.44,95.22 74.7,95.22 75.58,94.35 76.1,94.35 76.65,93.8 95.78,93.8 96.73,92.85 97.58,92.85 97.81,93.07 97.81,93.21 97.93,93.34 98.28,93.34 98.41,93.21 98.41,93.07 98.63,92.85 99.16,92.85 99.49,92.52 103.75,92.52 104.22,93 105.48,93 105.59,92.88 105.59,92.79 v3(105.49,92.69)
TBT_SNK1_ML2_P: length 177.8
  IN1 w0.06: 120.59,93.51 120.59,93.53 120.63,93.58 120.63,94.05 123.41,96.82 123.41,97.65 123.33,97.73 123.33,97.93 123.53,98.13 v1(123.53,98.34)
  IN1 w0.089: 120.59,93.51 120.59,93.39 119.6,92.39 118.99,92.39 118.33,91.73 116.17,91.73 116.02,91.58 113.28,91.58 113.09,91.78 108.08,91.78 108.01,91.71 106.5,91.71 105.81,92.4 105.81,92.65 v3(105.85,92.69)
  IN2 w0.084: v2(32.62,40.43) 32.76,40.29 32.99,40.29 33.05,40.36 33.05,41.56 31.99,42.62 31.99,49.66 29.96,51.68 29.96,60.28 27.49,62.76 27.49,65.16 20,72.65 20,85.2 22.09,87.3 22.09,95.92 24.24,98.06 25.33,98.06 26.03,98.76 28.36,98.76 28.82,99.22 32.09,99.22 32.72,99.86 35.13,99.86 36.08,98.91 40.73,98.91 40.94,99.12 41.66,99.12 42.42,99.88 49.74,99.88 50.07,99.55 61.58,99.55 65.74,95.39 66.05,95.39 66.23,95.21 66.23,94.99 66.31,94.91 66.54,94.91 66.62,94.99 66.62,95.33 66.84,95.55 67.21,95.55 67.43,95.33 67.43,95.17 67.56,95.04 67.74,95.04 67.86,95.17 67.86,95.4 68.09,95.62 69.47,95.62 69.69,95.4 69.69,95.3 69.79,95.19 69.94,95.19 70.04,95.3 70.04,95.44 70.25,95.65 70.55,95.65 70.76,95.44 70.76,95.04 70.87,94.93 71.04,94.93 71.15,95.04 71.15,95.16 71.38,95.39 74.77,95.39 75.65,94.51 76.17,94.51 76.72,93.96 95.85,93.96 96.8,93.01 97.52,93.01 97.64,93.14 97.64,93.28 97.87,93.5 98.35,93.5 98.57,93.28 98.57,93.14 98.7,93.01 99.23,93.01 99.56,92.68 103.68,92.68 104.16,93.16 105.55,93.16 105.76,92.95 105.76,92.78 v3(105.85,92.69)
TBT_SNK1_ML3_N: length 177.2
  IN1 w0.06: 116.32,94.13 116.33,94.14 116.33,94.21 116.54,94.42 118.68,94.42 118.88,94.22 120.15,94.22 122.89,96.96 122.89,97.84 v1(122.89,97.84)
  IN1 w0.089: 116.32,94.13 115.93,93.74 111.12,93.74 110.86,94 109.4,94 109.24,93.84 106.59,93.84 106.51,93.76 106.51,93.63 v3(106.59,93.55)
  IN2 w0.084: v2(32.62,41) 32.47,41.16 32.21,41.16 31.44,41.93 31.44,49.41 29.41,51.43 29.41,60 26.94,62.48 26.94,64.93 19.4,72.47 19.4,85.4 21.49,87.5 21.49,96.13 23.98,98.62 25.02,98.62 25.72,99.32 28.09,99.32 28.57,99.79 31.75,99.79 32.43,100.47 35.34,100.47 36.34,99.46 40.48,99.46 40.72,99.7 41.42,99.7 42.14,100.43 50.06,100.43 50.37,100.11 61.93,100.11 65.86,96.18 66.1,96.18 66.18,96.26 66.18,96.71 66.42,96.94 66.76,96.94 67,96.71 67,96.26 67.08,96.18 67.4,96.18 67.49,96.26 67.49,96.69 67.72,96.93 68.06,96.93 68.3,96.69 68.3,96.26 68.39,96.18 68.71,96.18 68.79,96.26 68.79,96.6 69.03,96.84 69.37,96.84 69.61,96.6 69.61,96.26 69.69,96.18 70.01,96.18 70.1,96.26 70.1,96.66 70.34,96.89 70.67,96.89 70.91,96.66 70.91,96.26 71,96.18 71.32,96.18 71.4,96.26 71.4,96.66 71.64,96.89 71.98,96.89 72.22,96.66 72.22,96.26 72.3,96.18 74.8,96.18 75.88,95.11 76.59,95.11 77.09,94.61 99.34,94.61 100.38,93.57 103.27,93.57 103.71,94.01 106.3,94.01 106.49,93.82 106.49,93.72 106.49,93.65 v3(106.59,93.55)
TBT_SNK1_ML3_P: length 177.2
  IN1 w0.06: v1(122.89,98.34) 122.89,98.13 122.69,97.93 122.69,97.73 122.77,97.65 122.77,97.01 120.1,94.34 118.93,94.34 118.72,94.54 116.49,94.54 116.24,94.29 116.17,94.29 116.17,94.29
  IN1 w0.089: 116.17,94.29 115.84,93.96 111.21,93.96 110.95,94.22 109.31,94.22 109.15,94.06 106.5,94.06 106.29,93.85 106.29,93.62 v3(106.23,93.55)
  IN2 w0.084: v3(106.23,93.55) 106.32,93.65 106.32,93.75 106.23,93.85 103.78,93.85 103.33,93.4 100.31,93.4 99.27,94.45 77.02,94.45 76.52,94.94 75.81,94.94 74.73,96.02 72.23,96.02 72.06,96.2 72.06,96.59 71.91,96.73 71.71,96.73 71.57,96.59 71.57,96.2 71.39,96.02 70.93,96.02 70.75,96.2 70.75,96.59 70.61,96.73 70.4,96.73 70.26,96.59 70.26,96.2 70.08,96.02 69.62,96.02 69.44,96.2 69.44,96.54 69.3,96.68 69.1,96.68 68.95,96.54 68.95,96.2 68.78,96.02 68.32,96.02 68.14,96.2 68.14,96.63 68,96.77 67.79,96.77 67.65,96.63 67.65,96.2 67.47,96.02 67.01,96.02 66.83,96.2 66.83,96.64 66.69,96.78 66.49,96.78 66.34,96.64 66.34,96.2 66.16,96.02 65.79,96.02 61.87,99.95 50.31,99.95 49.99,100.26 42.21,100.26 41.49,99.54 40.79,99.54 40.55,99.3 36.27,99.3 35.27,100.3 32.5,100.3 31.82,99.63 28.63,99.63 28.16,99.16 25.79,99.16 25.09,98.46 24.05,98.46 21.66,96.07 21.66,87.43 19.56,85.34 19.56,72.53 27.1,65 27.1,62.55 29.58,60.07 29.58,51.5 31.6,49.48 31.6,42 32.28,41.32 32.5,41.32 32.62,41.44 v2(32.62,41.58)
TBT_SRC_CFG1: length 3
  TOP w0.102: R1403.1 31.4,28.67 30.66,29.42 30,29.42 29.39,30.02 UT1.AA1
TBT_SRC_HPD: length 1.8
  TOP w0.119: R1405.1 23.06,28.95 22.95,29.05
  TOP w0.127: 22.95,29.05 UT1.G1
TBT_TCK: length 30
  TOP w0.119: R1381.1 32.87,42.7 32.59,42.98 v1(32.59,43.27) 32.59,43.42 32.68,43.5 33.5,43.5 34.77,44.77 34.77,45.92 36.41,47.56 36.41,49.03 v10(35.87,49.57) JAR1.3
  IN1 w0.089: v1(32.59,43.27) 32.59,42.85 31.11,41.37 31.11,40.42 30.45,39.75 30.45,36.69 30.33,36.57 30.33,32.62 29.5,31.78 29.5,31.36 29.31,31.18 29.03,31.18 28.86,31.35 28.86,31.61 28.71,31.76 28.44,31.76 28.23,31.54 28.23,31.39 28.01,31.17 27.47,31.17 v1(27.2,31.44)
  GND1 w0.119: v10(35.87,49.57) 35.87,49.02 v4(35.86,49.01)
  GND4 w0.119: v4(35.86,49.01) 36.02,49.17 v15(36.02,50.47)
TBT_TDI: length 19.8
  TOP w0.119: R1379.1 31.61,43.03 v1(31.95,43.38) 31.95,43.64 32.27,43.95 33.18,43.95 34.22,44.99 34.22,46.24 34.02,46.43 JAR1.1
  IN1 w0.089: v1(31.95,43.38) 31.95,42.64 30.92,41.61 30.92,40.51 30.26,39.85 30.26,36.77 30.14,36.65 30.14,32.76 29.15,31.77 v10(29.15,31.44)
  GND1 w0.119: v4(28.99,31.09) 29.15,31.25 v10(29.15,31.44)
  GND4 w0.119: v15(28.54,31.03) 28.59,31.09 v4(28.99,31.09)
TBT_TDO: length 29.8
  TOP w0.119: JAR1.4 35.98,50.82 36.63,50.17 36.63,47.25 v10(35.95,46.57) 35.04,45.66 35.04,44.66 33.91,43.52 R1382.1 33.38,43.06 33.24,43.2 v1(32.97,43.2)
  IN1 w0.089: v1(32.97,43.2) 32.97,42.96 31.3,41.29 31.3,40.34 30.64,39.68 30.64,36.61 30.52,36.49 30.52,31.85 30.15,31.47 30.15,30.67 29.96,30.48 29.35,30.48 28.5,31.32 v10(28.5,31.44)
  GND1 w0.119: v10(35.95,46.57) 35.95,46.17 v4(35.85,46.07)
  GND4 w0.119: v15(35.4,44.97) 35.4,45.62 v4(35.85,46.07)
TBT_TEST_EN: length 3.7
  TOP w0.119: RT11.2 21.16,27.02 21.16,28.95 22.03,29.82 UT1.E1
TBT_TEST_PWG: length 3.2
  TOP w0.076: 30.67,31.89 30.08,31.89 UT1.AB5
  TOP w0.119: RT12.2 32.03,30.54 31.88,30.68 31.88,31.05 31.22,31.71 30.85,31.71 30.67,31.89
TBT_TMS: length 25.7
  TOP w0.119: JAR1.2 35.55,48.32 v10(35.82,48.06) 35.82,47.35 34.5,46.03 34.5,44.89 33.34,43.73 32.46,43.73 v1(32.33,43.6) 32.26,43.53 32.26,43.03 R1380.1
  IN1 w0.089: v1(27.85,31.44) 28.45,32.04 29.08,32.04 29.95,32.91 29.95,36.73 30.07,36.84 30.07,39.93 30.73,40.6 30.73,41.69 31.68,42.63 31.68,43.47 31.85,43.64 32.29,43.64 v1(32.33,43.6)
  GND1 w0.119: v10(35.82,48.06) 35.82,47.58 v4(35.86,47.54)
  GND4 w0.119: v15(34.65,47.9) 35.02,47.54 v4(35.86,47.54)
TBT_TMU_CLK_OUT: length 4.3
  TOP w0.076: 27.79,29.73 27.78,29.74 27.78,30.51 UT1.V2
  TOP w0.119: 27.79,29.73 27.79,29.33 28.15,28.98 28.15,27.49 28.04,27.38 R1408.1 C1397.1
TBT_XTAL_25_IN: length 4.3
  TOP w0.076: UT1.D22 21.34,40.17 21.34,40.68
  TOP w0.119: Y4.1 19.84,42.78 C1260.1 20.74,41.88 20.74,41.29 21.34,40.68
TBT_XTAL_25_OUT: length 5.6
  TOP w0.119: Y4.3 20.72,43.85 20.72,42.76 C1259.1 21.03,41.48 21.57,40.94 UT1.D23
TBTA_AUX_N: length 3.3
  TOP w0.089: UT1.W15 v7(28.18,36.31)
  BOTTOM w0.112: C1282.2 29.8,37.02 29.66,36.88 29.66,36.57 29.01,35.92 28.57,35.92 v7(28.18,36.31)
TBTA_AUX_P: length 3.3
  TOP w0.089: UT1.Y15 29.32,36.48 29.32,36.37 29.22,36.27 28.88,36.27 v7(28.83,36.31)
  BOTTOM w0.112: C1280.2 30.13,37.73 30.03,37.73 29.9,37.6 29.9,37.36 29.82,37.28 29.69,37.28 29.4,36.98 29.4,36.68 29.04,36.31 v7(28.83,36.31)
TBTA_CA2HD_0_N: length 18.8
  TOP w0.076: UT1.A21 20.19,39.37 arc(20.19,39.34) 20.17,39.31 20.16,39.3 arc(20.14,39.28) 20.11,39.28 19.99,39.28 arc(19.97,39.29) 19.95,39.31 19.88,39.38 19.73,39.53 19.56,39.7 arc(19.54,39.72) 19.53,39.72 arc(19.49,39.74) 19.45,39.75 19.4,39.75 arc(19.36,39.75) 19.32,39.75 19.32,39.75 arc(19.13,39.7) v7(19.05,39.53)
  BOTTOM w0.14: v7(19.05,39.53) 18.82,39.76 arc(18.67,39.86) 18.48,39.9 17.92,39.9 arc(17.83,39.88) 17.76,39.83 arc(17.37,39.58) 16.92,39.49 13.76,39.49 arc(13.71,39.48) 13.67,39.45 11.23,37.01 arc(11.2,36.97) 11.2,36.93 11.2,36.02 arc(11.26,35.85) 11.43,35.78 D81.1 11.29,35.5 arc(11.22,35.41) 11.2,35.29 11.2,35.09 arc(11.19,35.05) 11.16,35.01 11.1,34.94 10.91,34.75 arc(10.8,34.68) 10.67,34.65 10.46,34.65 arc(10.31,34.62) 10.18,34.54 8.22,32.58 arc(8.11,32.5) 7.98,32.48 7.45,32.48 arc(7.01,32.38) JUSBC1.B10
TBTA_CA2HD_0_P: length 18.8
  TOP w0.076: UT1.B21 20.51,39.62 arc(20.43,39.68) 20.33,39.71 19.84,39.71 arc(19.8,39.71) 19.75,39.73 19.63,39.86 arc(19.59,39.89) 19.54,39.9 19.4,39.9 arc(19.28,39.92) 19.17,39.99 v7(19.05,40.11)
  BOTTOM w0.14: v7(19.05,40.11) 19.05,40.11 17.92,40.11 arc(17.75,40.08) 17.61,39.99 arc(17.29,39.78) 16.92,39.7 13.76,39.7 arc(13.62,39.68) 13.51,39.6 11.08,37.17 arc(11.01,37.06) 10.98,36.93 10.98,36.04 arc(10.96,35.93) 10.9,35.84 arc(10.83,35.8) 10.76,35.78 D79.1 10.86,35.54 arc(10.95,35.4) 10.98,35.24 10.98,35.18 arc(10.97,35.14) 10.95,35.09 10.76,34.91 arc(10.72,34.88) 10.67,34.87 10.46,34.87 arc(10.22,34.82) 10.03,34.69 8.07,32.73 arc(8.02,32.7) 7.98,32.69 7.14,32.69 arc(6.87,32.75) JUSBC1.B11
TBTA_CA2HD_1_N: length 17.9
  TOP w0.076: UT1.B15 20.5,36.87 arc(20.43,36.93) 20.34,36.95 20.05,36.95 arc(20,36.94) 19.96,36.9 19.52,36.46 arc(19.48,36.43) 19.43,36.42 17.89,36.42
  TOP w0.081: 17.89,36.42 17.86,36.45 17.84,36.45
  TOP w0.14: v7(16.74,36.67) 16.79,36.62 arc(16.97,36.5) 17.19,36.45 17.84,36.45 ; JUSBC1.A10 9.32,28.76 arc(9.36,28.75) 9.39,28.73 arc(9.42,28.7) 9.46,28.7 9.65,28.7 arc(9.8,28.73) v7(9.93,28.81)
  BOTTOM w0.14: v7(16.74,36.67) 16.64,36.58 arc(16.51,36.49) 16.35,36.46 16.23,36.46 arc(16.09,36.43) 15.98,36.36 13.73,34.11 arc(13.66,34) 13.63,33.86 13.63,31.56 arc(13.51,30.93) 13.16,30.41 12.13,29.38 arc(12.02,29.33) 11.91,29.38 D82.2 11.73,29.23 arc(11.71,29.1) 11.66,28.98 arc(11.63,28.94) 11.6,28.91 11.36,28.67 arc(11.32,28.65) 11.27,28.64 10.47,28.64 arc(10.19,28.68) v7(9.93,28.81)
TBTA_CA2HD_1_P: length 17.9
  TOP w0.076: 17.89,36.27 19.49,36.27 arc(19.54,36.28) 19.58,36.3 19.73,36.45 arc(19.77,36.48) 19.82,36.49 20.29,36.49 arc(20.37,36.52) 20.4,36.6 20.4,36.62 arc(20.38,36.68) 20.31,36.72 arc(20.3,36.72) 20.3,36.72 UT1.A15
  TOP w0.081: 17.84,36.24 17.86,36.24 17.89,36.27
  TOP w0.14: JUSBC1.A11 9.19,28.26 arc(9.24,28.27) 9.28,28.29 9.43,28.44 arc(9.47,28.47) 9.52,28.48 9.64,28.48 arc(9.69,28.47) 9.73,28.44 9.93,28.25 v7(9.93,28.23) ; 17.84,36.24 17.1,36.24 arc(16.9,36.2) v7(16.74,36.09)
  BOTTOM w0.14: v7(9.93,28.23) 10.08,28.38 arc(10.13,28.41) 10.17,28.42 11.27,28.42 arc(11.4,28.45) 11.51,28.52 11.68,28.68 arc(11.79,28.76) 11.93,28.79 D80.2 12.28,28.88 arc(12.21,29.05) 12.28,29.22 13.31,30.25 arc(13.71,30.85) 13.85,31.56 13.85,33.86 arc(13.86,33.91) 13.89,33.95 16.14,36.2 arc(16.18,36.23) 16.23,36.24 16.53,36.24 arc(16.58,36.23) 16.62,36.2 v7(16.74,36.09)
TBTA_CC1: length 34.9
  TOP w0.254: U717.L9 13.42,49.57 13.53,49.46 13.53,48.85 13.01,48.33 C289.1 ; JUSBC1.A5 9.54,31.26 10.64,30.16 v1(10.64,29.93)
  TOP w0.381: U717.K9 U717.L9
  IN1 w0.254: v1(13.1,48.27) 13.28,48.27 13.8,47.75 14.24,47.75 14.81,48.32 16.03,48.32 16.72,47.63 16.72,45.44 17.81,44.34 17.81,41.09 16.83,40.11 16.83,39.73 16.05,38.95 16.05,34.43 15.6,33.99 15.6,32.43 15.76,32.27 15.76,29.9 14.43,28.57 v1(13.46,28.57) 11.61,28.57 10.95,29.23 10.95,29.61 v1(10.64,29.93)
TBTA_CC2: length 39.9
  TOP w0.254: U717.K10 v1(13.92,49.73) 14.03,49.62 14.03,49.16 14.75,48.44 C288.1
  IN1 w0.254: v1(13.92,49.73) 13.92,49.42 14.53,48.81 16.41,48.81 17.28,47.94 17.28,45.87 18.18,44.97 18.18,40.95 17.19,39.96 17.19,39.44 16.83,39.09 v3(16.83,38.01) ; v3(7.77,29.64) 7.99,29.41 7.99,29 7.94,28.95 7.94,27.96 8.16,27.74 8.52,27.74 9.07,27.19 11.12,27.19 11.58,27.64 12.5,27.64 12.73,27.87 v1(13.49,27.87) 13.82,28.2 14.7,28.2 16.25,29.76 16.25,32.48 16.06,32.67 16.06,33.76 v3(16.21,33.91)
  GND1 w0.127: JUSBC1.B5 6.72,29.63 7.76,29.63 v3(7.77,29.64)
  IN2 w0.127: JUSBC1.B5 6.73,29.63 7.76,29.63 v3(7.77,29.64)
  IN2 w0.254: v3(16.83,38.01) 16.83,37.58 16.21,36.96 v3(16.21,33.91)
TBTA_DBG_CTL1: length 6.6
  TOP w0.119: v1(10.92,53.61) 10.92,52.73 U717.E4
  IN1 w0.089: v1(8.69,57.76) 8.46,57.53 8.46,56.98 8.82,56.62 9.06,56.62 9.65,56.03 10.27,56.03 10.67,55.63 10.67,53.86 v1(10.92,53.61)
TBTA_DBG_CTL2: length 5.7
  TOP w0.119: U717.D5 v1(11.42,53.65)
  IN1 w0.089: v1(11.42,53.65) 11.18,53.9 11.18,55.59 10.66,56.1 v1(10.66,58.66)
TBTA_DC_SS: length 25.5
  TOP w0.381: PR140.1 41.28,135.39 v2(41.59,135.69)
  IN1 w0.508: v1(42.6,113.27) 42.6,115.13 42.03,115.71 42.03,129.69 42.64,130.3 42.64,131.16 43.55,132.08 43.55,134.08 42.37,135.26
  BOTTOM w0.102: v7(44.48,110.97) v14(44.48,110.32)
TBTA_DCIN: length 28.9
  TOP w0.381: v7(44.47,122.68) 44.74,122.41 PQ111.4
  TOP w0.508: v7(43.38,107.11) 44.22,107.11 44.63,107.53 PR104.1 45.4,107.53 46.09,108.22 PC121.1
  GND1 w0.508: v10(49.16,128.99) 49.14,128.99 v4(48.75,128.6)
  GND4 w0.508: v9(48.38,128.18) 48.38,128.23 v4(48.75,128.6)
  BOTTOM w0.508: v7(43.38,107.11) 43.38,110.78 44.47,111.87 v7(44.47,122.68) 44.47,124.67 v14(45.4,125.61) 47.97,128.18 v9(48.38,128.18)
  vias: v7(41.4,108.26) v7(41.4,107.69) v7(41.38,107.13) v7(42.23,107.1) v7(42.79,107.09)
TBTA_DEBUG1: length 1.7
  TOP w0.119: R1443.2 9.1,48.5 9.92,49.32 U717.L2
TBTA_DEBUG2: length 2.9
  IN1 w0.089: v1(9.92,50.23) 10.04,50.11 10.04,49.23 9.36,48.55 8.76,48.55 v1(8.53,48.32)
TBTA_DEG3_LSTX: length 8.1
  TOP w0.119: U717.L3 v1(10.42,49.08) ; v1(7.77,46.19) 8.29,46.19 8.71,46.6 9.76,46.6 R5722.2
  IN1 w0.089: v1(10.42,49.08) 10.19,49.08 9.2,48.09 8.77,48.09 8.46,47.79 8.46,46.61 8.04,46.19 v1(7.77,46.19)
TBTA_DEG4_LSRX: length 8.8
  TOP w0.076: 10.17,49.54 10.17,49.98 U717.K3
  TOP w0.119: 10.17,49.54 10.17,49.23 9.68,48.75 R5723.2 ; U717.K3 10.42,50.68 v1(10.29,50.81)
  IN1 w0.089: v1(10.29,50.81) 9.91,50.81 9.12,51.6 9.12,52.33 8.71,52.74 8.44,52.74 7.83,52.13 6.64,52.13 v1(6.06,52.7)
TBTA_DPSRC_AUX_N: length 37.7
  TOP w0.076: U717.J2 9.68,50.97 9.32,50.97 9.16,50.82
  TOP w0.089: v7(8.73,49.89) 8.73,50.35 9.16,50.78 9.16,50.82
  TOP w0.112: R1480.2 7.79,49.27 7.92,49.27 8.22,49.57 8.42,49.57 v7(8.73,49.89)
  BOTTOM w0.112: C1282.1 31.64,37.02 32.68,38.06 32.68,40.93 29.76,43.85 28.58,43.85 26.66,45.77 25.69,45.77 23.96,47.49 23.96,48.64 22.68,49.92 17.01,49.92 16.05,48.95 14.38,48.95 13.57,49.77 8.85,49.77 v7(8.73,49.89)
TBTA_DPSRC_AUX_P: length 37.8
  TOP w0.089: U717.J1 9.42,50.56 9.37,50.5 9.23,50.5 9.01,50.29 9.01,50.17 9.14,50.05 9.14,49.09 9.03,48.98 8.85,48.98 8.73,49.1 v7(8.73,49.32)
  TOP w0.112: v7(8.73,49.32) 8.33,49.32 7.63,48.61 R1481.2
  BOTTOM w0.112: C1280.1 31.17,37.59 31.22,37.54 31.22,37.37 31.32,37.28 31.53,37.28 32.42,38.17 32.42,40.82 29.65,43.59 28.47,43.59 26.56,45.51 25.58,45.51 23.71,47.38 23.71,48.53 22.58,49.66 17.12,49.66 16.15,48.69 14.28,48.69 13.46,49.51 8.89,49.51 8.73,49.35 v7(8.73,49.32)
TBTA_HD2CA_0_N: length 12.7
  TOP w0.14: JUSBC1.A3 9.23,32.26 arc(9.28,32.27) 9.32,32.29 9.43,32.4 arc(9.47,32.43) 9.52,32.44 9.98,32.44 arc(10.17,32.4) 10.33,32.29 v7(10.37,32.25)
  BOTTOM w0.14: v7(10.37,32.25) 10.56,32.44 arc(10.6,32.47) 10.65,32.48 10.75,32.48 arc(10.88,32.51) 10.99,32.58 12.02,33.61 arc(12.1,33.72) 12.12,33.86 12.12,34.45 arc(12.19,34.8) 12.39,35.1 12.42,35.13 12.94,35.65 arc(13.01,35.76) 13.04,35.89 13.04,36.25 arc(13.07,36.42) 13.17,36.56 D77.1 13.2,36.8 arc(13.15,36.81) 13.11,36.84 13.07,36.88 arc(13.05,36.92) 13.04,36.97 13.04,37.54 arc(13.05,37.58) 13.07,37.62 13.58,38.13 13.67,38.22 arc(13.71,38.25) 13.76,38.26 16.21,38.26 arc(16.42,38.22) C1278.1
TBTA_HD2CA_0_P: length 12.7
  TOP w0.14: JUSBC1.A2 9.24,32.76 arc(9.29,32.75) 9.33,32.72 9.36,32.69 arc(9.4,32.67) 9.45,32.66 10.19,32.66 arc(10.32,32.71) v7(10.37,32.84)
  BOTTOM w0.14: v7(10.37,32.84) 10.47,32.74 arc(10.51,32.71) 10.56,32.7 10.75,32.7 arc(10.8,32.71) 10.84,32.74 11.87,33.77 arc(11.9,33.81) 11.91,33.86 11.91,34.45 arc(11.99,34.88) 12.24,35.25 12.27,35.28 12.79,35.8 arc(12.81,35.84) 12.82,35.89 12.82,36.25 arc(12.79,36.42) 12.7,36.55 D75.1 12.65,36.8 arc(12.7,36.81) 12.74,36.84 12.78,36.88 arc(12.81,36.92) 12.82,36.97 12.82,37.53 arc(12.85,37.67) 12.92,37.78 13.52,38.38 arc(13.63,38.45) 13.76,38.48 16.01,38.48 arc(16.33,38.54) C1276.1
TBTA_HD2CA_1_N: length 13.1
  BOTTOM w0.14: C1274.1 14.53,36.76 arc(14.5,36.57) 14.4,36.42 13.99,36.02 arc(13.91,35.89) 13.88,35.75 arc(13.85,35.61) 13.78,35.5 13.72,35.44 13.1,34.82 arc(12.86,34.45) 12.77,34.02 12.77,32.9 arc(12.72,32.67) 12.6,32.48 11.95,31.83 arc(11.84,31.76) 11.72,31.73 arc(11.64,31.75) 11.57,31.79 D78.2 11.46,31.61 arc(11.42,31.42) 11.32,31.27 10.7,30.65 10.64,30.59 arc(10.44,30.46) 10.22,30.41 10.05,30.41 arc(9.76,30.35) 9.51,30.19 9.48,30.15 7.9,28.58 arc(7.86,28.55) 7.81,28.54 7.01,28.54 arc(6.76,28.65) JUSBC1.B3
TBTA_HD2CA_1_P: length 13.1
  BOTTOM w0.127: C1272.1 arc(14.89,36.39) 14.84,36.38
  BOTTOM w0.14: 14.84,36.38 arc(14.69,36.34) 14.55,36.27 14.15,35.87 arc(14.11,35.81) 14.1,35.75 arc(14.05,35.53) 13.93,35.34 13.87,35.29 13.25,34.67 arc(13.06,34.37) 12.99,34.02 12.99,32.9 arc(12.92,32.59) 12.75,32.33 11.99,31.56 arc(11.98,31.55) 11.97,31.54 arc(11.94,31.49) 11.93,31.43 arc(11.95,31.31) 12.02,31.22 D76.2 11.71,31.14 arc(11.65,31.14) 11.58,31.13 arc(11.46,31.08) 11.35,30.99 10.79,30.43 arc(10.53,30.26) 10.22,30.2 10.05,30.2 arc(9.84,30.15) 9.66,30.03 9.63,30 8.06,28.43 arc(7.94,28.35) 7.81,28.33 7.42,28.33 arc(7.33,28.32) 7.24,28.32 arc(6.93,28.24) JUSBC1.B2
TBTA_HPD: length 355.5
  TOP w0.102: UT1.M4 v7(24.93,31.76)
  IN1 w0.089: v5(221.44,140.42) 220.71,139.69 216.24,139.69 215.61,140.32 212.4,140.32 212.35,140.37 209.18,140.37 208.69,139.89 208.69,139.62 208.45,139.38 207.32,139.38 205.27,137.33 204.56,137.33 202.35,135.12 191.95,135.12 188.11,131.28 186.85,131.28 185.24,129.67 185.24,125.84 184.91,125.51 180.07,125.51 179.95,125.63 179.95,128 178.17,129.78 176.05,129.78 175.57,129.29 174.05,129.29 173.53,129.81 172.87,129.81 170.88,131.81 164.24,131.81 163.84,132.22 163.16,132.22 162.61,132.76 160.11,132.76 159.75,132.41 159.58,132.41 159.11,131.93 156.64,131.93 155.81,132.76 154.37,132.76 154.17,132.56 149.81,132.56 148.75,131.5 145.34,131.5 143.95,130.11 142.42,130.11 141.75,129.44 141.75,127.91 140.69,126.85 138.38,126.85 138.3,126.77 136.04,126.77 134.08,128.73 131.95,128.73 130.13,130.55 123.44,130.55 122.8,129.91 122.36,129.91 121.91,129.46 121.05,129.46 119.93,130.58 116.62,130.58 116.37,130.33 116.37,128.47 116.44,128.4 116.44,127.46 116.15,127.17 109.16,127.17 108.57,126.58 101.33,126.58 99.15,124.4 99.15,121.61 97.24,119.69 97.24,112.03 96.75,111.54 96.75,106.11 95.98,105.33 95.98,101.75 93.45,99.22 93.45,98.09 93.05,97.69 93.05,94.23 89.88,91.07 77.01,91.07 76.26,90.32 65.84,90.32 63.21,92.95 61.83,92.95 60.84,93.94 58.33,93.94 58.22,93.83 53.12,93.83 52.59,93.3 49.88,93.3 49.52,92.95 45.94,92.95 44.95,91.95 44.95,87.56 43.7,86.32 40.15,86.32 39.86,86.03 39.64,86.03 35.22,81.6 35.22,76.76 34.23,75.78 34.23,65.13 35.55,63.81 35.55,55.98 37.25,54.28 37.25,37.78 36.68,37.21 36.68,32.42 v3(36.6,32.33) ; v8(19.26,51.62) 19.26,50.43 19.56,50.12 19.75,50.12 20.17,50.54 23.52,50.54 23.81,50.83 24.24,50.83 24.99,51.58 v3(26.05,51.58)
  GND1 w0.119: v10(13.92,53.73) v4(14.3,53.73) ; v4(19.21,52.03) 19.26,51.98 v8(19.26,51.62) ; v5(221.44,140.42) 221.52,140.42 v4(221.79,140.15) ; v4(223.73,139.15) 223.73,139.05 v10(223.27,138.59)
  IN2 w0.084: v3(36.6,32.33) 36.16,32.33 35.63,31.81 34.21,31.81 33.76,32.25 29.61,32.25 28.31,30.95 25.76,30.95 25.56,31.15 25.56,31.25 25.04,31.76 v7(24.93,31.76) 24.93,31.78 25.95,32.8 25.95,33.36 25.85,33.46 25.85,33.9 26.26,34.31 26.52,34.31 26.84,34.63 26.84,35.47 26.14,36.17 26.14,38.49 25.86,38.77 25.86,39.97 26.35,40.46 26.35,42.11 27.63,43.39 27.63,45.19 26.71,46.12 26.71,47.04 26.17,47.58 26.17,48.3 25.86,48.6 25.86,49.17 25.72,49.31 25.72,51.25 v3(26.05,51.58)
  IN3 w0.084: v4(223.73,139.15) 222.91,139.15 221.9,140.15 v4(221.79,140.15)
  GND4 w0.119: v4(19.21,52.03) 19.13,52.03 v9(18.88,52.28) ; v9(14.61,53.48) 14.36,53.73 v4(14.3,53.73)
  BOTTOM w0.119: v9(14.61,53.48) 15.81,52.28 v9(18.88,52.28)
  BOTTOM w0.127: R1416.1 25.13,31.4 25.13,31.57 v7(24.93,31.76)
TBTA_HPD_EC: length 27.3
  TOP w0.119: v2(231.03,138.51) 230.59,138.95 224.36,138.95 R5674.1 R5675.1
  IN2 w0.084: v2(235.31,122.75) 235.63,123.07 235.63,124.02 235.75,124.13 235.75,124.71 236.01,124.97 236.01,127.25 234.67,128.59 234.32,128.59 233.64,129.27 233.64,131.24 232,132.88 232,133.41 231.75,133.65 230.96,133.65 230.56,134.06 230.56,136.81 231.14,137.39 231.14,138.4 v2(231.03,138.51)
TBTA_I2C_ALERT#: length 44.8
  TOP w0.102: UT1.J4 v7(23.63,31.76)
  IN1 w0.089: v5(13.85,44.31) 14.23,44.69 v3(15.47,44.69)
  GND1 w0.119: v10(9.42,53.73) v4(9.42,54.2) ; v4(13.85,43.82) v5(13.85,44.31)
  IN2 w0.084: v7(23.63,31.76) 24.07,31.33 24.07,30.11 23.2,29.24 20.51,29.24 19.96,29.79 19.96,33.35 19.85,33.45 19.85,37.88 20.08,38.11 20.08,40.48 19.31,41.25 18.6,41.25 18.36,41.49 18.36,41.66 15.47,44.54 v3(15.47,44.69)
  IN3 w0.084: v4(13.85,43.82) 12.66,43.82 12.41,44.07 12.41,46.94 11.86,47.49 11.86,50.19 12.16,50.49 12.16,51.59 11.86,51.89 11.86,53.45 11.11,54.2 v4(9.42,54.2)
  BOTTOM w0.127: v7(23.63,31.76) 23.95,31.45 23.95,28.56 R1404.1
TBTA_I2C_D_N: length 25.8
  IN1 w0.066: v1(9.91,42.55) 10.2,42.55 10.27,42.49 10.27,42.27 10.47,42.07 11.07,42.07 11.63,42.63 12.78,42.63 14.48,40.93 14.48,34.41 14.75,34.15 14.75,32.07 14.84,31.97 14.84,30.22 14.23,29.61 14,29.61 13.93,29.69 13.93,29.92 v1(13.84,30.01) 13.57,29.74 12.16,29.74 11.36,30.54 9.85,30.54 9.19,29.88 8.6,29.88 7.94,30.54 7.81,30.54 JUSBC1.B7
TBTA_I2C_D_N_R: length 8.6
  IN1 w0.066: v1(9.91,43.47) 10.2,43.47 10.27,43.53 10.27,43.77 10.47,43.98 11.66,43.98 12.78,45.09 12.78,47.03 12.34,47.46 12.34,48.76 12.32,48.78 12.32,49.28 12.45,49.41 12.45,49.7 v1(12.42,49.73)
TBTA_I2C_D_P: length 25.8
  IN1 w0.066: v1(10.8,42.55) 10.51,42.55 10.45,42.49 10.45,42.35 10.55,42.25 10.99,42.25 11.55,42.81 12.86,42.81 14.66,41 14.66,34.49 14.93,34.22 14.93,32.14 15.02,32.05 15.02,30.15 14.3,29.43 13.97,29.43 v1(13.84,29.29) 13.57,29.56 12.09,29.56 11.28,30.36 9.93,30.36 9.26,29.7 8.53,29.7 7.86,30.36 7.71,30.36 JUSBC1.B6
TBTA_I2C_D_P_R: length 9.2
  IN1 w0.066: v1(10.8,43.47) 10.51,43.47 10.45,43.53 10.45,43.7 10.54,43.8 11.74,43.8 12.96,45.02 12.96,47.1 12.52,47.54 12.52,48.83 12.5,48.85 12.5,49.21 12.66,49.36 12.66,49.99 v1(12.42,50.23)
TBTA_LDO_BMC: length 1.9
  TOP w0.119: U717.E1 9.34,52.73 8.59,53.48 7.96,53.48 C1328.1
TBTA_LSRX: length 29.1
  TOP w0.119: v10(10.27,47.77) R5723.1
  TOP w0.127: v2(18.32,31.22) 18.6,30.95 19.48,30.95 UT1.A4
  GND1 w0.119: v4(10.73,49.08) 10.27,48.63 v10(10.27,47.77)
  IN2 w0.084: v4(10.73,49.08) 10.8,49.16 11.4,49.16 11.64,48.92 11.64,48.12 13.51,46.25 14.06,46.25 15.11,45.2 15.11,44.65 18.17,41.58 18.17,41.41 18.52,41.06 19.23,41.06 19.89,40.4 19.89,38.19 19.67,37.96 19.67,34.18 18.7,33.22 18.7,31.61 v2(18.32,31.22)
  IN3 w0.084: v6(10.86,50.2) 10.86,49.23 10.73,49.09 v4(10.73,49.08)
TBTA_LSRX_DEG4: length 2.2
  TOP w0.076: 10.67,49.51 10.67,49.92 10.92,50.16 U717.K4
  TOP w0.119: 10.67,49.51 10.71,49.48 10.71,48.8 R5721.2
TBTA_LSRX_R: length 0.7
  BOTTOM w0.119: R5689.2 R5691.1
TBTA_LSTX: length 28.6
  TOP w0.119: R5670.1 17.18,31.58 18.24,31.58 18.4,31.73 v2(18.4,31.92) ; v2(10.88,47.77) 10.88,47.14 R5722.1 ; v1(19.79,32.21) 20.1,32.21 UT1.A5
  IN1 w0.089: v2(18.4,31.92) 18.4,31.54 19.01,30.93 19.42,30.93 19.93,31.44 19.93,32.07 v1(19.79,32.21)
  IN2 w0.084: v2(18.4,31.92) 18.4,33.21 19.46,34.27 19.46,36.08 18.96,36.58 18.49,36.58 18.27,36.79 18.27,37.02 17.67,37.62 17.67,38.03 17.96,38.32 17.96,41.53 14.92,44.57 14.92,45.12 14.01,46.03 13.46,46.03 11.72,47.77 v2(10.88,47.77) 10.88,48.5 v4(11.21,48.83)
  GND4 w0.119: v9(10.86,48.67) 11.06,48.67 v4(11.21,48.83)
TBTA_LSTX_DEG3: length 1.4
  TOP w0.119: U717.L4 10.92,48.4 R5720.2
TBTA_LSTX_R: length 0.7
  BOTTOM w0.119: R5690.1 R5688.2
TBTA_PD_SBU1: length 6.8
  TOP w0.119: v10(12.81,49.11) 12.76,49.06 11.86,49.06 11.75,48.95 11.74,48.95 11.48,48.68 11.48,48.68 11.46,48.66 11.46,46.34 R1430.1
  IN1 w0.089: v1(12.92,50.23) 12.83,50.14 12.83,49.13 v10(12.81,49.11)
  GND1 w0.119: v10(12.81,49.11) 12.88,49.03 v4(13.44,49.03)
  GND4 w0.119: v9(13.14,48.75) 13.16,48.75 v4(13.44,49.03)
  BOTTOM w0.119: R5690.2 13.06,48.67 v9(13.14,48.75)
TBTA_PD_SBU2: length 7.6
  TOP w0.119: R1431.1 12.15,46.79 12.02,46.67 11.82,46.67 11.69,46.79 11.69,48.6 11.83,48.74 12.87,48.74 13.1,48.97 v10(13.1,49.32) 13.09,49.32 12.92,49.49 U717.L8
  GND1 w0.119: v10(13.1,49.32) 13.13,49.35 13.13,49.75 v4(13.19,49.82)
  IN3 w0.084: v4(13.19,49.82) 13.28,49.73 13.52,49.73 13.63,49.84 13.63,50.12 13.56,50.2 v6(13.21,50.2)
  BOTTOM w0.119: R5691.2 v6(13.21,50.2)
TBTA_RESET_N: length 50.8
  TOP w0.119: D100.1 32.61,32.85 32.34,33.11 31.81,33.11 31.07,32.37 v1(30.9,32.37)
  IN1 w0.089: v3(23.55,29.98) 23.55,28.87 23.35,28.67 23.35,27.82 24.24,26.93 24.99,26.93 26.49,28.43 26.49,28.81 27.4,29.73 27.4,30.78 27.6,30.98 28.57,30.98 29.58,29.98 30.42,29.98 30.63,30.19 30.63,30.59 30.35,30.86 30.35,31.4 30.71,31.77 30.71,32.19 v1(30.9,32.37)
  IN2 w0.084: v2(14.42,52.23) 14.06,51.87 12.41,51.87 11.42,50.88 11.42,50.59 11.18,50.35 11.18,49.63 12.27,48.53 12.27,48.01 13.82,46.46 14.11,46.46 15.96,44.61 15.96,44.32 18.55,41.73 18.55,41.56 18.66,41.45 19.37,41.45 20.26,40.56 20.26,38.02 20.06,37.82 20.06,33.5 20.14,33.42 20.14,29.87 20.59,29.42 22.99,29.42 v3(23.55,29.98)
TBTA_SBU1: length 50.7
  TOP w0.119: v1(10.7,25.84) 10.7,26.82 10.83,26.94 10.83,28.01 10.62,28.21 10.62,29.46 10.33,29.76 JUSBC1.A8 ; v10(13.34,46.31) 12.71,46.31 R1430.2
  IN1 w0.089: v2(13.49,25.45) 13.21,25.73 13.21,27.14 13.09,27.26 12.83,27.26 12.71,27.14 12.71,26.67 12.58,26.54 11.4,26.54 v1(10.7,25.84)
  GND1 w0.119: v4(14.16,46.95) 13.53,46.32 13.35,46.32 v10(13.34,46.31)
  IN2 w0.084: v2(13.49,25.45) 13.65,25.45 13.77,25.57 13.77,25.89 13.65,26.02 v4(10.32,26.02)
  IN3 w0.084: v4(10.32,26.02) 10.31,26.02 10.09,26.24 10.09,27.49 9.54,28.04 9.54,29.22 9.97,29.65 9.97,33.38 10.02,33.43 10.02,42.41 v6(5.81,46.62) ; v4(14.16,46.95) 13.99,46.78 v6(13.99,45.94)
  BOTTOM w0.119: v6(5.81,46.62) 5.81,46.95 5.96,47.09 6.65,47.09 8.34,45.4 v13(12.99,45.4) 13.53,45.4 13.99,45.86 v6(13.99,45.94)
TBTA_SBU2: length 50.7
  TOP w0.119: R1431.2 12.6,47.8 12.6,47.24 13.1,46.74 v10(13.35,46.74)
  IN1 w0.081: v3(9.53,29.17) 9.57,29.17 10.1,29.7 10.42,29.7 10.43,29.69
  IN1 w0.089: 10.43,29.69 10.65,29.47 10.65,28.82 v3(11.36,28.11)
  GND1 w0.119: v4(13.65,47.13) 13.65,47.04 v10(13.35,46.74)
  IN2 w0.084: v3(11.36,28.11) 11.35,28.1 11.97,28.1 13.49,26.58 v2(13.49,26.46) 10.24,26.46 v4(9.79,26.01) ; v3(9.53,29.17) 9.53,29.52 7.68,31.38 6.72,31.38 JUSBC1.B8
  IN3 w0.084: v4(13.65,47.13) 13.63,47.11 v6(13.63,45.94) ; v6(5.63,47.6) 5.51,47.47 5.51,46.38 5.81,46.07 6.1,46.07 9.84,42.33 9.84,33.51 9.79,33.46 9.79,29.73 9.36,29.3 9.36,27.96 9.9,27.41 9.9,26.12 v4(9.79,26.01)
  BOTTOM w0.119: v6(13.63,45.94) 13.47,45.78 v14(10.67,45.78) 8.27,45.78 6.74,47.32 5.91,47.32 v6(5.63,47.6)
TBTA_TX0_N: length 3.7
  TOP w0.076: UT1.B19 20.45,38.36 arc(20.41,38.33) 20.36,38.33 20.06,38.33 arc(20.01,38.33) 19.97,38.36 19.92,38.4 arc(19.91,38.41) 19.9,38.42 arc(19.87,38.43) 19.83,38.44 18.88,38.44 arc(18.66,38.4) 18.47,38.27 v7(18.42,38.22)
  BOTTOM w0.14: C1278.2 17.28,38.19 arc(17.42,38.28) 17.58,38.31 18.21,38.31 arc(18.33,38.29) v7(18.42,38.22)
TBTA_TX0_P: length 3.8
  TOP w0.076: UT1.A19 20.23,38.56 arc(20.32,38.59) 20.35,38.68 20.35,38.71 arc(20.33,38.77) 20.27,38.79 20.02,38.79 arc(19.97,38.78) 19.93,38.76 19.81,38.63 arc(19.77,38.61) 19.72,38.6 18.88,38.6 arc(18.65,38.64) 18.46,38.77 v7(18.42,38.81)
  BOTTOM w0.14: v7(18.42,38.81) 18.3,38.69 arc(18.12,38.57) 17.91,38.53 17.58,38.53 arc(17.41,38.56) 17.26,38.66 C1276.2
TBTA_TX1_N: length 6.2
  TOP w0.076: UT1.B17 20.52,37.78 arc(20.42,37.85) 20.3,37.87 19.82,37.87 arc(19.78,37.86) 19.74,37.83 19.36,37.45 arc(19.32,37.42) 19.27,37.41 19.09,37.41 arc(18.91,37.45) v7(18.75,37.55)
  BOTTOM w0.14: v7(18.75,37.55) 18.73,37.54 arc(18.55,37.41) 18.33,37.37 17.76,37.37 arc(17.7,37.38) 17.66,37.41 17.61,37.46 arc(17.5,37.54) 17.37,37.56 15.88,37.56 arc(15.6,37.51) 15.36,37.35 15.36,37.34 arc(15.21,37.24) 15.03,37.21 C1274.2
TBTA_TX1_P: length 6.2
  TOP w0.076: v7(18.75,36.97) 18.75,37 arc(18.76,37.05) 18.79,37.09 18.87,37.17 arc(18.96,37.24) 19.07,37.26 19.33,37.26 arc(19.38,37.27) 19.42,37.29 19.7,37.57 arc(19.77,37.6) 19.85,37.57 19.98,37.44 arc(20.02,37.42) 20.07,37.41 20.3,37.41 arc(20.38,37.44) 20.42,37.52 arc(20.38,37.6) 20.3,37.64 UT1.A17
  BOTTOM w0.14: v7(18.75,36.97) 18.73,36.99 arc(18.55,37.11) 18.33,37.15 17.66,37.15 arc(17.61,37.16) 17.57,37.19 17.46,37.31 arc(17.41,37.34) 17.37,37.35 15.88,37.35 arc(15.68,37.31) 15.51,37.19 15.51,37.19 arc(15.39,37.01) C1272.2
TBTA_USB2_D_N: length 17.4
  TOP w0.089: UT1.D20 21.35,39.58 v2(21.33,39.61)
  IN2 w0.066: v2(21.33,39.61) 21.47,39.61 21.56,39.52 21.56,39.28 21.48,39.21 21.21,39.21 21.02,39.4 21.02,41.46 20.18,42.3 19.05,42.3 16.78,44.57 16.78,45.02 12.42,49.38 12.42,49.71 12.14,49.99 11.48,49.99 11.42,50.05 v2(11.42,50.23)
TBTA_USB2_D_N_R: length 24.2
  TOP w0.112: R93.1 14.34,32.49 ML6.1 14.2,33.15 14.03,33.32 14.03,33.5 v1(14.3,33.78)
  IN1 w0.066: v1(11.92,49.73) 11.86,49.67 11.86,49.49 11.75,49.39 11.75,47.11 12.12,46.74 12.12,45.3 11.38,44.56 9.99,44.56 9.48,44.05 9.48,42.2 10.2,41.47 11.46,41.47 11.93,41.94 12.64,41.94 13.9,40.69 13.9,34.3 13.85,34.25 13.85,33.77 13.95,33.68 14.03,33.68 14.13,33.78 v1(14.3,33.78)
TBTA_USB2_D_P: length 17.4
  TOP w0.089: v2(21.85,39.61) 22,39.45 UT1.E20
  IN2 w0.066: v2(11.42,49.73) 11.53,49.84 12.08,49.84 12.27,49.65 12.27,49.32 16.64,44.96 16.64,44.51 18.99,42.15 20.12,42.15 20.88,41.4 20.88,39.33 21.15,39.06 21.55,39.06 21.71,39.22 21.71,39.46 v2(21.85,39.61)
TBTA_USB2_D_P_R: length 24.2
  TOP w0.112: R94.1 13.56,32.49 ML6.4 13.7,33.13 13.77,33.2 13.77,33.61 v1(13.6,33.78)
  IN1 w0.066: v1(11.92,50.23) 11.68,49.99 11.68,49.56 11.57,49.46 11.57,47.04 11.94,46.67 11.94,45.37 11.31,44.74 9.91,44.74 9.3,44.13 9.3,42.12 10.13,41.29 11.54,41.29 12.01,41.76 12.57,41.76 13.72,40.61 13.72,34.37 13.67,34.32 13.67,33.85 v1(13.6,33.78)
TBTA_USB_OC0#: length 228.4
  IN1 w0.089: v3(8.82,55.68) 7.97,55.68 5.43,53.14 5.43,46.3 5.9,45.83 9.63,45.83 9.87,46.07 v1(9.87,46.16)
  IN2 w0.06: v2(132.68,100.6) 132.89,100.6 133.1,100.39 133.86,100.39 134.44,99.8 135.66,99.8 136.19,99.27 136.56,99.27 136.91,98.92 136.91,98.31 137.39,97.82 137.55,97.82 137.65,97.72 137.93,97.72 138.08,97.57 138.18,97.57 138.31,97.44 138.31,97.34
  IN2 w0.084: 138.31,97.34 138.31,96.77 138.69,96.4 v4(138.69,96.38) 138.69,96.37 139.01,96.05 139.01,96.05 139.58,95.48 140.14,95.48 140.49,95.12 142.1,95.12 142.39,94.84 142.39,94.5 142.79,94.09 143.73,94.09 144.49,93.34 146.16,93.34 146.41,93.08 146.5,93.08 146.7,92.88 149.3,92.88 149.5,93.09 v4(150.02,93.09) ; v4(134.19,82.7) 134.19,81.47 132.55,79.83 47.49,79.83 46.44,80.88 v4(46.21,80.88) ; v3(8.82,55.68) 8.99,55.86 8.99,59.35 9.47,59.82 9.47,63.67 17.77,71.97 17.77,78.79 16.88,79.68 16.88,86.66 17.88,87.66 v7(18.64,87.66)
  IN3 w0.084: v4(46.21,80.88) 46.54,81.21 49.79,81.21 50.11,81.53 v6(50.04,81.59)
  GND4 w0.119: v4(134.19,82.7) 134.19,82.84 134,83.03 v9(134,83.06) ; v9(150.46,92.76) 150.13,93.09 v4(150.02,93.09) ; v9(138.92,96.08) 138.92,96.16 138.7,96.38 v4(138.69,96.38)
  BOTTOM w0.119: v7(18.64,87.66) 18.99,88.02 20.96,88.02 22.49,89.55 26.9,89.55 28,88.44 30.73,88.44 31.85,89.56 42.78,89.56 50.04,82.29 v6(50.04,81.59) ; v9(150.46,92.76) 150.36,92.76 149.57,91.96 149.57,91.74 143.79,85.96 141.79,85.96 141.32,85.48 136.42,85.48 v9(134,83.06)
TBTA_VBUS: length 86.8
  TOP w0.508: C1366.2 v2(10.2,34.79)
  GND1 w0.254: v10(9,29.25) 8.87,29.25 v4(8.35,29.78) ; v10(9,31.75) v4(8.4,31.75)
  GND1 w0.508: v10(32.24,63.1) 31.8,63.1 v4(31.71,63.01)
  IN3 w0.508: v4(31.71,63.01) 31.71,56.27 v6(31.11,55.67)
  IN3 w1.016: 18.97,21.65 17.02,21.65 14.36,24.31 14.36,30.04 13.68,30.71 13.68,38.92 13.72,38.96 13.72,38.96 ; 37.98,39.91 36.9,38.83 36.9,31.09 37.78,30.2 37.78,24.01 37.2,23.43 32.71,23.43 31.36,22.08 25.81,22.08 25.03,22.87
  BOTTOM w0.254: JUSBC1.B9 7.53,31.77 8.82,31.77 C1365.2 ; JUSBC1.B4 8.85,30.55 C1359.2
  BOTTOM w0.508: 37.76,41.92 37.79,41.94 37.79,50.95 36.88,51.86 32.58,51.86 31.11,53.33 v6(31.11,55.67)
  BOTTOM w1.016: 21.28,21.81 23.4,21.81
  vias: v1(13.07,36.74) v1(13.39,37.24) v1(13.4,36.32) v2(10.33,26.83) v4(8.24,30.28) v4(8.54,31.02) v4(9.29,31.35) v4(12.4,41.17) v4(12.44,40.7) v4(12.4,40.19) v4(12.4,39.72) v4(12.82,40.97) v4(12.82,40.42) v4(16.29,48.22) v4(16.63,47.89) v4(16.66,48.55) v4(17.04,48.87) v4(17.1,48.31) v4(17.1,47.85) v5(11.78,38.59) v5(11.94,38.04) v5(12.03,38.36) v5(12.3,38.15) v5(12.26,37.83) v5(12.67,37.89) v6(19.79,21.98) v6(19.79,21.62) v6(19.79,21.27) v6(20.15,21.62) v6(23.54,22.84) v6(23.9,22.84) v6(24.25,22.84) v6(24.25,22.49) v7(8.54,37.14) v7(8.45,36.58) v7(9.02,36.57) v7(9.12,37.14) v7(20.05,54.49) v7(19.97,53.93) v7(38.04,41.35) v7(38.04,40.71) v7(42.28,104.3) v7(42.78,104.58) v7(42.78,104.02) v7(42.78,103.46) v10(17.95,48.95) v10(17.93,47.85) v10(17.96,48.49) v10(18.21,48.68) v10(18.18,48.26) v14(24.19,21.7) v16(11.64,41.25) v16(11.64,40.88) v16(11.64,40.53) v16(11.66,40.15) v16(11.66,39.8) v16(11.97,41.22) v16(11.97,40.85) v16(11.97,40.51) v16(12,40.13) v16(12,39.77)
TBTA_VBUS_L: length 1.1
  TOP w0.254: v7(13.92,55.31) U717.A10 U717.B10
  vias: v7(14.7,49.36) v7(14.85,49.91) v7(15.12,51.42) v7(15.12,50.83) v7(15.3,50.27) v7(15.27,49.39)
TBTB_AUX_N: length 3.5
  TOP w0.089: UT1.W16 v7(28.18,36.96)
  BOTTOM w0.112: v7(28.18,36.96) 28.4,37.18 28.4,37.35 29.73,38.68 30.09,38.68 C1283.2
TBTB_AUX_P: length 3.3
  TOP w0.089: v7(28.83,36.96) 28.75,37.05 28.75,37.19 28.94,37.38 29.06,37.38 UT1.Y16
  BOTTOM w0.112: v7(28.83,36.96) 28.76,36.96 28.66,37.07 28.66,37.24 29.83,38.42 30.16,38.42 C1281.2
TBTB_CA2HD_0_N: length 26.4
  TOP w0.076: v7(18.35,35.11) 18.42,35.18 arc(18.59,35.29) 18.79,35.33 19.2,35.33 arc(19.25,35.34) 19.29,35.37 19.46,35.54 arc(19.51,35.57) 19.57,35.57 20.28,35.57 arc(20.43,35.61) 20.56,35.7 UT1.B13
  BOTTOM w0.14: v7(18.35,35.11) arc(18.24,35.19) 18.11,35.21 16.44,35.21 arc(16.39,35.2) 16.35,35.18 14.76,33.59 arc(14.74,33.54) 14.73,33.5 14.73,30.78 arc(14.54,29.83) 14,29.02 11.34,26.36 arc(11.06,25.95) 10.97,25.47 10.97,24.66 arc(11.04,24.47) 11.23,24.39 D89.1 11.21,24.27 arc(11.03,24) 10.97,23.68 10.97,21.77 arc(10.94,21.63) 10.87,21.52 7.92,18.58 arc(7.81,18.5) 7.68,18.48 6.96,18.48 arc(6.72,18.36) JUSBC2.B10
TBTB_CA2HD_0_P: length 26.4
  TOP w0.076: UT1.A13 20.26,35.8 arc(20.34,35.83) 20.38,35.92 arc(20.34,36) 20.26,36.03 20.07,36.03 arc(20.03,36.02) 19.98,35.99 19.76,35.78 arc(19.72,35.75) 19.67,35.74 19.55,35.74 arc(19.44,35.72) 19.35,35.66 19.21,35.52 arc(19.19,35.5) 19.16,35.49 18.79,35.49 arc(18.57,35.54) 18.39,35.66 v7(18.35,35.7)
  BOTTOM w0.14: v7(18.35,35.7) 18.16,35.5 arc(18.07,35.45) 17.97,35.43 16.44,35.43 arc(16.31,35.4) 16.2,35.33 16.14,35.27 14.61,33.74 arc(14.54,33.63) 14.51,33.5 14.51,30.78 arc(14.34,29.91) 13.84,29.17 12.51,27.84 11.18,26.51 arc(10.86,26.03) 10.75,25.47 10.75,24.66 arc(10.67,24.47) 10.48,24.39 D87.1 10.52,24.25 arc(10.69,23.99) 10.75,23.68 10.75,21.77 arc(10.74,21.72) 10.71,21.68 7.77,18.73 arc(7.73,18.7) 7.68,18.69 7.02,18.69 arc(6.8,18.75) JUSBC2.B11
TBTB_CA2HD_1_N: length 25.9
  TOP w0.076: UT1.A7 20.29,33.04 arc(20.4,33.16) 20.29,33.27 20.05,33.27 arc(20,33.26) 19.96,33.23 19.92,33.2 arc(19.9,33.16) 19.89,33.11 19.89,33.01 arc(19.87,32.92) 19.82,32.85 19.17,32.2 arc(19.16,32.18) v7(19.16,32.17)
  TOP w0.14: JUSBC2.A10 9.15,14.76 arc(9.18,14.75) 9.2,14.75 9.32,14.7 arc(9.34,14.69) 9.36,14.67 9.46,14.57 arc(9.5,14.55) 9.55,14.54 9.65,14.54 arc(9.73,14.55) 9.79,14.6 9.82,14.63 v7(10.05,14.86)
  BOTTOM w0.14: v7(19.16,32.17) 19.09,32.09 arc(19.05,32.06) 19.01,32.03 arc(18.89,31.98) 18.76,31.96 18.27,31.96 arc(18.14,31.94) 18.03,31.86 17.29,31.12 arc(17.22,31.01) 17.19,30.88 17.19,29.53 arc(17.02,28.67) 16.53,27.94 15.99,27.39 15.44,26.85 arc(15.22,26.52) 15.14,26.13 15.14,23.26 arc(15.07,23.08) 14.89,23.01 D90.2 15.01,22.78 arc(15.12,22.6) 15.16,22.4 15.16,22.27 arc(15.14,22.17) 15.09,22.09 14.3,21.3 arc(13.81,20.56) 13.63,19.69 13.63,18.62 arc(13.44,17.66) 12.9,16.85 10.9,14.85 arc(10.75,14.75) 10.57,14.71 10.4,14.71 arc(10.22,14.75) v7(10.05,14.86)
TBTB_CA2HD_1_P: length 25.9
  TOP w0.076: UT1.B7 20.52,32.91 arc(20.41,32.84) 20.29,32.81 20.06,32.81 arc(20.06,32.81) 20.06,32.81 arc(20.03,32.81) 20.01,32.8 arc(20.01,32.8) 20,32.8 arc(19.99,32.79) 19.97,32.78 19.63,32.43 arc(19.55,32.32) 19.53,32.19 19.53,31.83 arc(19.53,31.8) v7(19.55,31.77)
  TOP w0.14: JUSBC2.A11 9.42,14.26 arc(9.46,14.26) 9.5,14.29 arc(9.53,14.31) 9.58,14.32 9.94,14.32 arc(10,14.31) v7(10.05,14.28)
  BOTTOM w0.14: v7(19.55,31.77) 19.54,31.77 arc(19.51,31.75) 19.48,31.75 18.27,31.75 arc(18.22,31.74) 18.18,31.71 17.44,30.97 arc(17.42,30.93) 17.41,30.88 17.41,29.53 arc(17.22,28.59) 16.68,27.78 15.6,26.7 arc(15.42,26.44) 15.36,26.13 15.36,23.26 arc(15.43,23.08) 15.61,23.01 D88.2 15.54,22.78 arc(15.42,22.6) 15.38,22.4 15.38,22.27 arc(15.34,22.09) 15.24,21.93 14.45,21.15 arc(14.01,20.48) 13.85,19.69 13.85,18.62 arc(13.64,17.58) 13.05,16.7 11.06,14.7 arc(10.83,14.55) 10.57,14.5 arc(10.29,14.44) v7(10.05,14.28)
TBTB_CC1: length 57.6
  TOP w0.254: U719.K9 U719.L9 26.75,49.12 27.35,48.52 28.52,48.52 29.2,47.84 v10(29.37,47.84)
  IN1 w0.254: v7(18.9,20.79) 18.9,20.84 17.89,21.85 14.55,21.85 14.38,21.69 14,21.69 13.74,21.42 v1(13.74,21.32) 13.3,20.89 13.3,19.61 10.98,17.29 9.04,17.29 v1(9,17.25)
  GND1 w0.254: v10(29.37,47.84) 29.29,47.84 v4(28.99,47.53)
  GND4 w0.254: v4(28.99,47.53) 29.01,47.56 v9(29.01,48.05)
  BOTTOM w0.254: v9(29.01,48.05) 30.34,48.05 35.2,43.19 35.2,34.31 24.33,23.44 20.74,23.44 v14(20.34,23.04) 18.9,21.61 v7(18.9,20.79)
TBTB_CC2: length 67.7
  TOP w0.254: v10(27.25,49.98) U719.L10 27.25,49.37 27.58,49.04 29.05,49.04 C290.1
  IN1 w0.254: v2(14.17,14.79) 13.82,14.45 12.72,14.45 11.6,13.33 9.52,13.33 9.1,13.75 8.19,13.75 7.91,14.03 7.91,14.85 8.01,14.96 8.01,15.36 v3(7.89,15.47)
  GND1 w0.127: JUSBC2.B5 6.72,15.63 7.78,15.63 7.89,15.51 v3(7.89,15.47)
  GND1 w0.254: v10(27.25,49.98) v4(27.25,49.51)
  IN2 w0.127: v3(7.89,15.47) 7.89,15.51 7.77,15.63 6.72,15.63 JUSBC2.B5
  IN2 w0.254: v4(14.33,14.32) 14.33,14.63 v2(14.17,14.79)
  IN3 w0.254: v4(14.33,14.32) v6(13.94,14.32)
  GND4 w0.254: v4(27.25,49.51) v9(27.64,49.51)
  BOTTOM w0.254: v6(13.94,14.32) 13.94,15.1 16.16,17.32 16.16,17.45 v14(18.91,20.19) 21.29,20.19 21.98,20.89 24.42,20.89 27.73,24.2 27.73,26.2 35.72,34.18 35.72,43.35 30.52,48.55 28.81,48.55 27.84,49.51 v9(27.64,49.51)
TBTB_DBG_CTL1: length 3.9
  IN1 w0.089: v1(24.25,52.48) 23.81,52.92 23.81,53.63 24.01,53.83 24.01,55.86 v1(23.86,56.02)
TBTB_DBG_CTL2: length 6.4
  IN1 w0.089: v1(24.75,52.98) 24.75,51.6 24.2,51.04 23.71,51.04 23.4,50.73 20.55,50.73 v1(20.21,51.07)
TBTB_DC_SS: length 30.9
  IN2 w0.508: v7(48.04,112.95) 44.04,112.95 41.73,115.26 41.73,120.37 42.31,120.95 42.31,127.86 42.06,128.11 42.06,129.18 42.93,130.06 42.93,137.08 v2(42.17,137.84)
TBTB_DCIN: length 25.4
  TOP w0.254: PQ112.4 v10(44.42,119.58)
  TOP w0.381: v7(47.56,126.88) 48.11,126.33 PR124.1
  GND1 w0.254: v4(45.22,119.16) 45.22,119.22 44.86,119.58 v10(44.42,119.58)
  IN3 w0.508: v6(45.52,107.45) 46.03,106.94 v7(46.95,106.94)
  GND4 w0.381: v9(45.12,118.63) 45.22,118.73 v4(45.22,119.16)
  BOTTOM w0.508: v7(47.56,126.88) 47.54,126.88 45.22,124.56 45.22,118.73 v9(45.12,118.63) 45.17,118.58 45.17,107.81 v6(45.52,107.45)
TBTB_DEBUG1: length 2.9
  TOP w0.119: U719.L2 23.25,49.34 23.38,49.21 23.38,48.72 23.16,48.5 23.04,48.5 22.92,48.37 22.92,47.18 R1466.2
TBTB_DEBUG2: length 2.3
  TOP w0.076: U719.K2 23.25,49.87 23.01,49.63 23.01,49.42 23.01,49.42 23.01,49.32 23.12,49.21 23.12,49.15 23.2,49.07 23.2,48.84 23.04,48.68 22.97,48.68 22.55,48.27 R1467.2
TBTB_DEG3_LSTX: length 18
  TOP w0.119: v2(23.85,48.13) 23.85,49.38 U719.L3
  IN2 w0.084: v2(26.55,58.66) 26.89,58.32 26.89,55.78 26.12,55.01 26.12,53.22 25.77,52.86 24.22,52.86 23.11,53.97 22.66,53.97 22.33,53.64 22.33,52.9 23.09,52.14 23.09,50.71 23.39,50.42 23.39,49.84 23.45,49.78 23.45,48.53 v2(23.85,48.13)
TBTB_DEG4_LSRX: length 22.1
  TOP w0.076: 23.59,49.22 23.59,49.24 23.5,49.33 23.5,49.67 23.75,49.92 v2(23.75,49.98)
  TOP w0.119: R5727.2 23.27,48.31 23.59,48.64 23.59,49.22
  IN2 w0.084: v2(25.53,63.52) 26.3,62.76 26.3,59.51 27.11,58.69 27.11,55.74 26.33,54.96 26.33,53.18 25.84,52.69 24.15,52.69 23.04,53.8 22.73,53.8 22.51,53.57 22.51,52.97 23.27,52.21 23.27,50.78 23.56,50.49 23.56,50.17 v2(23.75,49.98)
TBTB_DPSRC_AUX_N: length 20.3
  TOP w0.076: U719.J2 23.01,50.72 22.64,50.72 22.49,50.57
  TOP w0.089: v7(21.9,49.08) 21.95,49.13 21.95,49.55 22.24,49.84 22.24,50.29 22.49,50.54 22.49,50.57
  TOP w0.112: R1478.2 21.39,48.41 21.55,48.41 21.9,48.76 v7(21.9,49.08)
  BOTTOM w0.112: v7(21.9,49.08) 21.94,49.04 21.94,47.9 25.22,44.62 25.53,44.62 25.77,44.37 25.77,44.08 27.2,42.65 29.34,42.65 31.42,40.56 31.42,38.98 31.31,38.87 C1283.1
TBTB_DPSRC_AUX_P: length 20.1
  TOP w0.089: U719.J1 22.47,50.2 22.47,49.74 22.19,49.45 22.19,49.32 22.43,49.08 22.48,49.08 v7(22.48,49.08)
  TOP w0.112: R1479.2 21.83,48.33 22.16,48.65 22.16,48.76 22.48,49.08
  BOTTOM w0.112: v7(22.48,49.08) 22.2,48.79 22.2,48.01 25.33,44.88 25.63,44.88 26.03,44.48 26.03,44.19 27.31,42.91 29.44,42.91 31.68,40.67 31.68,38.87 31.42,38.61 31.29,38.61 31.2,38.52 31.2,38.34 31.08,38.21 30.96,38.21 C1281.1
TBTB_EE_CLK: length 3.7
  TOP w0.119: U719.A3 23.75,55.02 24.3,55.57 24.3,57.3 R1475.2
TBTB_EE_CS_N: length 7
  TOP w0.119: v1(22.37,55.68) 22.37,57.34 23.72,58.68 R1477.2
  IN1 w0.089: v1(23.75,53.98) 23.82,54.04 23.82,55.63 23.63,55.83 22.52,55.83 v1(22.37,55.68)
TBTB_EE_DI: length 2.6
  IN1 w0.089: v1(25.7,56.02) 24.25,54.57 v1(24.25,53.98)
TBTB_EE_DO: length 4.8
  TOP w0.119: U719.A4 24.25,54.66 25.23,55.63 25.23,58.21 R1476.2
TBTB_HD2CA_0_N: length 22
  TOP w0.14: v7(17.28,34) 17.39,34.12 arc(17.47,34.17) 17.56,34.18 17.67,34.18 arc(17.8,34.13) C1279.1 ; v7(10.19,18.3) 10.17,18.32 arc(10.03,18.41) 9.86,18.45 9.63,18.45 arc(9.59,18.44) 9.55,18.41 9.43,18.29 arc(9.39,18.27) 9.34,18.26 JUSBC2.A3
  BOTTOM w0.14: v7(10.19,18.3) 10.35,18.45 arc(10.41,18.5) 10.48,18.51 10.62,18.51 arc(10.81,18.55) 10.97,18.66 11.53,19.22 arc(11.85,19.69) 11.96,20.24 11.96,21.14 arc(11.97,21.19) 11.99,21.23 12.36,21.6 arc(12.39,21.64) 12.4,21.69 12.4,21.95 arc(12.44,22.13) 12.54,22.28 12.66,22.4 D85.1 12.67,22.51 arc(12.45,22.6) 12.36,22.82 12.36,25.43 arc(12.48,26.01) 12.81,26.5 14.99,28.68 arc(15.44,29.36) 15.6,30.17 15.6,33.14 arc(15.61,33.19) 15.64,33.23 16.53,34.12 arc(16.57,34.15) 16.62,34.16 16.89,34.16 arc(17.1,34.12) v7(17.28,34)
TBTB_HD2CA_0_P: length 22
  TOP w0.14: v7(17.28,34.58) 17.39,34.47 arc(17.47,34.42) 17.56,34.4 17.66,34.4 arc(17.79,34.45) C1277.1 ; JUSBC2.A2 9.4,18.76 arc(9.45,18.75) 9.49,18.72 9.51,18.7 arc(9.55,18.67) 9.6,18.66 9.86,18.66 arc(9.96,18.68) 10.05,18.74 v7(10.19,18.89)
  BOTTOM w0.14: v7(17.28,34.58) 17.21,34.51 arc(17.05,34.41) 16.87,34.37 16.62,34.37 arc(16.49,34.35) 16.38,34.27 16.11,34.01 15.49,33.38 arc(15.41,33.27) 15.39,33.14 15.39,30.17 arc(15.24,29.44) 14.83,28.83 13.74,27.74 12.66,26.65 arc(12.28,26.09) 12.15,25.43 12.15,22.68 arc(12.1,22.56) 11.98,22.51 D83.1 12.08,22.21 arc(12.16,22.09) 12.19,21.95 12.19,21.78 arc(12.18,21.73) 12.14,21.68 11.84,21.38 arc(11.77,21.27) 11.74,21.14 11.74,20.24 arc(11.65,19.77) 11.38,19.37 11,19 10.82,18.81 arc(10.73,18.75) 10.62,18.73 10.48,18.73 arc(10.36,18.75) 10.25,18.82 v7(10.19,18.89)
TBTB_HD2CA_1_N: length 24.8
  TOP w0.14: C1275.1 17.24,33.14 arc(17.18,33.15) v7(17.13,33.19)
  BOTTOM w0.14: v7(17.13,33.19) arc(17.09,33.18) 17.06,33.16 16.3,32.4 arc(16.27,32.36) 16.26,32.32 16.26,29.54 arc(16.17,29.07) 15.9,28.67 14.93,27.7 13.96,26.73 arc(13.66,26.28) 13.56,25.75 13.56,24.6 arc(13.5,24.45) 13.35,24.39 D86.2 13.35,24.22 arc(13.51,23.98) 13.56,23.71 13.56,22.31 arc(13.48,21.91) 13.25,21.56 12.94,21.25 arc(12.74,20.95) 12.67,20.59 12.67,19.88 arc(12.51,19.1) 12.07,18.43 8.27,14.64 arc(8.17,14.57) 8.04,14.54 7.31,14.54 arc(6.93,14.64) JUSBC2.B3
