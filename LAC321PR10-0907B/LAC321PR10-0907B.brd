# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG18: length 21
  IN2 w0.06: v2(118.69,99.1) 118.7,99.09 118.7,98.36 118.27,97.93 116.74,97.93 115.91,97.09 114.56,97.09 113.93,96.46 113.93,95.79
  IN2 w0.084: v4(110.8,93.96) 111.72,94.88 113.62,94.88 113.93,95.18 113.93,95.79
  IN3 w0.084: v6(113.55,85.35) 113.55,85.81 112.95,86.4 112.95,88.53 111.08,90.41 111.08,93.82 110.93,93.96 v4(110.8,93.96)
CFG19: length 26.3
  IN2 w0.06: 113.09,95.96 114.46,97.33 114.93,97.33 115.11,97.51 115.11,97.81 115.21,97.91 116.39,97.91 116.65,98.18 117.91,98.18 118.49,98.76 118.49,99.25 118.7,99.46 v2(118.7,99.57)
  IN2 w0.084: v4(109.86,94.72) 110.27,95.13 111.49,95.13 111.59,95.23 112.36,95.23 113.09,95.96
  GND4 w0.089: v9(110.1,94.41) 110.1,94.48 v4(109.86,94.72)
  BOTTOM w0.152: v9(110.1,94.41) 109.56,93.86 108.66,93.86 107.07,92.27 107.07,91.85 107.73,91.19 107.73,90.66 107.94,90.44 111.16,90.44 113.05,88.55 JXDP2.22
CFG_RCOMP: length 4.1
  TOP w0.305: RC151.1 118.5,94.37 118.5,95.04 118.83,95.37 118.83,96.15 118.5,96.48 118.5,96.86 118.76,97.13 118.9,97.13 UC1.A54
CHG_BTS_C: length 1.3
  TOP w0.508: PC423.1 PR406.2
CHG_LED#: length 33.6
  TOP w0.119: v2(229.36,134.97) 230.83,134.97 231.72,135.86 231.72,136.11 231.53,136.3 231.53,137.24 232.53,138.25 233.23,138.25 233.58,138.6 238.12,138.6 v1(239.19,139.67) ; v1(246.81,139.7) 246.4,139.29 Q341.2
  IN1 w0.089: v1(246.81,139.7) 246.58,139.92 239.44,139.92 v1(239.19,139.67)
  IN2 w0.084: v2(233.81,125.75) 233.63,125.75 233.54,125.84 233.54,128 232.54,129 232.54,130.23 231.38,131.39 230.56,131.39 229.49,132.46 229.49,134.83 v2(229.36,134.97)
CHG_LED#_R: length 5.6
  TOP w0.119: JPB1.5 250.19,140.85 250.07,140.72 249.45,140.72 249,140.28 v13(248.76,140.28) 248.32,140.72 248,140.72 247.69,141.03 C1427.1 246.42,141.12 R1104.2
CHG_LGATE: length 8.5
  IN3 w1.016: 59.52,117.99 58.15,119.36 58.15,125.89
  vias: v7(58.15,127.36) v7(58.13,126.79) v7(59.57,117.04) v7(60.13,117.03)
CHG_PMIC_SMBCLK: length 255.2
  TOP w0.119: v2(163.71,113.5) 163.8,113.41 163.8,113.04 164.09,112.75 PR712.1
  IN1 w0.089: v3(236.09,123.43) 235.87,123.43 235.69,123.25 v1(235.31,123.25)
  IN2 w0.084: v2(50.2,126.14) 51.07,126.14 v4(51.47,126.54) ; v4(162.17,113.53) 163.67,113.53 v2(163.71,113.5) ; v4(141.06,127.11) 141.06,127.02 141.27,126.8 142.18,126.8 142.97,126.02 145.94,126.02 146.86,126.94 146.86,127.31 147.48,127.93 149.98,127.93 150.16,128.11 153.05,128.11 154.03,127.13 158.89,127.13 159.87,128.11 v4(160.08,128.11) 160.09,128.13 160.09,128.3 160.47,128.68 161.13,128.68 161.22,128.58 161.93,128.58 162.07,128.72 167.22,128.72 167.32,128.83 171.32,128.83 172.35,127.79 176.41,127.79 176.82,128.2 177.42,128.2 177.83,127.79 177.83,126.23 180.38,123.67 184.99,123.67 185.61,124.28 188.95,124.28 191.16,126.49 191.16,129.84 192.92,131.6 193.88,131.6 196.16,133.87 196.16,134.69 197.5,136.03 201.31,136.03 205.14,139.86 206.74,139.86 207.3,139.29 213.16,139.29 214.16,140.29 216.56,140.29 216.75,140.11 220.1,140.11 220.51,140.53 226.39,140.53 226.65,140.27 228.11,140.27 v4(228.19,140.35) ; v4(236.18,123.81) 236.09,123.72 v3(236.09,123.43)
  IN3 w0.084: v4(141.06,127.11) 140.64,127.11 139.78,126.25 137.01,126.25 134.54,123.77 134.54,120.4 134.32,120.18 126.66,120.18 125.82,121.03 125.82,125.27 121.82,129.26 121.67,129.26 119.83,131.1 116.29,131.1 115.9,130.71 115.31,130.71 114.09,131.93 109.97,131.93 109.28,132.62 106.92,132.62 106.01,133.52 104.58,133.52 104.43,133.67 101.83,133.67 100.32,132.16 99.64,132.16 99.42,131.93 95.9,131.93 95.78,132.05 94.99,132.05 94.44,132.6 86.2,132.6 85.19,133.62 78.3,133.62 76.51,131.83 58.84,131.83 57.18,130.16 53.63,130.16 51.86,128.4 51.86,126.94 v4(51.47,126.54) ; v4(162.17,113.53) 162.17,114.56 161.77,114.96 161.32,114.96 160.82,115.46 160.82,119.99 160.38,120.43 160.38,123.41 160.92,123.95 160.92,125.69 159.62,126.98 159.62,127.66 v4(160.08,128.11) ; v4(236.18,123.81) 236.18,123.99 234.85,125.31 234.85,127.16 235.25,127.55 235.25,129.87 234.11,131.01 234.11,137.16 230.91,140.35 v4(228.19,140.35)
CHG_PMIC_SMBDAT: length 245.8
  TOP w0.119: v7(164.22,112.15) 164.93,112.15 PR713.1
  GND1 w0.119: v4(235.16,123.43) 234.98,123.25 v10(234.81,123.25)
  IN2 w0.084: v4(228.11,140.85) 227.71,140.45 226.73,140.45 226.46,140.72 220.04,140.72 219.62,140.3 216.82,140.3 216.64,140.48 214.08,140.48 213.77,140.17 205.19,140.17 201.24,136.22 197.42,136.22 195.97,134.77 195.97,133.95 193.81,131.78 192.84,131.78 190.97,129.91 190.97,126.57 188.87,124.47 185.53,124.47 184.91,123.85 180.46,123.85 178.01,126.3 178.01,127.87 177.49,128.39 176.74,128.39 176.33,127.98 172.42,127.98 171.39,129.01 167.24,129.01 167.14,128.9 161.76,128.9 v4(161.73,128.94) 161.65,128.86 160.31,128.86 158.76,127.32 154.1,127.32 153.12,128.3 150.06,128.3 149.88,128.12 147.41,128.12 146.68,127.39 146.68,127.02 145.95,126.28 142.96,126.28 142.25,127 141.85,127 v4(141.52,127.32) ; v2(50.2,127.03) 50.31,127.15 51.24,127.15 v4(51.52,127.43)
  IN3 w0.084: v4(51.52,127.43) 51.52,128.32 53.55,130.35 57.1,130.35 58.76,132.01 76.44,132.01 78.23,133.8 85.27,133.8 86.1,132.96 92.65,132.96 93.15,133.46 95.41,133.46 96.7,132.17 99.39,132.17 99.57,132.35 100.25,132.35 101.75,133.85 101.81,133.85 101.81,133.85 104.51,133.85 104.66,133.7 106.09,133.7 106.99,132.8 109.36,132.8 110.05,132.11 114.17,132.11 115.39,130.89 115.82,130.89 116.21,131.28 119.91,131.28 121.75,129.44 121.9,129.44 123.33,128.02 124.01,128.02 124.66,127.37 133.25,127.37 133.76,127.87 139.65,127.87 140.07,127.45 141.39,127.45 v4(141.52,127.32) ; v4(228.11,140.85) 227.84,140.58 227.84,140.2 228.2,139.85 228.2,139.48 228.69,138.99 230.86,138.99 232.36,137.5 232.36,134.99 233.21,134.13 233.21,133.38 233.9,132.69 233.9,130.73 234.3,130.34 234.3,128.74 234.85,128.18 234.85,127.59 234.66,127.4 234.66,125.22 235.4,124.48 235.4,123.67 v4(235.16,123.43) ; v4(161.73,128.94) 161.93,128.74 161.93,126.37 164.19,124.11 164.19,123.48 163.97,123.25 163.97,122.67 163,121.7 163,119.13 163.46,118.67 163.46,118.22 162.89,117.65 162.89,114.87 163.48,114.28 163.48,113.6 164.22,112.86 v7(164.22,112.15)
CHG_SW: length 20.4
  BOTTOM w1.016: 59.67,130.06 60.43,129.29 60.43,123.86 58.4,121.83 58.4,111.41 58.53,111.29 v7(58.91,111.29)
  vias: v7(58.12,129.8) v7(58.27,111.29) v7(58.71,129.8)
CHG_UGATE: length 10.6
  BOTTOM w1.016: 55.66,118.42 56.11,118.88 56.11,122.46 59.04,125.38 59.04,127.67
  vias: v7(55.51,117.18) v7(55.5,116.62) v7(58.03,128.89) v7(58.63,128.9)
CHRGR_VIN: length 3.6
  IN2 w0.254: v2(54.53,134.22) v2(50.97,134.22)
  vias: v2(43.96,116.66) v2(43.96,116.34) v2(44.32,116.67) v2(44.32,116.35) v2(44.32,116.04) v2(44.63,116.67) v2(44.63,116.35) v2(44.63,116.04) v2(44.94,116.66) v2(44.94,116.34) v2(44.94,116.02) v2(46.36,124.44) v2(46.62,122.74) v2(49.87,115.63) v2(49.87,115.25) v2(49.88,114.87) v2(50.27,115.64) v2(50.26,115.26) v2(50.26,114.91) v2(50.64,114.22) v2(51.61,114.19) v2(55.75,136.66) v2(55.76,137.1) v2(55.99,136.88) v7(11.54,59.23) v7(11.54,58.59) v7(12.12,59.23) v7(12.12,58.59) v7(12.68,59.24) v7(12.68,58.61) v7(13.32,59.24) v7(13.32,58.61) v7(27.53,58.04) v7(27.53,57.41) v7(27.53,56.82) v7(27.53,56.24) v7(28.16,58.04) v7(28.16,57.41) v7(28.16,56.82) v7(28.16,56.24) v7(54.48,109.7) v7(54.48,108.99) v7(55.04,108.63) v7(55.09,110.03) v7(55.06,109.34) v7(68.33,141.92) v7(68.33,141.26) v7(68.33,140.62) v7(71.53,141.79) v7(71.53,141.18) v7(71.53,140.5) v14(23.32,60.71)
CK_XDP: length 27.4
  IN2 w0.06: 125.39,96.43 125.36,96.47 125.36,97.49 125.63,97.76 125.63,98.51 125.78,98.66 125.78,98.91 125.78,98.91 v2(125.78,99.07)
  IN2 w0.084: v4(120,87.44) 120.2,87.64 120.57,87.64 121.07,88.14 124.51,88.14 127.44,91.07 127.44,91.69 128.01,92.26 128.01,93.12 125.75,95.38 125.55,95.58 125.55,96.27 125.39,96.43
  IN3 w0.084: v4(120,87.44) 120,87.49 120.21,87.7 120.35,87.7 120.43,87.62 120.43,86.06 121.28,85.21 121.28,84.11 121.04,83.87 118.04,83.87 117.82,83.65 117.82,83.3 117.71,83.19 117.62,83.19 v6(117.47,83.35)
CK_XDP#: length 27.5
  IN2 w0.06: 125.29,96.3 125.24,96.36 125.24,97.53 125.51,97.81 125.51,98.56 125.66,98.71 125.66,98.91 125.58,98.99 125.58,99.16 125.78,99.36 v2(125.78,99.57)
  IN2 w0.084: 125.29,96.3 125.39,96.2 125.39,95.51 127.85,93.05 127.85,92.33 127.28,91.75 127.28,91.14 124.44,88.3 121,88.3 120.51,87.81 120.16,87.81 v4(120,87.97)
  IN3 w0.084: v4(120,87.97) 120.11,87.86 120.42,87.86 120.59,87.69 120.59,86.13 121.44,85.28 121.44,84.04 121.1,83.7 118.11,83.7 117.98,83.58 117.98,83.42 118.05,83.35 v6(118.1,83.35)
CL_CLK: length 144.8
  IN1 w0.06: 135.55,95.09 135.07,95.58 134.83,95.58 134.37,96.03 134.37,96.38 133.11,97.65 132.86,97.65 132.55,97.96 132.55,98.05 132.35,98.25 132.35,98.42 132.37,98.44 132.37,98.44 132.43,98.5 132.43,98.71 v1(132.55,98.83)
  IN1 w0.089: 135.55,95.09 136.19,95.09 138.23,93.05 138.23,92.48 138.45,92.26 139.41,92.26 139.85,92.7 144.03,92.7 144.63,92.1 146.74,92.1 147.13,92.49 151.11,92.49 151.47,92.85 152.09,92.85 152.84,92.09 154.8,92.09 155.03,91.86 159.03,91.86 159.25,91.65 161.26,91.65 162.18,90.74 164.64,90.74 165.39,89.99 166.57,88.81 166.93,88.81 167.31,88.43 171.63,88.43 171.77,88.57 187.68,88.57 189.21,90.1 190.99,90.1 191.34,90.46 195.7,90.46 198.43,93.19 198.43,98.08 199,98.65 199,104.75 202.39,108.14 204.97,108.14 210.14,113.3 210.4,113.3 213.57,116.48 215.34,116.48 215.89,117.03 216.86,117.03 217.51,117.69 222.36,117.69 222.81,117.24 224.75,117.24 225.54,116.46 232.28,116.46 233.67,115.06 238.56,115.06 241.81,118.31 243.01,118.31 243.28,118.58 v3(243.28,118.58)
  IN2 w0.084: v3(243.28,118.58) 243.89,117.97 246.77,117.97 247.42,118.62 JNGFF3.34
CL_DATA: length 143.1
  IN1 w0.06: v1(132.55,98.34) 132.67,98.21 132.67,98.01 132.91,97.77 133.16,97.77 134.49,96.43 134.49,96.13 134.82,95.8 135.11,95.8 135.62,95.29 135.75,95.29
  IN1 w0.089: 135.75,95.29 136.4,95.29 137.71,93.98 137.71,93.84 138.42,93.13 138.42,92.58 138.54,92.46 139.35,92.46 139.77,92.89 145.94,92.89 146.4,92.43 146.8,92.43 147.05,92.68 151,92.68 151.43,93.11 153.7,93.11 153.81,93 154.46,93 154.8,92.66 157.86,92.66 157.97,92.78 160.41,92.78 162.24,90.94 164.71,90.94 165.47,90.18 166.65,89 167.01,89 167.39,88.62 171.55,88.62 171.69,88.76 187.49,88.76 189.02,90.29 190.91,90.29 191.27,90.65 195.62,90.65 198.2,93.23 198.2,98.12 198.81,98.73 198.81,104.83 202.31,108.33 204.9,108.33 210.06,113.5 210.32,113.5 213.49,116.67 215.26,116.67 215.81,117.22 216.78,117.22 217.43,117.88 222.44,117.88 222.89,117.43 224.83,117.43 225.62,116.65 232.38,116.65 233.77,115.25 235.43,115.25 237.12,116.94 237.76,116.94 238.89,118.07 241.03,118.07 241.55,118.59 v3(242.86,118.59)
  IN2 w0.084: JNGFF3.32 247.41,118.12 247.07,117.79 243.66,117.79 v3(242.86,118.59)
CL_RST#: length 158.7
  TOP w0.089: UC1.B12 132.55,96.89 v1(132.49,96.83)
  IN1 w0.06: 134.14,95.03 134.14,95.11 132.58,96.67 132.58,96.75 v1(132.49,96.83)
  IN1 w0.076: JNGFF3.30 248,117.62
  IN1 w0.089: 248,117.62 247.76,117.38 247.76,115.22 245.57,113.04 245.57,111.84 243.96,110.23 241.01,110.23 v3(240.72,110.52) ; v3(165.8,88.35) 164.36,89.8 163.99,89.8 163.25,90.53 162.11,90.53 161.2,91.45 159.18,91.45 158.95,91.67 154.95,91.67 154.72,91.9 152.66,91.9 151.97,92.6 151.51,92.6 151.21,92.3 147.21,92.3 146.82,91.91 144.55,91.91 143.95,92.51 139.93,92.51 139.49,92.07 137.99,92.07 137.64,92.43 137.64,93.11 137.5,93.25 137.21,93.25 136.9,92.94 136.9,92.55 136.23,91.88 134.85,91.88 134.24,92.49 134.24,93.58 134.14,93.68 134.14,95.03
  IN2 w0.084: v3(240.72,110.52) 240.6,110.65 236.97,110.65 235.64,109.32 232.94,109.32 231.02,111.24 231.02,112.53 230.03,113.52 219.15,113.52 218.7,113.06 218.7,110.21 216.51,108.03 211.98,108.03 211.19,108.82 207.44,108.82 206.39,107.77 202.92,107.77 202.21,107.06 200.26,107.06 198.26,105.07 198.26,102.84 199.1,102 199.1,97.83 199.51,97.42 199.51,89.82 198.03,88.34 191.96,88.34 190.39,86.78 183.61,86.78 183.35,86.51 168.71,86.51 167.71,87.51 166.64,87.51 v3(165.8,88.35)
CLK_LPC_DEBUG: length 114.1
  TOP w0.152: v1(215.56,112.08) 215.26,111.78 JLPDE1.10
  IN1 w0.089: v3(216.38,114.37) 216.5,114.25 216.5,113.02 v1(215.56,112.08)
  IN2 w0.084: v4(215.21,115.5) 215.25,115.5 v3(216.38,114.37) ; v4(212.25,132.17) 210.32,132.17 209.25,131.1 208.31,131.1 206.7,129.49 202.28,129.49 202.09,129.3 199.4,129.3 198.38,128.28 198.38,127.8 197.56,126.98 196.65,126.98 190.19,120.53 189.95,120.53 189.12,119.71 185.17,119.71 184.83,120.05 179.08,120.05 174.19,115.16 172.96,115.16 170.84,113.04 166.62,113.04 165.34,114.32 162.22,114.32 161.55,113.65 158.83,113.65 158.48,114 154.72,114 149.41,119.31 145.02,119.31 143.29,117.58 143.29,116.92 v4(142.88,116.52)
  IN3 w0.084: v4(142.88,116.52) 141.56,115.2 141.56,112.8 142.25,112.11 142.25,111.29 141.81,110.85 141.81,110.66 v6(141.55,110.4) ; v4(215.21,115.5) 215.21,116.48 214.35,117.34 214.35,119.23 213.48,120.1 213.48,123.25 213.19,123.54 213.19,125.23 212.84,125.58 212.84,128.29 212.97,128.42 212.97,131.8 212.6,132.17 v4(212.25,132.17)
  BOTTOM w0.152: v6(141.55,110.4) 141.46,110.49 141.31,110.49 141.15,110.64 141.11,110.64 RH12.2
CLK_PCI_MEC: length 122.7
  TOP w0.152: v2(228.71,124.42) 228.71,124.24 R180.1 228.5,123.66 229.32,124.47 229.59,124.47 U27.N6
  IN2 w0.084: v2(228.71,124.42) 229.14,123.99 230.92,123.99 231.04,123.86 231.04,123.58 231.2,123.43 231.43,123.43 231.55,123.55 231.55,124.16 231.58,124.19 231.58,124.85 231.25,125.18 230.55,125.18 229.64,126.09 229.64,127.17 227.95,128.86 226.79,128.86 223.76,131.89 213.53,131.89 212.79,132.63 210.13,132.63 209.13,131.63 207.78,131.63 206.1,129.95 202.09,129.95 201.9,129.76 199.21,129.76 197.92,128.47 197.92,127.99 197.37,127.45 195.88,127.45 195.23,126.8 195.16,126.8 190.56,122.2 187.08,122.2 186.82,121.94 186.82,121.04 186.09,120.3 185.3,120.3 185.08,120.52 178.89,120.52 175.47,117.09 173.95,117.09 173.64,116.78 173.64,116.61 170.54,113.51 166.81,113.51 166.41,113.91 166.41,114.81 165.03,116.18 165.03,116.39 164.93,116.49 164.93,117.75 163.41,119.27 163.04,119.27 162.59,119.72 161.93,119.72 160.97,118.75 151.26,118.75 149.31,120.71 148.19,120.71 147.5,120.02 145.07,120.02 143.39,118.35 143.39,118.35 142.78,117.74 142.78,117.08 142.2,116.49 v4(142.17,116.49)
  IN3 w0.084: v6(140.79,112.81) 141.05,113.08 141.05,115.64 141.9,116.49 v4(142.17,116.49)
  BOTTOM w0.152: RH11.2 v6(140.79,112.81)
CLK_PCIE2: length 132.8
  TOP w0.152: v2(30.88,75.97) 30.89,75.99 30.89,76.27 31.23,76.61 31.5,76.61 31.6,76.7 31.6,76.83 31.36,77.06 LR1.1 31.36,77.57 RR16.1
  IN2 w0.06: v2(125.14,99.07) 125.06,99.07 125.01,99.02 125.01,98.91 125.08,98.83 125.16,98.83 125.23,98.76 125.23,97.98 124.92,97.66 124.92,96.18 124.99,96.1 124.99,96.03 124.98,96.01
  IN2 w0.084: 124.98,96.01 124.98,95.23 127.33,92.88 127.33,92.61 126.87,92.15 126.87,91.51 125.19,89.84 123.54,89.84 123.38,89.68 123.38,89.47 123.31,89.4 v2(123.01,89.4) 123.01,89.3 123.14,89.17 123.24,89.17 123.37,89.05 123.37,88.95 123.2,88.78 122.32,88.78 121.98,89.12 119.79,89.12 119.58,88.92 118.89,88.92 118.14,88.17 118.14,87.21 117.67,86.73 107.93,86.73 107.66,86.47 103,86.47 102.26,87.22 98.06,87.22 97.96,87.31 87.32,87.31 86.85,87.77 76.89,87.77 76.59,88.07 65.28,88.07 61.92,91.43 61.47,91.43 59.56,93.34 51.48,93.34 49.97,94.85 43.88,94.85 43.53,95.2 41.75,95.2 41.56,95.01 39.43,95.01 39,95.45 37.81,95.45 34.7,92.34 33.02,92.34 31.49,90.8 31.49,88.16 30.68,87.35 30.68,81 29.59,79.91 29.59,78.4 30.98,77.01 30.98,76.08 v2(30.88,75.97)
CLK_PCIE2#: length 133.2
  TOP w0.152: RR17.1 32.16,77.57 LR1.4 32.16,77.07 31.93,76.84 31.93,76.56 31.64,76.27 31.37,76.27 31.23,76.13 31.23,76.01 v2(31.26,75.97)
  IN2 w0.06: 125.14,96.05 125.11,96.08 125.11,96.15 125.04,96.23 125.04,97.61 125.35,97.93 125.35,99.39 125.17,99.57 v2(125.14,99.57)
  IN2 w0.084: v2(31.26,75.97) 31.15,76.09 31.15,77.07 29.75,78.47 29.75,79.84 30.85,80.94 30.85,87.29 31.65,88.1 31.65,90.74 33.09,92.17 34.77,92.17 37.88,95.28 38.93,95.28 39.36,94.85 41.63,94.85 41.82,95.04 43.46,95.04 43.82,94.69 49.9,94.69 51.41,93.18 59.49,93.18 61.4,91.27 61.86,91.27 65.21,87.91 76.52,87.91 76.82,87.61 86.78,87.61 87.25,87.15 97.9,87.15 97.99,87.05 102.19,87.05 102.94,86.31 107.73,86.31 107.99,86.57 117.74,86.57 118.3,87.14 118.3,88.11 118.95,88.76 119.65,88.76 119.85,88.96 121.91,88.96 122.26,88.62 123.27,88.62 123.53,88.88 123.53,89.06 123.66,89.19 123.77,89.19 123.9,89.32 v2(123.9,89.4) 123.61,89.4 123.54,89.47 123.54,89.61 123.6,89.67 125.26,89.67 127.03,91.44 127.03,92.09 127.49,92.54 127.49,92.95 125.14,95.3 125.14,96.05
CLK_PCIE2#_R: length 3.6
  TOP w0.152: RR17.2 32.16,78.83 LR1.3 32.16,79.34 32.11,79.39 32.11,79.73 31.66,80.17 UR1.6
CLK_PCIE2_R: length 3.4
  TOP w0.152: RR16.2 31.36,78.83 LR1.2 31.68,79.05 31.77,79.14 31.77,79.59 31.52,79.84 30.36,79.84 30.29,79.77 UR1.5
CLK_PCIE3: length 106.2
  TOP w0.152: v10(194.33,100.28) L25.4 194.77,100.28 R1095.1 ; C269.1 124.85,92.53 v2(124.85,92.11)
  GND1 w0.089: v4(195,100.06) 194.78,100.28 v10(194.33,100.28)
  IN2 w0.06: 124.43,94.62 124.42,94.63 124.42,97.87 124.46,97.91 124.46,98.66 124.5,98.7 v2(124.5,99.07)
  IN2 w0.084: v2(124.85,92.11) 125.04,91.92 125.04,91.84 v4(124.89,91.69) 124.92,91.69 125.09,91.52 125.09,91.39 125,91.29 124.28,91.29 124.05,91.52 124.05,92.2 124.69,92.85 124.69,94.36 124.63,94.42 124.43,94.62
  IN3 w0.084: v4(124.89,91.69) 125.23,91.34 125.23,91.18 126.48,89.93 126.55,89.93 127.31,89.17 133.48,89.17 134.18,88.47 137.98,88.47 138.52,89 138.8,89 139.47,89.66 146.06,89.66 148.86,92.47 150.55,92.47 150.97,92.89 155.18,92.89 155.9,93.61 159.75,93.61 160.08,93.94 162.96,93.94 164.87,95.84 165.31,95.84 168.41,98.94 174.17,98.94 174.63,99.4 178.06,99.4 184.22,93.24 184.22,92.27 186.91,89.58 193.44,89.58 195.72,91.86 195.72,92.32 198.29,94.89 198.29,98.63 197.1,99.81 195.23,99.81 195,100.04 v4(195,100.06)
CLK_PCIE3#: length 106.2
  TOP w0.152: v2(125.41,92.13) 125.58,92.31 C268.1 ; v10(194.33,99.43) L25.1 194.77,99.43 R1096.1
  GND1 w0.089: v10(194.33,99.43) 194.88,99.43 v4(195,99.55)
  IN2 w0.06: 124.3,94.54 124.3,94.55 124.3,94.56 124.3,94.56 124.3,97.92 124.34,97.96 124.34,98.71 124.38,98.75 124.38,98.91 124.3,98.99 124.3,99.16 124.5,99.36 v2(124.5,99.57)
  IN2 w0.084: v2(125.41,92.13) 125.2,91.93 125.2,91.88 v4(125.39,91.69) 125.25,91.55 125.25,91.32 125.06,91.13 124.21,91.13 123.88,91.45 123.88,92.26 124.53,92.91 124.53,94.28 124.3,94.51 124.3,94.54
  IN3 w0.084: v4(125.39,91.69) 125.39,91.25 126.55,90.09 126.62,90.09 127.38,89.33 133.54,89.33 134.25,88.63 137.91,88.63 138.45,89.16 138.74,89.16 139.4,89.82 145.99,89.82 148.79,92.63 150.48,92.63 150.9,93.05 155.12,93.05 155.84,93.77 159.68,93.77 160.01,94.1 162.89,94.1 164.8,96 165.24,96 168.34,99.1 174.11,99.1 174.56,99.56 178.13,99.56 184.38,93.3 184.38,92.34 186.98,89.75 193.38,89.75 195.56,91.93 195.56,92.39 198.13,94.95 198.13,98.56 197.03,99.65 195.1,99.65 v4(195,99.55)
CLK_PCIE3#_R: length 5.9
  TOP w0.152: R1096.2 195.85,99.43 L25.2 v2(196.28,99.43) ; JNGFF2.53 v2(199.04,96.73)
  IN2 w0.084: v2(199.04,96.73) 199.04,96.76 198.9,96.9 198.62,96.9 197.48,98.04 197.48,99.37 197.08,99.77 196.37,99.77 196.28,99.69 v2(196.28,99.43)
CLK_PCIE3_R: length 5.9
  TOP w0.152: R1095.2 195.85,100.28 L25.3 v2(196.28,100.28) ; JNGFF2.55 v2(199.04,97.23)
  IN2 w0.084: v2(196.28,100.28) 196.28,100.02 196.37,99.94 197.14,99.94 197.64,99.44 197.64,98.1 198.69,97.06 198.87,97.06 v2(199.04,97.23)
CLK_PCIE4: length 163.9
  TOP w0.152: R1098.1 239.51,120.6 v2(239.1,120.6)
  IN2 w0.06: v2(124.82,98.83) 124.78,98.83 124.74,98.79 124.74,98.67 124.8,98.6 124.8,97.85 124.75,97.8 124.75,96.02 124.79,95.99
  IN2 w0.084: v4(240.18,120.6) 239.87,120.91 239.41,120.91 v2(239.1,120.6) ; v4(124.72,90.2) 124.72,90.26 124.87,90.41 125.21,90.41 126,91.2 126,93.66 124.79,94.86 124.79,95.99
  IN3 w0.084: v4(240.18,120.6) 240.18,120.78 240.01,120.95 239.82,120.95 239.73,120.86 239.73,119.99 240.43,119.29 240.43,118.19 239.84,117.6 238.59,117.6 234.8,113.8 219.1,113.8 211.95,106.65 201.5,106.65 201.3,106.45 199.72,106.45 198.71,105.44 198.71,102.7 199.45,101.96 199.45,99.58 199.3,99.43 199.3,90.65 197.14,88.48 186.35,88.48 183.05,91.77 183.05,92.91 178.14,97.82 176.21,97.82 175.91,98.12 168.91,98.12 166.34,95.55 166.34,94.92 163.98,92.56 160.98,92.56 159.99,91.57 150.01,91.57 147.76,89.31 146.55,89.31 146.29,89.05 139.65,89.05 139.04,88.44 138.78,88.44 138.25,87.91 133.45,87.91 132.69,88.67 126.43,88.67 125.56,89.54 125.56,89.94 125.08,90.42 124.9,90.42 124.72,90.23 v4(124.72,90.2)
CLK_PCIE4#: length 164
  TOP w0.152: v2(239.1,121.4) 239.51,121.4 R1097.1
  IN2 w0.06: 124.63,95.96 124.63,95.97 124.63,95.98 124.63,97.85 124.68,97.9 124.68,98.55 124.62,98.62 124.62,98.91 124.69,98.99 124.7,98.99 124.7,99.16 124.69,99.16 124.69,99.2 v2(124.82,99.32)
  IN2 w0.084: v4(124.72,90.72) 124.87,90.57 125.14,90.57 125.83,91.27 125.83,93.59 124.63,94.8 124.63,95.96 ; v4(240.23,121.4) 239.91,121.07 239.42,121.07 v2(239.1,121.4)
  IN3 w0.084: v4(124.72,90.72) 124.87,90.58 125.15,90.58 125.72,90 125.72,89.61 126.5,88.83 132.76,88.83 133.52,88.07 138.18,88.07 138.71,88.6 138.97,88.6 139.59,89.22 146.22,89.22 146.48,89.48 147.69,89.48 149.94,91.73 159.92,91.73 160.91,92.72 163.91,92.72 166.18,94.98 166.18,95.62 168.84,98.28 175.98,98.28 176.27,97.99 178.2,97.99 183.22,92.97 183.22,91.84 186.42,88.64 197.07,88.64 199.14,90.71 199.14,99.5 199.28,99.64 199.28,101.9 198.55,102.63 198.55,105.51 199.65,106.61 201.24,106.61 201.44,106.81 211.88,106.81 219.03,113.97 234.73,113.97 238.53,117.76 239.77,117.76 240.26,118.26 240.26,119.22 239.56,119.92 239.56,120.93 239.75,121.11 239.98,121.11 240.23,121.36 v4(240.23,121.4)
CLK_PCIE4#_R: length 6.5
  TOP w0.152: v2(241.08,121.4) 240.64,121.4 R1097.2
  IN2 w0.084: v2(246.39,120.37) 246.19,120.18 243.2,120.18 242.29,121.08 241.4,121.08 v2(241.08,121.4)
CLK_PCIE4_R: length 6.5
  TOP w0.152: R1098.2 240.64,120.6 v2(241.08,120.6)
  IN2 w0.084: v2(246.39,119.87) 246.25,120.01 243.13,120.01 242.22,120.92 241.4,120.92 v2(241.08,120.6)
CLK_PCIE5: length 123.1
  TOP w0.152: v1(16.14,97.98) 16.14,98.43 R1100.1
  IN1 w0.089: v3(26.19,95.16) 26.13,95.22 25.91,95.22 25.69,95.45 25.69,96.41 25.37,96.73 16.97,96.73 16.43,97.27 16.43,97.6 16.43,97.69 v1(16.14,97.98)
  IN2 w0.06: 124.03,94.9 124.07,94.94 124.07,97.49 124.13,97.55 124.13,98.62 124.09,98.65 124.09,98.75 v2(124.17,98.83)
  IN2 w0.084: v3(26.19,95.16) 26.29,95.26 30.09,95.26 30.48,94.86 34.3,94.86 35.39,95.96 50.27,95.96 51.85,94.38 60.09,94.38 61.58,92.9 61.88,92.9 66.05,88.73 76.36,88.73 76.88,89.25 86.64,89.25 87.79,88.1 98.16,88.1 98.45,87.82 102.39,87.82 102.85,87.36 107.05,87.36 107.36,87.67 112.97,87.67 113.16,87.87 116.16,87.87 117.43,89.14 118.16,89.14 118.44,89.41 118.85,89.41 119.39,89.95 120.47,89.95 123.18,92.66 123.18,94.05 124.03,94.9
CLK_PCIE5#: length 123
  TOP w0.152: v1(16.94,97.98) 16.94,98.43 R1099.1
  IN1 w0.089: v1(16.94,97.98) 16.65,97.68 16.65,97.36 17.06,96.95 25.46,96.95 25.9,96.5 25.9,95.54 26,95.44 26.08,95.44 v3(26.19,95.55)
  IN2 w0.06: 123.9,95 123.95,95.05 123.95,97.54 124.01,97.6 124.01,98.57 123.97,98.6 123.97,98.91 124.17,99.11 v2(124.17,99.32)
  IN2 w0.084: 123.9,95 123.02,94.12 123.02,94.12 123.02,94.12 123.02,92.73 120.4,90.11 119.32,90.11 118.78,89.58 118.37,89.58 118.1,89.3 117.36,89.3 116.09,88.03 113.1,88.03 112.9,87.83 107.3,87.83 106.99,87.52 102.92,87.52 102.46,87.98 98.51,87.98 98.23,88.27 87.86,88.27 86.71,89.42 76.81,89.42 76.29,88.89 66.11,88.89 61.95,93.06 61.64,93.06 60.16,94.55 51.91,94.55 50.34,96.12 35.32,96.12 34.23,95.03 30.55,95.03 30.15,95.42 26.31,95.42 v3(26.19,95.55)
CLK_PCIE5#_R: length 5.7
  TOP w0.152: R1099.2 16.94,99.56 16.94,100.14 16.75,100.33 16.75,100.52 16.83,100.61 19.3,100.61 19.67,100.99 19.67,101.36 19.8,101.49 JNGFF1.45
CLK_PCIE5_R: length 5.7
  TOP w0.152: R1100.2 16.14,99.56 16.14,100.12 16.41,100.39 16.41,100.66 16.69,100.95 19.16,100.95 19.34,101.13 19.34,101.45 19.3,101.49 JNGFF1.47
CLK_REQ2#: length 180.2
  TOP w0.119: RH30.2 140.54,114.21 140.17,114.21 v10(140.07,114.31) ; UR1.2 30.25,78.57 30.47,78.35 30.47,76.59 30.33,76.45 30.33,75.8 30.75,75.38 34.49,75.38 v1(34.73,75.62)
  IN1 w0.06: 139.81,114.31 139.75,114.31 139.47,114.03 138.97,114.03 137.78,112.84 137.04,112.84 136.91,112.98 134.41,112.98 133.8,112.36 133.8,112.11 133.65,111.96 133.65,111.62 133.44,111.41 133.44,111.34 133.31,111.2 133.25,111.2 133.23,111.2 133.22,111.2 133.16,111.16 133.08,111.09 133.08,110.92 133.17,110.82 v1(133.17,110.26)
  IN1 w0.089: v5(102.47,126.02) 102.11,125.65 102.11,122.97 98.28,119.14 98.28,111.46 97.84,111.02 97.84,105.68 97.03,104.88 97.03,100.26 94.7,97.92 94.7,96.69 94.28,96.27 94.28,92 90.02,87.75 63.8,87.75 63.36,87.31 56.99,87.31 56.79,87.51 51.55,87.51 50.18,88.88 50.18,91.98 49.61,92.55 46.13,92.55 45.36,91.79 45.36,87.17 43.5,85.3 40.91,85.3 40.25,84.64 39.33,84.64 35.79,81.1 35.79,76.69 34.87,75.77 34.87,75.76 v1(34.73,75.62) ; 139.81,114.31 v10(140.07,114.31)
  GND1 w0.119: v4(102.7,126.4) 102.47,126.17 v5(102.47,126.02) ; v4(140.48,114.39) 140.14,114.39 v10(140.07,114.31)
  GND3 w0.119: v4(102.7,126.4) 102.7,126.32 103.4,125.62 112.64,125.62 113.66,124.6 117.52,124.6 118.75,123.37 119.8,123.37 122.4,120.77 122.4,119.41 123.32,118.49 129,118.49 129.47,118.95 138.88,118.95 v4(139.26,118.58)
  IN3 w0.076: v4(140.48,114.39) 140.47,114.4 140.47,116.47 139.26,117.67 v4(139.26,118.58)
CLK_REQ3#: length 79.2
  IN1 w0.06: v3(138.74,108.59) 138.56,108.42 138.28,108.42 138.02,108.15 137.82,108.15 137.78,108.11 136.93,108.11 136.72,108.33 135.42,108.33 135.3,108.45 134.82,108.45 134.8,108.47 134.67,108.6 134.46,108.6 v1(134.41,108.65)
  IN2 w0.06: 139.81,109.5 138.9,108.59 v3(138.74,108.59)
  IN2 w0.084: 139.81,109.5 139.86,109.55 140.91,109.55 141.45,110.1 141.9,110.1 142.04,109.97 143.68,109.97 143.81,110.1 144.85,110.1 146.08,108.87 146.89,108.87 v4(147.02,108.75) 147.28,108.48 147.28,108.37 150.64,105.01 151.16,105.01 151.9,104.28 152.77,104.28 153.01,104.03 158.94,104.03 159.69,103.28 164.31,103.28 165.61,104.57 167.9,104.57 168.22,104.89 171.93,104.89 172.65,105.61 177.45,105.61 178.01,105.06 181.27,105.06 v4(181.43,104.89)
  IN3 w0.084: v4(181.43,104.89) 182.43,103.89 183.81,103.89 187.64,100.07 187.64,99.68 189.08,98.23 190.73,98.23 v6(191.24,97.72)
  GND4 w0.119: v4(147.02,108.75) 147.03,108.73 v9(146.48,108.73)
  BOTTOM w0.119: JNGFF2.52 201.19,96.48 198.57,99.09 194.82,99.09 194.27,98.53 193.68,98.53 192.87,97.72 v6(191.24,97.72) ; v9(146.48,108.73) 145.55,109.66 RH33.2
CLK_REQ4#: length 138.2
  TOP w0.119: JNGFF3.45 247.16,121.37 247.39,121.14 v2(247.39,119.29)
  IN1 w0.06: v1(133.91,108.65) 134.12,108.65 134.42,108.36 134.42,108.28 134.57,108.13 134.74,108.13 134.82,108.21 135.2,108.21 135.64,107.77 136.38,107.77 136.52,107.63 136.77,107.63 136.83,107.69 138.1,107.69 v3(138.33,107.92)
  IN2 w0.084: v3(138.33,107.92) 138.77,108.36 139.93,108.36 140.95,109.38 141.77,109.38 142.17,109.78 143.76,109.78 143.89,109.91 144.78,109.91 146.2,108.49 146.67,108.49 v4(147.33,107.83) 147.56,107.83 150.49,104.9 150.49,104.62 151.02,104.09 152.69,104.09 152.93,103.85 158.86,103.85 159.61,103.09 164.39,103.09 165.69,104.39 167.98,104.39 168.3,104.7 172,104.7 172.73,105.43 177.38,105.43 178.26,104.55 181.58,104.55 182.06,105.04 186.04,105.04 186.9,105.89 188.52,105.89 189.45,106.82 189.45,108.06 196.36,114.97 196.36,115.33 198.7,117.67 199.77,117.67 200.28,118.18 208.6,118.18 209.72,117.06 211.13,117.06 213.54,119.48 215.96,119.48 216.64,120.16 223.7,120.16 225.25,118.62 226.06,118.62 227.47,117.2 231.64,117.2 231.87,116.97 232.37,116.97 233.41,115.93 235.5,115.93 235.98,116.42 235.98,117.09 237.34,118.45 239.52,118.45 240.51,119.44 246.31,119.44 246.55,119.19 247.3,119.19 v2(247.39,119.29)
  GND4 w0.119: v4(147.33,107.83) 147.3,107.86 v9(147.3,108.42)
  BOTTOM w0.119: v9(147.3,108.42) 147.3,109.61 146.4,110.51 RH35.2
CLK_REQ5#: length 179.7
  IN1 w0.06: v1(134.41,109.94) 134.47,110 135.21,110 135.38,109.84 136.71,109.84 137.14,109.41 137.92,109.41 v3(138.09,109.58)
  IN1 w0.089: JNGFF1.44 20.87,103.59 21.77,103.59 22.12,103.25 22.93,103.25 23.02,103.16 23.02,101.56 23.21,101.37 25.01,101.37 25.39,100.99 26.46,100.99 27.59,102.12 28.07,102.12 28.48,101.71 29.93,101.71 30.61,101.02 34.87,101.02 35.48,100.41 38.61,100.41 39.99,101.79 42.58,101.79 43.79,103 43.79,105.78 44.63,106.61 44.93,106.61 46.5,108.19 46.5,111.56 47.38,112.44 47.38,113.33 48.34,114.29 48.34,116.69 50.6,118.96 52.2,118.96 53.8,120.56 58.85,120.56 60.42,122.13 61.07,122.13 62.92,123.99 v3(62.92,124.72)
  IN2 w0.06: v3(138.09,109.58) 138.5,109.58 138.79,109.88 v4(138.79,110.19)
  IN2 w0.084: v3(62.92,124.72) 62.87,124.72 v4(62.59,125)
  IN3 w0.084: v4(138.79,110.19) 138.79,111.67 137.7,112.76 137.7,115.58 138.77,116.64 138.77,117.92 138.62,118.07 138.62,118.79 139.09,119.27 139.09,121.33 139.74,121.99 139.74,123.12 139.47,123.39 138.85,123.39 138.32,123.93 137.3,123.93 136.79,124.44 135.47,124.44 134.72,123.69 134.72,120.33 134.39,120 126.58,120 125.63,120.95 125.63,125.19 121.75,129.07 121.59,129.07 119.76,130.91 116.36,130.91 115.98,130.52 115.24,130.52 114.02,131.74 109.89,131.74 109.2,132.43 106.84,132.43 105.94,133.33 104.5,133.33 104.35,133.48 101.91,133.48 100.4,131.97 99.72,131.97 99.49,131.75 95.96,131.75 95.41,131.2 94.72,131.2 94.11,131.81 85.7,131.81 85.6,131.71 84.64,131.71 84.39,131.96 84.39,132.58 84.21,132.76 80.84,132.76 80.65,132.95 78.74,132.95 77.24,131.46 66.91,131.46 62.85,127.39 62.85,125.26 v4(62.59,125)
  GND4 w0.119: v4(138.79,110.19) 139.19,109.8 v9(139.34,109.8)
CLK_SMB: length 9.9
  TOP w0.119: JBAT100.4 153.55,91.86 154.2,92.5 v7(154.36,92.5) 154.51,92.65 157.98,92.65 158.51,93.19 PD100.2 159.01,93.33 159.01,94.27 158.93,94.34 158.93,94.78 159.11,94.95 159.11,95.56 PR121.1
CLK_XDP#_L: length 2.2
  BOTTOM w0.152: RC69.2 117.98,84.06 117.98,84.88 118.05,84.95 JXDP2.42
CLK_XDP_L: length 2.3
  BOTTOM w0.152: JXDP2.40 117.55,84.97 117.66,84.87 117.66,84.12 RC70.2
CLKOUT_LPC0: length 8.3
  IN1 w0.06: v5(138.37,113.87) 137.99,113.49 137.23,113.49 136.84,113.1 134.36,113.1 133.66,112.4 133.66,112.15 133.52,112.01 133.52,111.72 v1(133.19,111.4)
  GND1 w0.089: v5(138.37,113.87) 138.44,113.8 138.48,113.8 v4(138.69,113.59)
  IN3 w0.084: v6(138.96,112.81) 138.69,113.08 v4(138.69,113.59)
  BOTTOM w0.152: RH11.1 v6(138.96,112.81)
CLKOUT_LPC1: length 7.1
  IN1 w0.06: v5(140.1,110.43) 139.88,110.21 138.01,110.21 138,110.21 137.63,110.21 137.55,110.29 137.07,110.29 137.03,110.33 135.45,110.33 135.39,110.39 134.81,110.39 134.61,110.59 v1(134.41,110.59)
  GND1 w0.089: 140.12,110.3 v4(140.32,110.1)
  GND1 w0.102: 140.12,110.3 140.1,110.32 v5(140.1,110.43)
  GND4 w0.089: v9(140.91,110.26) 140.7,110.04 140.37,110.04 v4(140.32,110.1)
CLKRUN#: length 125.1
  IN1 w0.06: v1(132.87,111.15) 132.87,111.36 133.14,111.62 133.25,111.62 133.4,111.77 133.4,112.06 133.54,112.2 133.54,112.49 134.27,113.22 136.79,113.22 137.88,114.31 138.78,114.31 139.03,114.56 139.48,114.56 139.81,114.88
  IN1 w0.089: 139.81,114.88 140.58,114.88 140.76,115.06 141.85,115.06 142.44,115.65 143.07,115.65 143.28,115.86 143.82,115.86 143.87,115.81 145.61,115.81 v1(145.94,115.48) 146.37,115.04 146.37,114.76 146.65,114.49 147.13,114.49 149.41,112.2 149.41,111.51 149.99,110.93 152.24,110.93 153.07,110.1 161.36,110.1 162.48,108.99 162.48,107.7 163.2,106.98 165.86,106.98 166.88,105.96 167.68,105.96 168.3,105.34 168.3,105.09 169.37,104.02 172.29,104.02 172.71,103.61 179.26,103.61 179.51,103.86 182.28,103.86 182.63,104.22 186.58,104.22 188.07,105.72 188.54,105.72 189.84,107.01 189.84,108.44 190.75,109.35 190.75,110.75 196.35,116.35 196.35,118.55 198.55,120.76 200.04,120.76 200.22,120.58 201.86,120.58 202.75,121.47 203.33,121.47 203.66,121.81 203.66,122.26 203.89,122.49 204.37,122.49 204.68,122.8 204.68,123.27 205.26,123.85 206.56,123.85 207.23,124.53 208.53,124.53 211.01,127 212.5,127 213.42,127.92 213.42,128.63 213.77,128.99 215.83,128.99 216.85,127.97 225.51,127.97 226.83,126.65 226.83,125.84 227.04,125.63 227.83,125.63 228.15,125.31 229.11,125.31 229.41,125.01 231.46,125.01 231.55,125.1 231.55,125.35 231.81,125.61 v1(231.81,125.75)
CMSRC: length 3.1
  TOP w0.203: PU400.3 55.37,131.59 55.23,131.73 55.23,132.69 54.6,133.31 PR427.2
CODEC_MUTE#: length 338.2
  TOP w0.119: RA17.1 17.51,16.19 17.84,16.52 19.6,16.52 v2(19.81,16.72) ; UA1.52 33.52,19.83 34.4,20.71 34.4,23.04 35.02,23.65 36.08,23.65 RA25.2 37.01,24 RA72.1 37.24,24.22 37.24,25.18 DA7.1 38.13,25.28 v2(38.14,25.27) ; UA2.11 202.78,125.04 201.72,126.1 201.72,128.3 v1(201.38,128.64)
  IN1 w0.089: v2(38.14,25.27) 38.01,25.27 36.04,27.24 36.04,29.79 35.86,29.97 35.86,32.85 35.75,32.96 35.75,37.94 36.68,38.87 36.68,54.04 34.97,55.75 34.97,63.58 33.66,64.89 33.66,76.01 34.64,77 34.64,81.84 37.69,84.89 37.69,87.65 41.28,91.24 42.49,91.24 42.95,91.7 43.47,91.7 45.29,93.52 49.29,93.52 49.64,93.87 52.36,93.87 54.08,95.6 61.7,95.6 66.12,91.18 76.05,91.18 76.78,91.92 87.92,91.92 91.37,95.37 91.37,97.39 91.93,97.95 91.93,99.05 95,102.12 95,105.71 95.79,106.5 95.79,111.93 96.25,112.38 96.25,122.71 97.26,123.72 97.26,124.36 98.02,125.12 98.02,125.78 99.97,127.73 101.5,127.73 102.22,128.45 102.22,129.14 102.44,129.37 102.44,129.75 102.85,130.16 105.23,130.16 v3(105.39,130.32) ; v5(148.24,121.47) 148.43,121.66 149.28,121.66 149.55,121.4 149.55,121.13 150.81,119.87 159.03,119.87 160.17,121.01 160.17,121.39 160.72,121.94 161.82,121.94 162.18,121.58 162.18,121.4 162.45,121.13 163.4,121.13 164.04,120.48 164.26,120.48 165.43,119.31 165.43,117.82 165.84,117.41 165.84,116.97 165.63,116.76 165.63,116.29 165.87,116.05 165.87,115.4 166.39,114.88 166.39,114.22 166.86,113.76 167.66,113.76 168.94,112.48 170.25,112.48 172.08,110.65 172.22,110.65 172.6,110.27 173.42,110.27 174.43,109.26 176.04,109.26 176.24,109.45 177.06,109.45 178.1,110.5 178.1,111.69 176.57,113.22 176.57,117.4 178.11,118.94 183.89,118.94 184.07,119.12 184.84,119.12 186.68,120.96 186.68,122.62 188.57,124.52 189.78,124.52 191.79,126.53 193.58,126.53 193.94,126.88 193.94,127.34 194.23,127.63 197.17,127.63 197.97,128.42 198.56,128.42 199.25,129.12 200.31,129.12 200.5,128.93 201.09,128.93 v1(201.38,128.64)
  GND1 w0.119: v5(148.24,121.47) 148.11,121.34 v4(148.11,121.06) ; v4(105,130.21) 105.1,130.31 105.38,130.31 v3(105.39,130.32)
  IN2 w0.084: v2(38.14,25.27) 37.38,24.51 37.38,24.27 35.12,22 24.42,22 21.51,19.1 21.51,18.42 v2(19.81,16.72)
  GND3 w0.119: v4(105,130.21) 105.01,130.2 106.01,130.2 106.86,129.34 110.8,129.34 114.66,125.48 120.52,125.48 121.91,124.09 121.91,123.03 122.48,122.46 123.47,122.46 125.47,120.45 139.73,120.45 140.6,121.32 144.4,121.32 145.18,122.11 147.07,122.11 v4(148.11,121.06)
CORE_SW: length 3.9
  TOP w0.254: U16.G7 193.19,143.7 192.57,144.32
  TOP w0.508: L17.1 191.26,145.89 192.57,144.57 192.57,144.32
CPU_B+: length 3.7
  TOP w0.279: PC1245.1 75.39,110.75 PU800.A5 PU800.B5
  TOP w0.508: PC1245.1 75.8,111.16 v7(76.31,111.16)
  GND1 w0.254: v4(73.64,110.33) 73.23,110.33 v10(73.22,110.35)
  GND4 w0.254: v4(73.64,110.33) 73.91,110.33 v9(74.02,110.22)
  vias: v1(82.89,119.97) v1(83.19,119.99) v1(83.23,108.82) v1(83.5,119.99) v1(83.53,108.82) v1(83.8,119.99) v1(83.86,108.82) v1(84.11,119.99) v1(84.17,108.82) v1(84.41,119.99) v1(84.49,108.81) v1(84.72,120) v1(84.79,108.82) v1(85.02,120) v1(85.11,108.82) v1(85.44,120.02) v1(85.44,119.72) v1(85.41,108.81) v1(85.82,108.81) v1(85.83,108.49) v7(72.98,97.85) v7(73.88,101.71) v7(74.15,100.8) v7(74.15,100.24) v7(74.15,98.71) v7(74.15,98.15) v7(74.7,100.94) v7(78.49,109.69) v7(79.13,109.69) v7(79.52,118.51) v7(79.7,109.67) v7(80.08,118.51) v7(80.33,109.67) v7(80.65,118.51) v7(81.25,118.54) v7(82,119.58) v7(81.98,119.01) v14(77.27,115.01)
CPU_POPIRCOMP: length 7.6
  TOP w0.089: RC14.1 137.38,115.3 137.26,115.3 136.36,114.4 133.6,114.4 132.83,113.63 132.3,113.63 131.75,113.08 131.6,113.08 131.26,112.73 UC1.BN17
CPU_XDP_TCK: length 15.9
  TOP w0.152: RC23.1 125.23,94.78 RC27.1 124.73,94.46 124.16,93.89 v2(124.09,93.89)
  IN1 w0.06: v5(117.73,97.25) 118.04,97.56 119.06,97.56 119.27,97.78 119.27,97.88 119.09,98.06 119.09,98.2 119.23,98.34 v1(119.67,98.34)
  GND1 w0.089: v4(117.68,96.86) 117.68,97.21 v5(117.73,97.25)
  IN2 w0.084: v2(124.09,93.89) 124.09,93.56 v4(124.14,93.51)
  IN3 w0.084: v6(124.56,93.56) 124.51,93.51 v4(124.14,93.51)
  GND4 w0.089: v4(117.68,96.86) 117.68,96.86 117.44,97.11 v6(117.3,97.11)
  BOTTOM w0.152: v6(117.3,97.11) 117.69,97.49 118.34,97.49 119.97,95.87 120.71,95.87 120.94,95.64 122.38,95.64 123.21,94.81 123.51,94.81 v13(123.97,94.36) 124.56,93.77 v6(124.56,93.56)
CPU_XDP_TDI: length 25.9
  TOP w0.152: RC25.1 125.88,89.81 RC43.1 126.44,89.89 126.81,90.26 v2(127.31,90.26)
  IN1 w0.06: v5(118.22,97.21) 118.37,97.36 119.03,97.36 119.4,97.74 119.4,98.03 v1(119.34,98.09)
  GND1 w0.089: v4(118.16,96.68) 118.22,96.74 v5(118.22,97.21)
  IN2 w0.084: v4(121.34,86.62) 122.13,87.41 124.29,87.41 127.14,90.26 v2(127.31,90.26)
  IN3 w0.084: v4(121.34,86.62) 121.34,87 120.99,87.36 120.99,88.12 120,89.11 120,89.59 119.72,89.87 119.18,89.87 118.88,89.57 118.47,89.57 118.08,89.96 118.08,90.37 117.15,91.3 117.15,92.67 116.71,93.11 116.71,94.94 117.66,95.89 117.74,95.89 117.89,96.05 117.89,96.05 118.16,96.32 v4(118.16,96.68)
  GND4 w0.089: v15(118.12,97.09) 118.16,97.05 v4(118.16,96.68)
CPU_XDP_TDO: length 17.1
  TOP w0.152: v13(119.23,89.85) 119.23,89.91 119.04,90.11 v10(119.04,90.24) 120.48,90.24 121.22,89.5 RC18.1 121.22,88.77 RC5.1
  GND1 w0.089: v10(119.04,90.24) 118.94,90.24 v4(118.62,89.92)
  IN2 w0.06: v2(121.28,99.07) 121.28,98.58 121.35,98.51 121.35,97.42 120.71,96.78 120.27,96.78 118.93,95.44 117.66,95.44 117.07,94.86 v4(117.07,94.55)
  IN3 w0.084: v4(117.07,94.55) 117.07,93.25 117.51,92.82 117.51,91.52 118.42,90.61 118.42,90.13 v4(118.62,89.92)
CPU_XDP_TMS: length 20.7
  TOP w0.152: RC44.1 128.73,92.74 RC20.1 128.01,92.02 v10(127.74,92.02)
  IN1 w0.06: v1(118,98.19) 117.97,98.22 116.93,98.22 116.89,98.25 115.99,98.25 v5(115.65,98.59)
  GND1 w0.089: v4(127.98,91.68) 127.74,91.91 v10(127.74,92.02) ; v5(115.65,98.59) 115.82,98.75 116.01,98.75 v4(116.02,98.76)
  GND4 w0.089: v4(116.02,98.76) 116.11,98.67 v9(116.47,98.67) ; v9(127.49,92.03) 127.84,91.68 v4(127.98,91.68)
  BOTTOM w0.152: v9(116.47,98.67) 117.95,98.67 120.21,96.41 120.92,96.41 121.13,96.21 122.62,96.21 v14(123.04,95.79) 123.25,95.57 123.54,95.57 125.76,93.35 125.76,92.51 126.24,92.03 v9(127.49,92.03)
CPU_XDP_TRST#: length 16.2
  TOP w0.14: RC12.1 RC24.1 v2(113.34,90.46)
  IN2 w0.06: v2(121.6,98.83) 121.6,98.77 121.6,98.76 121.6,97.31 120.46,96.17 119.83,96.17 118.98,95.32 117.71,95.32 117.38,94.99 117.38,94.37 117.23,94.22 117.23,94.14
  IN2 w0.079: 117.23,94.14 117.23,93.91 117.71,93.43 v4(117.71,93.23) 117.71,93.14 116.17,91.6 115.56,91.6 115.42,91.47 114.94,91.47 114.89,91.42 114.78,91.42 114.53,91.17 114.07,91.17 114.07,91.17 113.92,91.17 113.34,90.59 v2(113.34,90.46)
  GND4 w0.084: v4(117.71,93.23) 117.71,93.35 v15(117.41,93.66)
CPUDRVL1_1: length 12.1
  TOP w0.508: PR806.2 v7(87.13,105.24) ; v7(82.68,110.84) 83.26,110.84 PQ800.8
  IN3 w0.508: v7(87.13,105.24) 86.93,105.24 86.11,106.05 83.8,106.05 83.42,105.67 82.68,105.67 82.05,106.31 82.05,107.75 82.67,108.37 82.67,110.82 v7(82.68,110.84)
CPUSW1: length 13.3
  TOP w0.254: PU801.7 v7(84.44,107.07) ; PR808.1 90.79,111.97 90.79,111.62 89.48,110.32 89.48,109.16 89.2,108.87 PL802.1
  TOP w0.508: PC804.2 82.99,104.92 v7(82.99,106.51)
  IN2 w0.508: v7(82.99,106.51) 83.88,106.51 v7(84.44,107.07) 85.17,107.07 85.73,107.63 85.73,109.33 v7(86.04,109.63)
CSI2_COMP: length 3.4
  TOP w0.254: RC64.2 131.22,96.08 131.59,96.45 132.63,96.45 132.84,96.66 132.84,97.34 132.87,97.37 UC1.A11
DAT_SMB: length 9.1
  TOP w0.119: JBAT100.5 154.8,91.35 155.71,92.26 v7(156.06,92.26) 156.22,92.41 158.05,92.41 158.38,92.74 159.42,92.74 PD100.3 159.87,94.83 159.75,94.95 PR122.1
DD: length 143.1
  TOP w0.119: v2(127.03,81.19) 126.82,80.98 121.6,80.98 120.5,82.07 v1(120.5,82.23) JPOGO.66 ; v10(65.42,118.55) 66.22,119.35 PR219.1 PR218.2 67.14,120.33 PU208.1 ; MD6.6 MD6.5 144.09,89.33 144.67,88.75 144.67,86.56 142.37,84.27 v2(141.96,84.27)
  IN1 w0.089: v3(102.01,122.18) 100.13,120.3 100.13,119.13 98.91,117.91 98.91,109.72 98.44,109.24 98.44,105.47 97.61,104.64 97.61,100 95.49,97.89 95.49,97.4 95.7,97.19 95.7,96.88 94.95,96.13 94.95,92.49 95.49,91.95 95.49,89.68 98.42,86.75 98.84,86.75 99.57,86.01 102.83,86.01 103.03,86.22 104.08,86.22 104.84,85.45 105.6,85.45 107.83,83.22 119.51,83.22 v1(120.5,82.23)
  GND1 w0.119: v10(65.42,118.55) 65.42,118.66 v4(65.72,118.96)
  IN2 w0.084: v2(127.03,81.19) 132.12,81.19 133.15,82.22 133.15,82.93 133.83,83.61 141.31,83.61 v2(141.96,84.27) ; v4(97.35,126.27) 97.7,126.27 99.02,124.95 100.23,124.95 102.01,123.17 v3(102.01,122.18)
  IN3 w0.084: v4(97.35,126.27) 96.34,125.26 89.19,125.26 88.25,126.19 85.35,126.19 84.92,126.63 80.04,126.63 78.08,124.66 75.37,124.66 73.51,122.8 69.71,122.8 65.98,119.07 65.83,119.07 v4(65.72,118.96)
DDR_0_DQ_VREF: length 20.2
  TOP w0.254: U3.H17 102.8,116.95 102.62,116.77 100.16,116.77 C2.1 v1(99.55,116.87) ; U3.U8 107.63,122.5 106.86,123.27 106.86,124.53 v1(106.91,124.58)
  TOP w0.381: R10.1 R6.2 v1(106.91,124.58)
  IN1 w0.254: v1(99.55,116.87) 99.55,117.36 100.97,118.78 100.97,119.77 102.54,121.34 102.54,121.93 104.37,123.76 106.09,123.76 v1(106.91,124.58)
DDR_1_DQ_VREF: length 30.6
  TOP w0.254: v2(121.35,127.73) 121.35,128.33 R16.1 121.23,128.48 R15.2 121.23,129.5 C4.1 ; U4.H17 129.75,128.27 130.08,128.61 131.71,128.61 132.57,129.47 v10(132.57,129.6) ; v2(135.72,125.48) 135.39,125.15 135.39,124.01 134.79,123.42 U4.U8
  GND1 w0.119: v10(132.57,129.6) v4(132.57,129.01)
  IN2 w0.254: v4(135.34,126.68) 135.72,126.3 v2(135.72,125.48) ; v2(121.35,127.73) 122.76,129.14 122.76,129.57 v4(124.49,131.3)
  IN3 w0.254: v4(135.34,126.68) 135.34,127.52 v6(135.36,127.54)
  GND4 w0.119: v9(132.67,128.56) 132.67,128.94 132.57,129.04 v4(132.57,129.01)
  GND4 w0.254: v9(124.03,131.52) 124.27,131.52 v4(124.49,131.3)
  BOTTOM w0.254: v6(135.36,127.54) 134.35,128.56 v9(132.67,128.56) 126.99,128.56 v9(124.03,131.52)
DDR_CHA_EN: length 31.2
  TOP w0.119: RH140.1 159.65,103.06 158.93,103.06 RH142.1 157.69,103.23 157.18,103.23 156.78,102.83 v7(156.78,102.62)
  IN1 w0.06: v1(134.16,103.82) 134.27,103.71 134.48,103.71 134.58,103.61 134.72,103.61 134.82,103.71 134.99,103.71 135.11,103.58 136.14,103.58 136.5,103.22 136.92,103.22 137,103.15 137.42,103.15 137.89,102.67 139.32,102.67 139.88,102.12 140.06,102.12
  IN1 w0.089: v8(146.96,101.18) 146.96,101.59 146.55,102 144.36,102 143.81,101.45 142.96,101.45 142.59,101.82 142.17,101.82 141.95,102.04 141.76,102.04 141.68,102.12 140.06,102.12
  GND1 w0.119: v4(146.7,100.3) 146.7,100.68 146.96,100.94 v8(146.96,101.18)
  IN3 w0.084: v7(156.78,102.62) 156.78,102.6 156.35,102.18 154.28,102.18 153.46,101.35 149.19,101.35 148.47,100.63 147.47,100.63 147.14,100.3 v4(146.7,100.3)
DDR_CHB_EN: length 32.2
  TOP w0.119: RH143.1 158.91,99.09 159.67,99.09 RH141.1 v2(160.18,98.84)
  IN1 w0.06: 140.06,101.34 140,101.34 139.95,101.38 v3(139.12,101.38)
  IN1 w0.089: 140.06,101.34 141.03,101.34 141.57,100.8 142.25,100.8 142.25,100.79 142.52,100.51 146.23,100.51 146.5,100.25 147.19,100.25 147.89,99.55 v3(147.89,99.03)
  IN2 w0.06: v3(139.12,101.38) 139.12,101.79 138.97,101.94 138.29,101.94 137.12,103.11 136.46,103.11 135.9,103.67 134.63,103.67 134.46,103.5 v2(134.41,103.5)
  IN2 w0.084: v3(147.89,99.03) 147.92,99.07 148.95,99.07 149.36,98.66 150.86,98.66 151.71,97.82 157.01,97.82 157.62,98.43 159.77,98.43 v2(160.18,98.84)
DDR_RCOMP_0: length 3.5
  TOP w0.305: RC45.1 114.53,108.75 116.38,110.59 UC1.BF64
DDR_RCOMP_1: length 3.2
  TOP w0.305: RC46.1 114.66,110.14 115.81,111.29 UC1.BJ64
DDR_RCOMP_2: length 3.5
  TOP w0.305: RC47.1 114.84,107.98 UC1.BC64
DDR_VREF_CA: length 57.4
  TOP w0.254: U4.J1 130.25,117.29 v10(129.77,116.82) ; U4.A10 126.18,124.35 123.6,124.35 123.55,124.4 R11.1 v10(122.66,124.4) ; v10(114.51,115.04) C3.1 113.21,115.48 111.24,117.45 U3.J1 ; U3.A10 106.63,112.48 v10(106.31,112.15) 106.46,112 106.91,112 107.75,111.16 R9.2
  GND1 w0.254: v10(122.66,124.4) 122.66,124.16 v4(122.79,124.04) ; v10(114.51,115.04) 114.59,115.12 114.59,115.53 v4(114.64,115.58) ; v4(129.69,116.27) 129.69,116.35 129.77,116.44 v10(129.77,116.82) ; v4(105.91,112.28) 105.94,112.25 106.2,112.25 v10(106.31,112.15)
  IN3 w0.254: v4(129.69,116.27) 129.69,116.07 128.99,115.37 121.95,115.37 118.6,118.73 v6(118.6,119.34) ; v6(122.02,123.74) 122.5,123.74 v4(122.79,124.04) ; v6(115.93,120.71) 114.64,119.41 v4(114.64,115.58) 111.46,112.4 106.04,112.4 v4(105.91,112.28)
  BOTTOM w0.254: v6(115.93,120.71) 115.93,119.85 116.87,118.91 118.17,118.91 v6(118.6,119.34) 122.02,122.75 v6(122.02,123.74)
DEBUG_UART_TX: length 190.3
  TOP w0.119: JDEG1.9 207.73,147.11 208.18,147.57 v1(208.18,149.04)
  IN1 w0.06: 140.06,102.37 139.79,102.37 139.37,102.79 137.94,102.79 137.47,103.27 137.04,103.27 136.97,103.34 136.55,103.34 136.19,103.7 135.16,103.7 135.04,103.83 134.65,103.83 v1(134.65,103.82)
  IN1 w0.089: v3(211.82,113.77) 211.82,113.92 213.8,115.9 215.56,115.9 216.13,116.46 217.09,116.46 217.75,117.11 222.13,117.11 223.29,115.95 225.35,115.95 225.66,116.27 232.2,116.27 233.59,114.87 238.64,114.87 241.8,118.03 243.69,118.03 244.17,118.51 244.17,122.26 v3(244.02,122.41) ; v3(148.89,98.74) 148.82,98.8 148.82,99.94 148,100.77 148,101.25 147.6,101.65 147.17,101.65 146.63,102.19 144.28,102.19 143.73,101.65 143.04,101.65 142.67,102.01 142.25,102.01 142.03,102.23 141.83,102.23 141.57,102.5 140.8,102.5 140.67,102.37 140.06,102.37 ; v3(237.7,141.79) 237.7,142.73 236.51,143.92 232,143.92 229.98,145.94 229.98,146.64 227.43,149.2 208.34,149.2 v1(208.18,149.04)
  IN2 w0.084: v3(148.89,98.74) 149.15,98.48 150.79,98.48 151.63,97.63 157.09,97.63 157.7,98.24 168.22,98.24 168.74,98.76 171.98,98.76 173.34,100.12 176.26,100.12 176.66,100.52 181.08,100.52 182.06,101.5 184.77,101.5 185.3,102.02 190,102.02 193.17,105.2 193.17,105.5 199.99,112.31 202.75,112.31 203.41,112.97 206.99,112.97 207.75,113.72 209.4,113.72 209.65,113.48 211.52,113.48 v3(211.82,113.77) ; v3(244.02,122.41) 245.46,123.85 245.46,132.56 242.98,135.04 242.43,135.04 241.49,135.99 239.17,135.99 237.7,137.46 v3(237.7,141.79)
DEVSLP0: length 110.3
  TOP w0.119: R1378.1 209.39,107.95 v2(209.67,107.95)
  IN1 w0.06: 136.52,96.06 136.34,96.24 135.54,96.24 135.17,96.61 135.01,96.77 134.97,96.81 134.8,96.81 133.67,97.94 133.67,98.31 133.19,98.79 v1(133.19,98.83)
  IN1 w0.089: 136.52,96.06 137.53,95.05 138.02,95.05 138.36,94.71 138.36,94.34 138.56,94.14 138.56,93.78 138.79,93.56 139.37,93.56 139.66,93.27 145.96,93.27 146.03,93.34 146.76,93.34 147.04,93.06 149.75,93.06 150.61,93.92 152.01,93.92 152.3,93.62 153.76,93.62 153.93,93.8 154.74,93.8 155.07,93.46 157.77,93.46 158.08,93.16 162.35,93.16 162.92,92.59 164.66,92.59 165.94,91.31 166.48,91.31 167.49,90.29 169.72,90.29 170.13,89.89 178.56,89.89 181.54,92.86 183.16,92.86 183.61,92.41 187.12,92.41 191.28,96.57 193.24,96.57 194.37,97.7 v5(195.89,97.7)
  GND1 w0.119: v5(195.89,97.7) v4(195.89,98.08)
  IN2 w0.084: v4(206.74,105.85) 207.91,105.85 209.67,107.62 v2(209.67,107.95)
  IN3 w0.084: v4(206.74,105.85) 206,105.11 202.61,105.11 201.95,105.77 200.29,105.77 199.71,105.2 199.71,103.26 200.81,102.16 200.81,99.82 200.92,99.7 200.92,98.03 200.51,97.62 200.51,93.35 200.89,92.98 JNGFF2.38
  GND4 w0.119: v4(195.89,98.08) v9(195.89,98.74)
  BOTTOM w0.076: JNGFF2.38 200.89,92.98 200.59,93.28
  BOTTOM w0.119: 200.59,93.28 200.59,96.22 T18.1 198.08,98.74 v9(195.89,98.74)
DISPOFF#: length 14
  TOP w0.119: JLVDS1.19 183.65,94.5 183.27,94.88 181.76,94.88 181.26,95.37 180.8,95.37 180.35,95.82 180.35,96.99 v2(179.86,97.48) ; v2(177.08,98.95) 177.08,99.5 R31.1 177.31,101.75 D2.1
  IN2 w0.084: v2(177.08,98.95) 177.08,98.97 177.33,99.21 179.13,99.21 179.86,98.48 v2(179.86,97.48)
DMIC_CLK1: length 233.6
  TOP w0.119: v7(35.67,26.09) 36.07,25.69 36.07,24.67 RA53.1 ; JDMIC1.1 v10(86.08,137.33)
  IN1 w0.089: v1(95.69,128.43) 95.69,128.74 95.97,129.01 95.97,129.66 95.88,129.75 95.88,130.17 v3(96.12,130.41)
  GND1 w0.119: v10(86.08,137.33) 86.08,136.47 v4(85.85,136.24)
  IN2 w0.084: v3(96.12,130.41) 95.55,130.41 94.44,131.52 90.14,131.52 v4(89.22,130.6) 88.84,130.22 87.84,130.22 87.78,130.28 82.15,130.28 80.82,128.95 79.13,128.95 74.26,124.08 73.8,124.08 72.65,122.93 70.65,122.93 70.44,122.72 68.39,122.72 65.12,119.44 65.12,118.34 62.46,115.68 62.46,111.9 59.39,108.82 59.39,106.75 59.71,106.44 59.71,105.6 60.15,105.16 60.15,103.56 59.52,102.93 58.49,102.93 58.06,103.36 53.12,103.36 52.41,104.08 52.41,104.82 47.23,110 40.35,110 38.81,108.47 38.81,108.43 v4(38.61,108.23) ; v7(35.67,26.09) 35.27,26.49 34.64,26.49 34.37,26.22 34.37,26.02 33.75,25.39 25.79,25.39 24.13,23.73 20.86,23.73 19.42,25.17 19.42,25.8 18.47,26.74 16.89,26.74 13.75,29.88 13.75,31.27 12.94,32.09 12.94,36.4 12.05,37.28 12.05,42.11 6.91,47.25 6.91,47.65 6.39,48.17 6.39,59.39 5.6,60.18 5.6,69.34 10.89,74.62 10.89,78.88 12.41,80.4 12.41,87.69 10.92,89.18 10.11,89.18 v4(9.86,89.42)
  IN3 w0.084: v4(38.61,108.23) 38.36,107.98 38.36,105.37 37.71,104.71 37.71,104.53 35.16,101.99 32.08,101.99 31.05,103.02 18.92,103.02 18.84,102.94 16.2,102.94 10.12,96.86 10.12,91.65 9.24,90.77 9.24,90.05 v4(9.86,89.42)
  GND4 w0.119: v9(85.79,135.44) 85.86,135.51 85.86,136.23 v4(85.85,136.24) ; v9(89.35,131.25) 89.35,130.73 v4(89.22,130.6)
  BOTTOM w0.119: v7(35.67,26.09) CA35.1 ; v9(85.79,135.44) 85.79,135.3 86.34,134.75 v14(86.34,133.94) 86.34,133.17 88.66,130.84 89.08,130.84 89.35,131.11 v9(89.35,131.25)
DMIC_CLK1_R: length 4.9
  TOP w0.119: UA1.53 33.41,20.23 34.16,20.98 34.16,23.13 34.73,23.7 RA53.2
DMIC_CLK2: length 230.2
  TOP w0.119: v7(31.75,26.1) 31.75,26.08 31.04,25.37 RA54.1 ; C284.1 95.69,126.47 96.48,127.26 96.48,128.78 v1(96.55,128.85) ; JDMIC1.11 v10(88.08,137.32)
  IN1 w0.089: v1(96.55,128.85) 96.59,128.89 96.59,128.92 96.73,129.07 96.73,129.83 96.58,129.98 v3(96.58,129.95)
  GND1 w0.119: v4(88.25,136.22) 88.08,136.39 v10(88.08,137.32)
  IN2 w0.084: v3(96.58,129.95) 96.4,129.78 91.32,129.78 v4(90.51,130.59) 89.31,129.4 88.05,129.4 87.54,129.91 83.67,129.91 82.31,128.54 79.26,128.54 74.36,123.65 73.89,123.65 72.8,122.56 70.85,122.56 70.52,122.23 69.17,122.23 66.12,119.18 66.12,118.82 62.9,115.59 62.9,111.56 59.76,108.43 59.76,106.91 60.08,106.6 60.08,105.77 61.22,104.64 61.22,102.62 60.94,102.34 52.88,102.34 52.04,103.18 52.04,104.67 47.07,109.63 40.53,109.63 39.65,108.75 v4(39.65,108.27) ; v7(31.75,26.1) 31.37,26.49 29.31,26.49 28.58,25.76 25.64,25.76 23.97,24.1 21.01,24.1 19.79,25.32 19.79,25.95 18.63,27.11 17.04,27.11 14.12,30.03 14.12,31.43 13.31,32.24 13.31,38.25 13.54,38.48 13.54,41.14 7.28,47.4 7.28,47.8 6.76,48.33 6.76,59.55 5.98,60.33 5.98,69.13 11.26,74.42 11.26,78.72 12.82,80.28 12.82,88.07 10.38,90.51 v4(9.81,90.51)
  IN3 w0.084: v4(39.65,108.27) 39.65,107.65 38.75,106.74 38.75,105.19 38.08,104.53 38.08,104.37 35.31,101.6 31.94,101.6 30.9,102.64 19.07,102.64 18.99,102.56 16.36,102.56 10.59,96.79 10.59,91.29 v4(9.81,90.51)
  GND4 w0.119: v4(90.51,130.59) v9(90.51,131.33) ; v9(88.54,135.34) 88.54,135.58 88.25,135.87 v4(88.25,136.22)
  BOTTOM w0.119: v9(90.51,131.33) 90.51,132.65 v13(90.43,132.72) 88.54,134.61 v9(88.54,135.34) ; CA39.1 31.22,25.55 31.75,26.08 v7(31.75,26.1)
