# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW9: length 9.7
  TOP w0.254: 170.62,127.16 170.03,127.16 169.59,126.72 PU500.A11 PU500.B11
  TOP w0.508: PL602.2 174.05,132.2 174.05,129.75 173.67,129.37 172.5,129.37 172.14,129.01 172.14,128.29 171.75,127.9 PC608.1 171.43,127.67 170.92,127.16 170.62,127.16
SW10: length 13.7
  TOP w0.254: 164.9,124.06 165.53,124.06 PU500.G1
  TOP w0.508: v10(162.3,126.27) PC620.2 162.54,126.27 163.73,125.08 163.73,124.75 164.42,124.06 164.9,124.06 ; 154.67,128.53 152.47,128.53 PR607.1
  GND1 w0.508: v4(156.72,125.03) 156.42,125.03 v10(156.32,125.13) ; v10(162.3,126.27) 162.3,126.11 v4(161.91,125.71)
  GND4 w0.508: v9(157.05,125.26) 156.83,125.03 v4(156.72,125.03) ; v9(161.35,125.71) v4(161.91,125.71)
  BOTTOM w0.508: v9(161.35,125.71) 157.51,125.71 v9(157.05,125.26)
SW11: length 14.6
  TOP w0.254: v1(167.57,120.1) 167.42,120.25 167.42,120.72 167.59,120.89 PU500.P6
  IN1 w0.254: v1(167.57,120.1) 167.57,120.1 167.57,119.45 167.42,119.3 167.42,118.78
  IN1 w0.508: 167.42,118.78 167.42,116.84 167.27,116.69 167.27,115.65 167.19,115.58 v5(167.19,115.5)
  GND1 w0.508: v4(166.73,114.94) 166.73,115.04 v5(167.19,115.5)
  IN3 w0.508: 164.95,108.42 165.69,108.42 166.72,109.45 166.72,113.84 166.48,114.09 166.48,114.69 v4(166.73,114.94)
  vias: v7(163.67,108.02) v7(164.23,108.01)
SW12: length 1
  TOP w0.254: PU500.N9 PU500.P9 168.79,120.57
SYS_PRE#: length 36
  TOP w0.119: PR305.2 PR306.1 167.43,109.72 167.6,109.56 167.6,108.94 167.34,108.68 167.34,107.98 168.1,107.22 168.1,105.93 v10(168.15,105.88) ; JBAT100.7 157.3,89.49 157.56,89.22 162.02,89.22 162.77,89.97 163.28,89.97 163.61,89.64 v7(163.61,89.01)
  GND1 w0.119: v4(167.9,105.34) 167.9,105.62 v10(168.15,105.88)
  GND4 w0.119: v9(168.41,105.24) 168,105.24 v4(167.9,105.34)
  BOTTOM w0.119: v9(168.41,105.24) 168.41,104.53 164.31,100.43 164.31,98.84 v13(163.54,98.08) 163.54,97.4 164.92,96.03 164.92,90.81 164.56,90.46 163.33,90.46 162.79,89.92 162.79,89.54 163.33,89.01 v7(163.61,89.01)
SYS_PWROK: length 71.4
  TOP w0.152: v10(138.2,90.6) 138.84,90.6 139.69,89.74 RC67.1 140.53,89.69 T26.1 ; v10(140.87,97.24) 140.87,97.26 140.7,97.44 140.34,97.44 139.57,98.22 138.83,98.22 138.58,97.96 RH113.2 137.74,97.86 136.58,99.02 136.12,99.02 135.51,99.64 UC1.J1
  GND1 w0.089: v4(138.11,91) 138.2,90.91 v10(138.2,90.6) ; v4(141.78,97.05) 141.59,97.24 v10(140.87,97.24)
  IN2 w0.06: 168.26,121.32 168.26,121.37 167.93,121.7 167.93,122.13 167.79,122.26 167.79,122.48 167.91,122.6 167.91,122.6 168.11,122.6 168.21,122.69 168.21,123.03 168.06,123.18 167.9,123.18 167.59,123.48 v2(167.59,123.6)
  IN2 w0.084: 168.26,121.32 168.26,120.58 v4(168.69,120.15)
  IN3 w0.084: v6(147.02,100.66) 147.33,100.97 148.33,100.97 149.09,101.74 152.48,101.74 153.45,102.7 153.45,103.21 154.18,103.94 156.47,103.94 157.56,102.85 157.91,102.85 158.53,103.48 159.36,103.48 160.34,104.46 162.06,104.46 163.2,105.61 163.2,106.33 163.96,107.09 164.67,107.09 165.41,107.83 166.71,107.83 167.52,108.64 167.52,113.55 168.22,114.25 168.22,119.15 168.36,119.29 168.36,119.83 168.66,120.14 168.68,120.14 v4(168.69,120.15)
  GND4 w0.089: v9(138.4,91.7) 138.4,91.33 138.11,91.04 v4(138.11,91) ; v9(142.42,96.95) 141.88,96.95 v4(141.78,97.05)
  BOTTOM w0.152: v9(138.4,91.7) 139.41,92.72 141.75,92.72 143.88,94.85 143.88,96.01 143.12,96.77 142.6,96.77 v9(142.42,96.95) 142.54,97.06 145.19,97.06 146.13,98 146.13,99.62 v13(146.49,99.97) 147.02,100.5 v6(147.02,100.66)
SYS_PWROK_XDP: length 65.7
  TOP w0.152: RC235.2 163.46,103.75 v2(163.4,103.75) ; v2(137.57,90.58) 137.64,90.58 138.29,89.93 RC9.2 138.3,89.69 RC67.2
  IN2 w0.084: v4(130.11,82.74) 130.52,82.74 133.37,85.59 135.62,85.59 137.76,87.73 v4(137.76,89.1) 137.57,89.29 v2(137.57,90.58) ; v4(162.9,104.02) 163.12,103.8 163.35,103.8 v2(163.4,103.75)
  IN3 w0.084: v4(162.9,104.02) 162.66,103.78 160.62,103.78 159.64,102.8 158.81,102.8 157.81,101.8 156.96,101.8 156.66,101.5 154.56,101.5 153.74,100.68 149.55,100.68 v6(149.49,100.62) ; v4(130.11,82.74) 126.12,82.74 v6(122.99,85.86)
  GND4 w0.089: v6(138.17,89.31) 137.97,89.31 v4(137.76,89.1)
  BOTTOM w0.152: v6(149.49,100.62) 147.75,98.88 147.75,95.49 144.68,92.42 144.68,91.53 142.84,89.69 139.64,89.69 139.26,89.31 v6(138.17,89.31) ; v6(122.99,85.86) 122.89,85.96 122.89,87.31 119.55,90.65 JXDP2.47
SYS_RESET#: length 5.3
  TOP w0.14: UC1.H2 135.46,99.31 136.19,98.58 136.27,98.58 137.57,97.28 RH132.2 138.58,96.44 RH52.2
SYSTHERM0: length 42.5
  TOP w0.254: PR745.1 183.62,137.09 PR741.2 183.72,136.36 185.71,136.36 v10(186.01,136.05)
  IN1 w0.06: 171.43,125.08 171.01,125.08 170.68,124.75 170.35,124.75 170.2,124.6 169.39,124.6 v1(169.19,124.4)
  IN1 w0.254: v3(185.32,121.52) 185.32,121.35 184.31,120.34 183.1,120.34 182.94,120.18 179.91,120.18 179.51,120.58 178.18,120.58 177.61,121.14 176.82,121.14 175.93,122.02 175.93,122.27 175.45,122.75 175.45,123.44 174.75,124.14 173.87,124.14 173.29,124.72 173.29,125.27 173.01,125.55 171.9,125.55 171.43,125.08
  GND1 w0.254: v4(185.93,135.54) 186.01,135.62 v10(186.01,136.05)
  IN2 w0.254: v3(185.32,121.52) 185.49,121.34 v4(185.88,121.34)
  IN3 w0.254: v4(185.93,135.54) 187.08,135.54 188.82,133.8 188.82,131.72 189.16,131.38 189.16,126.06 185.88,122.78 v4(185.88,121.34)
TBT_BATLOW#: length 298.5
  TOP w0.119: RT8.2 22.47,26.11 v7(22.21,25.84)
  IN1 w0.06: 140.06,98.81 139.72,99.14 139.44,99.14 139.29,99.29 137.63,99.29 137.44,99.47 137.27,99.47 136.53,100.22 135.98,100.22 135.07,101.13 134.32,101.13 134.23,101.04 134.09,101.04 133.87,101.26 133.87,101.33 133.75,101.45 133.58,101.45 133.49,101.36 133.35,101.36 133.13,101.58 133.13,101.65 133.09,101.69 132.98,101.8 132.77,101.8 v1(132.68,101.89)
  IN1 w0.089: 140.06,98.81 140.09,98.78 140.38,98.78 140.82,98.34 140.82,98.14 141.44,97.53 141.44,96.98 142.52,95.9 143.53,95.9 143.74,95.69 145.76,95.69 v5(146.13,96.06)
  GND1 w0.119: v4(146.45,96.46) 146.45,96.38 v5(146.13,96.06)
  IN2 w0.084: v7(22.21,25.84) 21.59,26.46 21.19,26.46 19.37,28.28 17.76,28.28 15.46,30.59 15.46,31.98 14.64,32.79 14.64,37.7 15.17,38.23 15.17,41.4 8.62,47.96 8.62,48.38 8.1,48.9 8.1,55.72 8.62,56.24 8.62,59.38 8.31,59.69 8.31,63.04 17.36,72.08 17.36,78.68 15.17,80.86 15.17,86.37 16.48,87.68 16.48,89.22 18.27,91.01 18.27,94.24 17.3,95.22 17.3,96.87 17.04,97.12 17.04,98.91 v4(16.78,99.17)
  IN3 w0.06: v6(133.95,104.87) 133.81,105.01 133.81,107.67 133.35,108.13 133.35,108.77
  IN3 w0.084: v4(16.78,99.17) 17.24,99.62 17.43,99.62 19.51,101.7 25.66,101.7 25.84,101.52 30.01,101.52 31.08,100.45 35.95,100.45 37.86,102.36 39.94,102.36 41.28,101.02 42.65,101.02 42.81,100.86 61.54,100.86 64.02,103.34 64.02,108.07 63.71,108.38 63.71,118.68 68.99,123.96 68.99,125.29 70.56,126.85 77.51,126.85 79.12,128.46 85.22,128.46 85.62,128.85 91.88,128.85 92.25,128.48 94.22,128.48 94.64,128.06 101.16,128.06 102.57,129.47 104.05,129.47 104.05,129.48 108.76,129.48 110.65,127.59 111.1,127.59 112.44,126.25 120.56,126.25 121.5,125.32 121.5,122.96 121.82,122.64 121.82,119.31 124.42,116.71 126.36,116.71 126.85,117.2 132.05,117.2 133.35,115.89 133.35,108.77
  GND4 w0.119: v4(146.45,96.46) 146.35,96.46 v9(146.13,96.25)
  BOTTOM w0.119: v6(133.95,104.87) 133.6,104.52 133.6,101.05 132.73,100.18 132.73,93.04 134.89,90.88 138.78,90.88 139.04,91.14 142.05,91.14 142.69,91.78 142.69,92.48 146.13,95.92 v9(146.13,96.25)
TBT_BATLOW_N: length 4.4
  TOP w0.076: UT1.F2 22.72,30.51 22.72,29.65
  TOP w0.119: RT8.1 22.12,27.35 22.12,28.37 22.27,28.52 R1402.1 22.47,29.4 22.72,29.65
TBT_CIO_PLUG_EVENT#: length 307.7
  IN1 w0.06: v1(134.9,102.21) 135.42,102.21 135.86,101.77 136.07,101.77 137.05,100.79 138.3,100.79 138.49,100.6 139,100.6 139.37,100.23 139.4,100.23 139.62,100.01
  IN1 w0.089: v5(145.56,96.36) 145.28,96.08 143.95,96.08 143.74,96.28 142.68,96.28 141.82,97.13 141.82,97.68 141.44,98.07 141.44,98.52 139.95,100.01 139.62,100.01
  GND1 w0.119: v10(29.51,26.92) 29.53,26.94 v12(29.53,27.25) ; v5(145.56,96.36) 145.85,96.64 v4(145.94,96.64)
  IN2 w0.084: v12(29.53,27.25) 29.19,27.25 28.32,26.37 25.39,26.37 23.74,24.71 21.24,24.71 20.38,25.58 20.38,26.22 19.06,27.54 17.45,27.54 14.71,30.28 14.71,31.67 13.9,32.48 13.9,38.01 14.42,38.52 14.42,41.11 7.88,47.65 7.88,48.05 7.36,48.57 7.36,56.02 7.88,56.55 7.88,58.87 7.55,59.2 7.55,59.6 6.57,60.58 6.57,68.76 11.86,74.05 11.86,78.41 13.54,80.1 13.54,88.34 13.19,88.69 13.19,89.1 13.47,89.38 v4(13.89,89.38)
  IN3 w0.06: 133.54,108.95 133.54,108.25 133.93,107.86 133.93,105.2 134.23,104.9 v6(134.23,104.59)
  IN3 w0.084: 133.54,108.95 133.54,115.97 132.13,117.38 126.77,117.38 126.28,116.9 125.51,116.9 124.69,117.72 123.67,117.72 122.01,119.38 122.01,122.71 121.68,123.04 121.68,125.44 120.69,126.43 112.51,126.43 111.17,127.77 110.72,127.77 108.83,129.66 103.93,129.66 103.93,129.66 102.5,129.66 101.13,128.29 94.67,128.29 94.29,128.67 92.33,128.67 91.96,129.04 85.54,129.04 85.15,128.65 79.05,128.65 77.44,127.03 70.48,127.03 68.81,125.36 68.81,124.04 63.53,118.76 63.53,108.3 63.83,107.99 63.83,103.42 61.46,101.05 42.89,101.05 42.71,101.23 41.34,101.23 40.02,102.54 37.78,102.54 35.87,100.63 31.16,100.63 30.09,101.71 25.91,101.71 25.73,101.88 19.43,101.88 17.35,99.81 15.71,99.81 12.2,96.29 12.2,93.45 11.82,93.07 11.82,91.45 v4(13.89,89.38)
  GND4 w0.119: v9(146.18,97.23) 146.18,96.96 145.99,96.77 145.99,96.69 v4(145.94,96.64)
  BOTTOM w0.119: v6(134.23,104.59) 133.82,104.18 133.82,100.96 132.95,100.09 132.95,93.13 134.98,91.1 138.68,91.1 138.95,91.36 141.96,91.36 142.45,91.86 142.45,92.55 145.8,95.91 145.8,96.85 v9(146.18,97.23)
TBT_CIO_PLUG_EVENT_N: length 4.1
  TOP w0.076: 28.7,30.04 28.71,30.05 28.71,30.11 28.71,30.11 28.71,30.45 28.71,30.51 UT1.W2
  TOP w0.119: 28.7,30.04 28.7,29.55 29.53,28.71 R1400.1 29.62,28.66 29.89,28.39 29.89,27.82 RT5.1
TBT_CLKREQ_N: length 273.3
  TOP w0.119: UT1.AC5 30.76,32.12 30.94,31.95 31.3,31.95 32.13,31.11 v10(32.23,31.11)
  GND1 w0.119: v4(32.15,30.34) 32.15,31.03 v10(32.23,31.11)
  IN2 w0.06: v4(138.34,109.95) 138.23,109.84 136.39,109.84 136.05,109.49 135.35,109.49 134.83,108.97 134.42,108.97 v4(134.13,108.68) 134.1,108.65 v2(133.42,108.65)
  IN2 w0.084: v4(32.15,30.34) 31.64,30.34 31.15,29.84 30.61,29.84 28.38,27.61 27.84,27.61 27.63,27.39 25.51,27.39 25.2,27.08 23.76,27.08 23.17,26.49 23.17,25.08 22.99,24.9 21.32,24.9 20.57,25.65 20.57,26.29 19.13,27.72 17.53,27.72 14.9,30.36 14.9,31.75 14.09,32.56 14.09,37.93 14.61,38.45 14.61,41.18 8.06,47.72 8.06,48.13 7.54,48.65 7.54,55.95 8.07,56.47 8.07,58.95 7.73,59.28 7.73,59.72 6.76,60.69 6.76,68.68 12.05,73.97 12.05,78.33 13.74,80.02 13.74,88.73 v4(13.54,88.92)
  IN3 w0.06: v4(134.13,108.68) 133.92,108.89 133.92,109.34
  IN3 w0.084: v4(13.54,88.92) 11.36,91.11 11.36,92.95 12.01,93.6 12.01,96.37 16.64,101 17.98,101 19.23,102.26 25.89,102.26 26.07,102.08 30.24,102.08 31.31,101 35.72,101 37.65,102.94 40.17,102.94 41.5,101.61 42.86,101.61 43.05,101.42 61.31,101.42 63.42,103.53 63.42,107.8 63.16,108.07 63.16,118.95 68.32,124.12 68.32,125.4 71.69,128.77 75.72,128.77 76.05,128.44 76.95,128.44 77.99,129.48 79.36,129.48 79.47,129.59 81.84,129.59 82.2,129.22 85.2,129.22 85.38,129.41 92.11,129.41 92.48,129.04 94.45,129.04 94.73,128.76 100,128.76 100.71,129.47 101.74,129.47 102.81,130.54 104.37,130.54 104.6,130.76 105.32,130.76 106.04,130.04 108.98,130.04 110.88,128.14 111.33,128.14 112.67,126.8 120.85,126.8 123.37,124.28 123.37,119.56 125.66,117.27 126.13,117.27 126.62,117.75 132.28,117.75 133.92,116.11 133.92,109.34
  GND4 w0.119: v4(138.34,109.95) 138.23,110.06 138.23,110.3 v9(138.22,110.31)
  BOTTOM w0.119: RH28.2 v9(138.22,110.31)
TBT_EE_CLK: length 16.5
  TOP w0.119: R5706.1 39,38.29 38.42,37.72 37.5,37.72 37.32,37.54 U716.6 37.32,35.3 37.56,35.06 v2(38.16,35.06)
  IN2 w0.084: v2(29.85,31.66) 30.05,31.86 33.51,31.86 33.98,31.4 36.64,31.4 37.32,32.07 37.32,34.22 v2(38.16,35.06)
TBT_EE_CS_N: length 19.8
  TOP w0.119: U716.1 v2(34.78,28.84) 34.78,27.99 R1385.2 ; v2(30.68,31.01) 30.48,31.2 UT1.AC3 ; R5709.1 37.35,38.24 v1(36.88,37.77)
  IN1 w0.089: v1(36.88,37.77) 36.49,37.38 36.49,34.04 36.32,33.87 36.32,32.06 36.59,31.79 36.59,29.33 v3(36.38,29.12)
  IN2 w0.084: v2(30.68,31.01) 31.14,31.47 32.54,31.47 34.42,29.59 34.42,29.19 v2(34.78,28.84) 35.13,28.84 35.41,29.12 v3(36.38,29.12)
TBT_EE_DI: length 15.5
  TOP w0.119: R5707.1 33.42,30.45 v2(34.07,31.1)
  IN2 w0.084: v2(29.85,31.2) 29.94,31.2 30.41,31.67 33.44,31.67 33.9,31.21 33.95,31.21 v2(34.07,31.1) 34.18,31.21 36.72,31.21 38.59,33.08 v2(38.59,36)
TBT_EE_DO: length 11.3
  TOP w0.119: R1384.2 35.29,28.22 v2(35.54,28.48) 35.87,28.48 36.05,28.66 36.05,30.1 ; UT1.AC4 30.57,31.66 31.18,31.05 v2(31.23,31.05) 31.23,30.76 32.02,29.96 R5708.1
  IN2 w0.084: v2(35.54,28.48) 34.75,28.48 34.23,29 34.23,29.49 32.43,31.29 31.47,31.29 v2(31.23,31.05)
TBT_EE_WP_N: length 14.4
  TOP w0.119: R1383.2 35.95,27.94 v2(36.32,28.31) 37.08,28.31 37.31,28.53 37.31,28.84 37.32,28.85 U716.3 ; UT1.V1 28.01,29.89 28.17,29.73 v2(28.17,29.7)
  IN2 w0.084: v2(36.32,28.31) 35.93,27.92 35.05,27.92 34.04,28.93 34.04,29.39 32.34,31.1 31.7,31.1 31.29,30.69 30.2,30.69 29.21,29.7 v2(28.17,29.7)
TBT_FORCE_PWR: length 5.9
  TOP w0.102: UT1.H4 v7(22.98,31.76)
  BOTTOM w0.119: RT7.1 22.59,27.39 22.59,28.35 22.75,28.52 R1409.1
  BOTTOM w0.127: R1409.1 23.3,28.85 23.3,31.45 v7(22.98,31.76)
TBT_HDMI_DDC_CLK: length 3.2
  TOP w0.076: 29.16,29.96 29.16,30.51 UT1.Y2
  TOP w0.119: R1389.1 30.83,28.63 30.32,29.14 29.98,29.14 29.16,29.96
TBT_HDMI_DDC_DATA: length 2.3
  TOP w0.119: UT1.Y1 28.93,29.86 R1390.1
TBT_HOLD_N: length 2.4
  TOP w0.119: 36.05,36 36.05,37.55 36.44,37.94 R1386.2
TBT_I2C_SCL: length 56.4
  TOP w0.076: 26.88,29.53 27.32,29.97 27.32,30.51 UT1.U2
  TOP w0.119: v2(26.98,28.57) 26.88,28.67 26.88,29.53
  IN1 w0.089: v1(23.25,52.98) 23.01,53.22 22.6,53.22 22.27,53.55 21.87,53.55 21.38,54.05 21.38,54.5 20.82,55.06 19.03,55.06 18.66,54.69 12.96,54.69 11.35,53.07 10.2,53.07 10.04,53.23 v2(9.92,53.23)
  IN2 w0.084: v2(26.98,28.57) 26.94,28.53 25.19,28.53 24.74,28.08 20.36,28.08 19.6,28.84 18.07,28.84 16.01,30.89 16.01,32.21 15.2,33.02 15.2,37.47 15.73,38 15.73,42.46 13.8,44.38 13.75,44.38 11.21,46.92 10.56,46.92 9.36,48.12 9.36,50.3 9.75,50.69 9.75,53.06 v2(9.92,53.23)
TBT_I2C_SDA: length 56.8
  TOP w0.076: UT1.U1 27.55,29.89 27.22,29.56
  TOP w0.119: 27.22,29.56 27.22,29.14 27.55,28.81 v2(27.55,28.57)
  IN1 w0.089: v1(22.75,52.98) 22.56,52.98 22.18,53.36 21.8,53.36 21.19,53.97 21.19,54.42 20.74,54.87 19.11,54.87 18.74,54.5 13.03,54.5 11.42,52.89 10.13,52.89 10.04,52.98 9.67,52.98 v2(9.42,53.23)
  IN2 w0.084: v2(27.55,28.57) 27.37,28.57 27.07,28.26 25.19,28.26 24.82,27.89 20.28,27.89 19.52,28.65 17.97,28.65 15.83,30.8 15.83,32.13 15.01,32.95 15.01,37.55 15.54,38.07 15.54,41.61 13.46,43.69 13.46,44.41 11.13,46.73 10.45,46.73 9.18,48.01 9.18,50.36 9.58,50.76 9.58,53.07 v2(9.42,53.23)
TBT_PCIE_RX0_N: length 160.7
  TOP w0.076: 28.93,39.99 28.7,40.22 28.7,40.73
  TOP w0.081: UT1.Y22 28.93,39.99
  TOP w0.119: v7(28.87,41.51) 29.04,41.33 29.04,41.07 28.7,40.73
  IN2 w0.084: v2(135.12,93.86) 135.37,93.62 135.37,92.47 135.23,92.33 135.23,90.52 132.37,87.67 130.25,87.67 125.37,82.79 120.61,82.79 120.23,82.42 116.65,82.42 116.33,82.74 110.9,82.74 110.56,82.4 103.3,82.4 102.93,82.03 89.79,82.03 89.72,81.96 51.96,81.96 51.58,82.33 46.55,82.33 45.22,83.66 38.83,83.66 36.61,81.44 36.61,54.58 39.15,52.04 39.15,45.18 38.45,44.49 38.45,44.26 38.19,43.99 38.19,43.44 38.54,43.08 38.69,43.08 38.77,43.01 38.77,42.8 v4(38.69,42.72)
  IN3 w0.084: v4(38.69,42.72) 38.75,42.65 38.75,42.31 38.56,42.12 29.26,42.12 29.05,41.91 29.05,41.69 v7(28.87,41.51)
TBT_PCIE_RX0_N_C: length 8.5
  IN2 w0.06: v2(135.12,94.45) 135.12,94.34 135.2,94.27 135.36,94.27 135.42,94.33 135.42,94.59 133.51,96.5 132.43,96.5 132.15,96.78 131.29,96.78 130.3,97.78 130.3,99.07 v2(130.29,99.07)
TBT_PCIE_RX0_P: length 160.7
  TOP w0.119: UT1.Y23 28.93,40.58 29.31,40.95 29.31,41.44 29.38,41.51 v7(29.45,41.51)
  IN2 w0.084: v2(135.69,93.87) 135.59,93.87 135.53,93.81 135.53,92.4 135.39,92.26 135.39,90.46 132.44,87.51 130.32,87.51 125.44,82.63 120.68,82.63 120.3,82.25 116.58,82.25 116.26,82.57 110.97,82.57 110.63,82.24 103.37,82.24 103,81.87 89.86,81.87 89.79,81.8 51.89,81.8 51.52,82.17 46.48,82.17 45.15,83.5 38.89,83.5 36.77,81.38 36.77,54.64 39.31,52.11 39.31,45.12 38.61,44.42 38.61,44.19 38.35,43.92 38.35,43.51 38.61,43.25 38.76,43.25 38.93,43.08 38.93,43.08 38.98,43.02 39.17,43.02 39.22,42.98 v4(39.22,42.72)
  IN3 w0.084: v4(39.22,42.72) 39.18,42.72 38.92,42.46 38.92,42.25 38.63,41.96 29.33,41.96 29.22,41.84 29.22,41.64 29.35,41.51 v7(29.45,41.51)
TBT_PCIE_RX0_P_C: length 8.5
  IN2 w0.06: v2(130.29,99.57) 130.29,99.36 130.49,99.16 130.49,98.99 130.42,98.91 130.42,97.83 131.34,96.9 132.2,96.9 132.48,96.62 133.56,96.62 135.54,94.64 135.54,94.61 v2(135.69,94.46)
TBT_PCIE_RX1_N: length 160.7
  TOP w0.076: UT1.T22 27.09,39.99 26.87,40.22 26.87,40.71
  TOP w0.081: 26.87,40.71 26.88,40.73
  TOP w0.119: v7(27.05,41.58) 27.1,41.54 27.18,41.45 27.18,41.39 26.88,41.09 26.88,40.73
  IN2 w0.084: v4(39.1,44.09) 39.27,44.26 39.27,44.42 39.8,44.94 39.8,52.28 37.24,54.84 37.24,81.18 39.03,82.97 44.95,82.97 46.22,81.7 51.32,81.7 51.7,81.33 104.5,81.33 105.17,82 110.42,82 111.05,81.37 120.35,81.37 121.07,82.09 125.57,82.09 130.52,87.04 132.72,87.04 134.72,89.04 134.72,89.43 135.75,90.46 135.75,91.83 135.81,91.89 v2(135.81,92.59)
  IN3 w0.084: v7(27.05,41.58) 27.26,41.79 27.26,42.32 27.69,42.75 37.45,42.75 38.05,43.35 38.88,43.35 39.15,43.62 39.15,44.05 v4(39.1,44.09)
TBT_PCIE_RX1_N_C: length 9.4
  IN2 w0.06: 136.1,94.27 136.1,94.28 136.12,94.3 136.12,94.44 135.44,95.13 135.22,95.13 133.61,96.74 132.53,96.74 132.17,97.11 132.17,97.17 131.81,97.52 131.81,97.78 131.32,98.27 131,98.27 130.7,98.57 130.7,98.79 130.66,98.83 v2(130.62,98.83)
  IN2 w0.084: 136.1,94.27 136.1,93.08 136.06,93.04 135.95,93.04 v2(135.81,93.18)
TBT_PCIE_RX1_P: length 160.7
  TOP w0.119: v7(27.64,41.58) 27.45,41.39 27.45,41.28 27.15,40.98 27.15,40.45 UT1.T23
  IN2 w0.084: v2(136.38,92.59) 136.19,92.4 136.19,92.32 136.14,92.27 136.01,92.27 135.97,92.23 135.97,91.83 135.91,91.77 135.91,90.39 134.88,89.37 134.88,88.97 132.79,86.88 130.59,86.88 125.64,81.93 121.13,81.93 120.41,81.21 110.98,81.21 110.35,81.84 105.24,81.84 104.57,81.16 51.64,81.16 51.25,81.54 46.16,81.54 44.89,82.81 39.1,82.81 37.4,81.11 37.4,54.9 39.96,52.34 39.96,44.88 39.44,44.35 39.44,44.21 39.55,44.09 v4(39.64,44.09)
  IN3 w0.084: v7(27.64,41.58) 27.43,41.79 27.43,42.25 27.76,42.58 37.51,42.58 38.12,43.19 38.94,43.19 39.31,43.55 39.31,43.81 39.6,44.09 v4(39.64,44.09)
TBT_PCIE_RX1_P_C: length 9.5
  IN2 w0.06: 136.26,94.27 136.26,94.47 135.49,95.25 135.27,95.25 133.66,96.86 132.58,96.86 132.29,97.16 132.29,97.22 131.93,97.57 131.93,97.83 131.37,98.39 131.05,98.39 130.82,98.62 130.82,98.91 130.62,99.11 v2(130.62,99.32)
  IN2 w0.084: v2(136.38,93.18) 136.26,93.29 136.26,94.27
TBT_PCIE_RX2_N: length 163.4
  TOP w0.076: 25.28,40.97 25.03,40.71 25.03,40.22 25.25,39.99 UT1.M22
  TOP w0.152: 25.28,40.97 25.28,41.61 v7(25.2,41.69)
  IN2 w0.084: v4(37.73,44.89) 37.81,44.97 37.81,45.8 37.39,46.22 37.39,51.98 35.35,54.02 35.35,82.03 38.64,85.31 45.39,85.31 47.11,83.59 52.1,83.59 52.46,83.23 65.12,83.23 65.82,83.93 70.83,83.93 71.24,84.34 74.65,84.34 74.94,84.05 101.18,84.05 101.93,83.29 109.07,83.29 109.46,83.69 124.93,83.69 130.22,88.98 132.52,88.98 134.38,90.84 134.38,91.78 134.02,92.14 134.02,93.62 v2(133.84,93.8)
  IN3 w0.084: v4(37.73,44.89) 37.89,44.73 37.89,44.14 37.12,43.37 26.49,43.37 25.29,42.17 25.29,41.79 v7(25.2,41.69)
TBT_PCIE_RX2_N_C: length 7.9
  IN2 w0.06: v2(133.84,94.38) 133.95,94.27 134.07,94.27 134.13,94.33 134.13,94.49 133.19,95.44 132.81,95.44 131.95,96.3 131.09,96.3 129.65,97.75 129.65,98.59 129.65,98.79 129.51,98.93 129.51,99.04 129.57,99.09 129.63,99.09 v2(129.65,99.07)
TBT_PCIE_RX2_P: length 163.3
  TOP w0.081: 25.6,40.95 25.6,40.94 25.57,40.91 25.57,40.88 25.25,40.56 UT1.M23
  TOP w0.152: 25.6,40.95 25.62,40.97 25.62,41.47 25.62,41.58 25.73,41.69 v7(25.78,41.69)
  IN2 w0.084: v2(134.41,93.8) 134.3,93.8 134.18,93.68 134.18,92.21 134.54,91.85 134.54,90.77 132.58,88.81 130.29,88.81 125,83.52 109.53,83.52 109.14,83.13 101.87,83.13 101.11,83.89 74.87,83.89 74.58,84.17 71.3,84.17 70.9,83.77 65.89,83.77 65.19,83.07 52.39,83.07 52.04,83.42 47.04,83.42 45.32,85.15 38.7,85.15 35.52,81.96 35.52,54.08 37.56,52.04 37.56,46.29 37.98,45.87 37.98,45.18 v4(38.27,44.89)
  IN3 w0.084: v4(38.27,44.89) 38.21,44.89 38.05,44.73 38.05,44.07 37.19,43.21 26.56,43.21 25.45,42.1 25.45,41.96 25.73,41.69 v7(25.78,41.69)
TBT_PCIE_RX2_P_C: length 7.9
  IN2 w0.06: v2(134.41,94.38) 133.24,95.56 132.86,95.56 132,96.42 131.14,96.42 129.77,97.8 129.77,98.64 129.77,98.91 129.78,98.92 129.78,98.92 129.85,98.99 129.85,99.16 129.65,99.36 v2(129.65,99.57)
TBT_PCIE_RX3_N: length 162.4
  TOP w0.076: UT1.H22 23.41,39.99 23.18,40.22 23.18,40.64 23.09,40.72 23.09,40.82
  TOP w0.152: v7(23,41.29) 23.09,41.19 23.09,40.82
  IN2 w0.084: v4(38.04,46.5) 38.27,46.74 38.27,52.01 35.98,54.3 35.98,81.75 38.52,84.3 45.49,84.3 46.83,82.96 51.84,82.96 52.21,82.6 70.89,82.6 71.84,83.55 74.16,83.55 74.39,83.32 94.65,83.32 95.31,82.66 101.89,82.66 102.07,82.83 110.25,82.83 110.7,83.29 125.22,83.29 130.51,88.58 132.68,88.58 134.8,90.69 134.8,92.18 134.65,92.33 134.65,92.47 v2(134.51,92.61)
  IN3 w0.084: v7(23,41.29) 23.08,41.36 23.08,41.86 23.65,42.42 24.65,42.42 26.23,44 36.11,44 38.14,46.03 38.14,46.4 v4(38.04,46.5)
TBT_PCIE_RX3_N_C: length 9
  IN2 w0.06: 134.69,94.27 134.69,94.28 134.71,94.3 134.71,94.43 133.38,95.76 132.83,95.76 132.05,96.54 131.19,96.54 130.06,97.68 130.06,98.56 130.03,98.59 129.9,98.59 129.89,98.6 129.89,98.8 129.92,98.83 v2(129.97,98.83)
  IN2 w0.084: v2(134.51,93.19) 134.49,93.22 134.49,93.37 134.52,93.4 134.78,93.4 134.82,93.44 134.82,93.53 134.69,93.66 134.69,94.27
TBT_PCIE_RX3_P: length 162.2
  TOP w0.152: v7(23.59,41.29) 23.52,41.29 23.43,41.2 23.43,40.42 UT1.H23
  IN2 w0.084: v4(38.57,46.5) 38.43,46.64 38.43,52.08 36.14,54.37 36.14,81.69 38.59,84.13 45.42,84.13 46.76,82.8 51.78,82.8 52.14,82.43 70.95,82.43 71.91,83.39 74.1,83.39 74.32,83.16 94.58,83.16 95.24,82.49 101.96,82.49 102.14,82.67 110.32,82.67 110.77,83.12 125.29,83.12 130.58,88.41 132.75,88.41 134.96,90.63 134.96,92.25 134.82,92.39 134.82,92.51 134.91,92.6 v2(135.08,92.6)
  IN3 w0.084: v4(38.57,46.5) 38.54,46.5 38.31,46.27 38.31,45.97 36.18,43.84 26.3,43.84 24.72,42.26 23.71,42.26 23.24,41.79 23.24,41.57 23.53,41.29 v7(23.59,41.29)
TBT_PCIE_RX3_P_C: length 9.1
  IN2 w0.06: 134.85,94.27 134.85,94.28 134.83,94.3 134.83,94.48 133.43,95.88 132.88,95.88 132.1,96.66 131.24,96.66 130.18,97.73 130.18,98.91 130.14,98.94 130.14,98.94 129.97,99.11 v2(129.97,99.32)
  IN2 w0.084: v2(135.08,93.19) 135.08,93.49 134.85,93.73 134.85,94.27
TBT_PCIE_TX0_N: length 153.8
  TOP w0.152: C1255.1 28.77,43.29 28.77,44.78 v7(28.78,44.8)
  IN1 w0.06: v1(130.29,98.09) 130.29,97.87 130.5,97.67 130.5,97.39 130.36,97.25 130.36,96.42 130.12,96.18 130.12,95.45 129.93,95.26 129.93,94.95 130.15,94.73 130.15,94.47 v3(130.31,94.32)
  IN2 w0.084: v4(129.9,93.47) 129.74,93.63 129.74,93.75 130.12,94.12 130.12,94.13 v3(130.31,94.32)
  IN3 w0.084: v4(129.9,93.47) 129.75,93.32 129.75,93.13 129.56,92.94 128.89,92.94 128.72,92.77 127.56,92.77 127.22,93.11 126.48,93.11 125.68,93.92 124.51,93.92 123.37,95.06 122.56,95.06 121.76,95.86 119.4,95.86 118.49,96.77 118.49,97.09 118.19,97.39 116.85,97.39 116.42,96.96 111.48,96.96 111.22,97.23 110.34,97.23 109.85,97.72 109.25,97.72 108.44,96.91 108.44,95.9 106.5,93.95 106.5,93.01 103.64,90.15 102.79,90.15 101.44,88.81 101.44,88.18 101.06,87.81 98.85,87.81 98.38,87.33 91.5,87.33 88.75,84.58 75.39,84.58 74.8,85.17 64.07,85.17 62.91,86.33 59.06,86.33 58.91,86.49 44.02,86.49 41.16,83.63 38.72,83.63 35.82,80.74 35.82,51.18 31.73,47.09 30.35,47.09 29.05,45.79 29.05,45.18 28.78,44.92 v7(28.78,44.8)
TBT_PCIE_TX0_P: length 153.8
  TOP w0.152: v7(28.2,44.8) 28.23,44.8 28.43,44.59 28.43,43.73 28,43.29 C1254.1
  IN1 w0.06: v3(129.95,94.31) 130.04,94.39 130.04,94.68 129.81,94.9 129.81,95.31 130,95.5 130,96.23 130.24,96.47 130.24,97.31 130.29,97.36 v1(130.29,97.57)
  IN2 w0.084: v3(129.95,94.31) 129.95,94.19 129.57,93.81 129.57,93.67 v4(129.37,93.47)
  IN3 w0.084: v4(129.37,93.47) 129.44,93.47 129.59,93.31 129.59,93.2 129.5,93.1 128.82,93.1 128.66,92.93 127.63,92.93 127.29,93.28 126.55,93.28 125.74,94.08 124.58,94.08 123.44,95.22 122.63,95.22 121.83,96.02 119.47,96.02 118.65,96.84 118.65,97.16 118.26,97.55 116.78,97.55 116.35,97.13 111.55,97.13 111.29,97.39 110.41,97.39 109.92,97.88 109.18,97.88 108.28,96.98 108.28,95.96 106.33,94.02 106.33,93.08 103.57,90.32 102.72,90.32 101.28,88.87 101.28,88.25 101,87.97 98.79,87.97 98.31,87.5 91.43,87.5 88.68,84.75 75.46,84.75 74.87,85.34 64.14,85.34 62.98,86.49 59.13,86.49 58.97,86.65 43.95,86.65 41.1,83.8 38.65,83.8 35.66,80.81 35.66,51.25 31.67,47.25 30.28,47.25 28.89,45.86 28.89,45.25 28.83,45.19 28.49,45.19 28.2,44.91 v7(28.2,44.8)
TBT_PCIE_TX1_N: length 154.9
  TOP w0.152: C1252.1 26.61,43.43 26.61,44.33 26.46,44.48 v7(26.42,44.48)
  IN1 w0.06: v1(130.62,97.84) 130.62,97.84 130.62,97.32 130.49,97.19 130.49,96.25 130.26,96.03 130.26,95.2 v3(130.19,95.13)
  IN2 w0.06: v3(130.19,95.13) 130.19,94.93 130.24,94.88 130.24,94.79 130.13,94.68 129.82,94.68 129.69,94.56 129.59,94.56 129.44,94.7 v4(129.44,94.8)
  IN3 w0.084: v4(129.44,94.8) 129.44,94.75 129.11,94.42 129.11,94.31 128.97,94.16 128.97,93.88 128.45,93.37 127.95,93.37 127.49,93.82 126.62,93.82 125.96,94.48 124.74,94.48 123.47,95.75 122.74,95.75 122.07,96.42 119.63,96.42 119.06,97 119.06,97.39 118.48,97.96 115.73,97.96 115.41,98.28 113.22,98.28 112.71,97.77 111.8,97.77 111.54,98.02 110.67,98.02 110.01,98.68 109.09,98.68 107.65,97.24 107.65,96.22 105.71,94.28 105.71,93.37 103.3,90.97 102.48,90.97 100.71,89.2 98.67,89.2 97.59,88.12 91.17,88.12 88.42,85.37 77.82,85.37 77.61,85.58 75.51,85.58 74.83,86.26 64.1,86.26 63.24,87.12 59.4,87.12 59.23,87.29 43.7,87.29 40.83,84.42 38.39,84.42 35.03,81.07 35.03,51.51 31.4,47.88 30.02,47.88 28.08,45.94 27.99,45.94 27.34,45.28 27.18,45.28 26.78,44.88 26.78,44.78 26.48,44.48 v7(26.42,44.48)
TBT_PCIE_TX1_P: length 154.9
  TOP w0.152: v7(27.01,44.48) 26.94,44.41 26.94,43.34 C1251.1
  IN1 w0.06: v1(130.62,98.34) 130.62,98.13 130.82,97.93 130.82,97.76 130.74,97.68 130.74,97.27 130.61,97.14 130.61,96.2 130.38,95.98 130.38,95.44 130.46,95.36 v3(130.46,94.88)
  IN2 w0.06: v3(130.46,94.88) 130.46,94.84 130.18,94.56 129.87,94.56 129.73,94.42 129.6,94.42 v4(129.47,94.29)
  IN3 w0.084: v4(129.47,94.29) 129.33,94.29 129.13,94.09 129.13,93.81 128.52,93.2 127.88,93.2 127.43,93.66 126.55,93.66 125.89,94.32 124.68,94.32 123.41,95.59 122.67,95.59 122,96.26 119.57,96.26 118.89,96.93 118.89,97.32 118.42,97.8 115.66,97.8 115.34,98.12 113.29,98.12 112.78,97.61 111.73,97.61 111.47,97.86 110.6,97.86 109.94,98.52 109.16,98.52 107.82,97.18 107.82,96.16 105.87,94.21 105.87,93.31 103.37,90.81 102.55,90.81 100.78,89.04 98.74,89.04 97.66,87.96 91.24,87.96 88.49,85.21 77.76,85.21 77.55,85.42 75.44,85.42 74.76,86.1 64.03,86.1 63.17,86.96 59.33,86.96 59.16,87.13 43.77,87.13 40.9,84.26 38.46,84.26 35.2,81 35.2,51.44 31.47,47.72 30.09,47.72 28.15,45.78 28.06,45.78 27.4,45.12 27.25,45.12 26.94,44.81 26.94,44.54 v7(27.01,44.48)
TBT_PCIE_TX2_N: length 155.6
  TOP w0.152: C1257.1 24.93,43.32 24.93,43.71 v7(25,43.78)
  IN1 w0.06: 128.9,94.39 128.94,94.43 128.94,95.61 129.38,96.06 129.38,96.52 129.74,96.88 129.74,97.31 129.85,97.42 129.85,97.67 129.65,97.87 v1(129.65,98.09)
  IN1 w0.089: v3(128.87,94.37) 128.9,94.39
  IN2 w0.06: 128.86,94.27 128.87,94.28 v3(128.87,94.37)
  IN2 w0.084: 128.86,94.27 v4(128.62,94.03)
  IN3 w0.084: v4(128.62,94.03) 128.56,94.09 126.83,94.09 126.2,94.72 124.84,94.72 123.2,96.36 122.53,96.36 122.23,96.66 119.73,96.66 119.35,97.04 119.35,97.54 118.66,98.23 115.82,98.23 115.47,98.58 110.79,98.58 110.15,99.21 108.96,99.21 107.19,97.44 107.19,96.43 105.23,94.47 105.23,93.55 103.11,91.44 102.29,91.44 100.54,89.69 98.5,89.69 97.4,88.59 90.98,88.59 88.48,86.1 85.88,86.1 85.77,86.2 75.61,86.2 75.08,86.73 64.29,86.73 62.9,88.12 61.33,88.12 60.95,88.5 59.92,88.5 59.18,87.76 43.5,87.76 40.63,84.89 38.19,84.89 34.57,81.26 34.57,51.7 31.21,48.35 29.74,48.35 29.28,47.89 28.18,47.89 27.73,47.44 27.73,47.08 26.44,45.79 25.79,45.79 25,45 v7(25,43.78)
TBT_PCIE_TX2_P: length 155.4
  TOP w0.152: C1256.1 24.42,43.25 24.59,43.42 24.59,43.6 v7(24.42,43.78)
  IN1 w0.06: v1(129.65,97.57) 129.65,97.39 129.62,97.36 129.62,96.93 129.26,96.57 129.26,96.11 128.82,95.66 128.82,94.74 128.78,94.7 v3(128.72,94.7)
  IN2 w0.06: v3(128.72,94.7) 128.59,94.7 v4(128.37,94.47)
  IN3 w0.084: v4(128.37,94.47) 128.39,94.45 128.39,94.32 128.32,94.25 126.9,94.25 126.27,94.88 124.91,94.88 123.27,96.52 122.6,96.52 122.3,96.82 119.8,96.82 119.51,97.11 119.51,97.61 118.73,98.39 115.88,98.39 115.54,98.74 110.85,98.74 110.22,99.37 108.89,99.37 107.03,97.5 107.03,96.5 105.06,94.54 105.06,93.62 103.04,91.6 102.22,91.6 100.47,89.85 98.44,89.85 97.33,88.75 90.91,88.75 88.42,86.26 85.95,86.26 85.84,86.37 75.68,86.37 75.15,86.89 64.36,86.89 62.96,88.28 61.4,88.28 61.02,88.66 59.86,88.66 59.11,87.92 43.43,87.92 40.56,85.05 38.13,85.05 34.41,81.33 34.41,51.77 31.14,48.51 29.67,48.51 29.21,48.05 28.11,48.05 27.57,47.51 27.57,47.15 26.37,45.96 25.72,45.96 24.84,45.07 24.84,44.14 24.78,44.08 24.47,44.08 24.42,44.03 v7(24.42,43.78)
TBT_PCIE_TX3_N: length 158.6
  TOP w0.152: v7(23.04,44) 23.24,43.8 23.24,43.48 C1258.1
  IN1 w0.06: v1(129.97,97.84) 129.97,97.37 129.87,97.27 129.87,96.59 129.61,96.32 129.61,95.57 129.41,95.37 129.22,95.37 129.16,95.43 v3(129.16,95.5)
  IN2 w0.06: v4(127.95,95.05) 128.25,95.36 129.03,95.36 v3(129.16,95.5)
  IN3 w0.084: v7(23.04,44) 23.15,44 23.23,44.08 23.23,44.89 24.96,46.61 26.14,46.61 26.93,47.4 26.93,47.76 27.9,48.73 28.89,48.73 29.3,49.14 30.88,49.14 33.78,52.03 33.78,81.6 37.85,85.68 39.66,85.68 42.75,88.76 48,88.76 48.9,89.67 49.76,89.67 50.58,88.85 58.68,88.85 59.15,89.32 61.34,89.32 61.69,88.97 63.22,88.97 64.67,87.52 75.41,87.52 75.89,87.04 85.6,87.04 86.15,87.59 88.86,87.59 90.65,89.38 97.07,89.38 98.18,90.48 100.2,90.48 101.95,92.23 102.78,92.23 104.43,93.87 104.43,94.79 106.4,96.76 106.4,97.77 108.2,99.57 108.2,100.02 108.51,100.34 110.26,100.34 110.83,99.77 115.5,99.77 116,99.27 118.5,99.27 119.77,98 120.49,98 120.86,97.63 122.12,97.63 122.84,96.92 123.44,96.92 125.07,95.28 126.57,95.28 126.84,95.55 127.22,95.55 127.59,95.18 127.59,94.9 127.74,94.75 127.88,94.75 128.01,94.88 128.01,94.99 v4(127.95,95.05)
TBT_PCIE_TX3_P: length 158.7
  TOP w0.152: C1253.1 23.58,43.34 23.58,43.94 v7(23.63,44)
  IN1 w0.06: v3(129.16,95.13) 129.26,95.23 129.27,95.23 129.28,95.25 129.46,95.25 129.73,95.52 129.73,96.28 129.99,96.54 129.99,97.22 130.09,97.32 130.09,97.66 130.17,97.74 130.17,97.93 129.97,98.13 v1(129.97,98.34)
  IN2 w0.06: v4(128.47,95.05) 128.64,95.23 129.06,95.23 v3(129.16,95.13)
  IN3 w0.084: v4(128.47,95.05) 128.44,95.05 128.09,94.7 128.06,94.7 127.95,94.59 127.68,94.59 127.43,94.83 127.43,95.11 127.16,95.39 126.91,95.39 126.64,95.12 125.01,95.12 123.37,96.76 122.77,96.76 122.06,97.47 120.8,97.47 120.42,97.84 119.7,97.84 118.43,99.11 115.93,99.11 115.43,99.6 110.76,99.6 110.19,100.18 108.58,100.18 108.36,99.96 108.36,99.5 106.56,97.7 106.56,96.69 104.59,94.72 104.59,93.8 102.85,92.06 102.01,92.06 100.27,90.32 98.24,90.32 97.14,89.22 90.72,89.22 88.93,87.43 86.22,87.43 85.66,86.88 75.82,86.88 75.35,87.35 64.6,87.35 63.15,88.81 61.63,88.81 61.27,89.16 59.22,89.16 58.75,88.69 50.51,88.69 49.69,89.51 48.97,89.51 48.06,88.6 42.82,88.6 39.73,85.52 37.92,85.52 33.94,81.54 33.94,51.96 30.95,48.97 29.37,48.97 28.95,48.56 27.96,48.56 27.09,47.69 27.09,47.34 26.21,46.45 25.03,46.45 23.4,44.82 23.4,44.23 v7(23.63,44)
TBT_PCIE_WAKE_N: length 3.4
  TOP w0.119: RT4.1 28.61,27.81 28.61,28.48 28.78,28.66 R1399.1 28.95,28.95 28.47,29.43 UT1.W1
TBT_PERST_N: length 3.3
  IN1 w0.089: v1(24.6,31.44) 24.64,31.4 24.64,30.5 24.86,30.29 24.86,28.83 v1(25.28,28.41)
TBT_RBIAS: length 5.9
  TOP w0.119: UT1.H6 v1(23.63,32.57)
  IN1 w0.089: v1(24.4,27.49) 24.4,27.9 24.06,28.24 24.06,28.85 23.87,29.04 23.87,31.42 24.06,31.61 24.06,31.98 23.63,32.42 v1(23.63,32.57)
TBT_REFCLK_100_N: length 145.5
  TOP w0.152: R1417.1 30.75,44.34 L62.3 30.75,44.9 30.65,44.99 v7(30.65,45.43)
  IN1 w0.06: 123.87,94.9 123.87,94.91 123.82,94.96 123.82,95.09 124.71,95.98 125.09,95.98 126.22,97.11 126.22,98.26 126.02,98.46 126.02,98.56 125.46,99.11 v1(125.46,99.32)
  IN1 w0.089: v5(107.66,88.62) 107.75,88.71 115.09,88.71 115.37,88.43 118.8,88.43 119.18,88.81 119.79,88.81 119.91,88.92 121.24,88.92 121.72,89.4 122.4,89.4 123.03,90.04 123.03,90.61 124.11,91.69 124.11,93.42 123.81,93.72 123.81,94.59 123.87,94.65 123.87,94.9
  GND1 w0.089: v5(107.66,88.62) 107.57,88.72 107.02,88.72 v4(106.84,88.54)
  IN3 w0.084: v7(30.65,45.43) 30.44,45.65 30.44,45.78 30.87,46.21 32.19,46.21 36.63,50.65 36.63,80.42 39.09,82.88 41.56,82.88 44.3,85.61 45.49,85.61 45.98,85.12 54.23,85.12 54.44,85.33 58.38,85.33 58.59,85.12 61.42,85.12 62.39,84.14 74.23,84.14 74.87,83.5 89.15,83.5 92.27,86.62 99.01,86.62 99.53,86.1 101.25,86.1 101.39,86.24 101.39,87.03 102.18,87.82 102.18,88.62 102.52,88.96 104.07,88.96 104.3,88.73 106.65,88.73 v4(106.84,88.54)
TBT_REFCLK_100_N_R: length 9.3
  TOP w0.152: R1417.2 30.75,43.21 L62.4 v2(30.75,42.8)
  IN2 w0.084: v2(27.2,38.59) 27.45,38.35 27.45,37.83 27.67,37.61 29.62,37.61 30.43,38.42 30.43,42.48 v2(30.75,42.8)
TBT_REFCLK_100_P: length 144.9
  TOP w0.152: R1410.1 29.95,44.34 L62.2 29.95,44.91 30.07,45.03 v7(30.07,45.43)
  IN1 w0.06: v1(125.46,98.83) 125.58,98.83 125.9,98.51 125.9,98.41 126.1,98.21 126.1,97.16 125.04,96.1 124.66,96.1 123.7,95.14 123.7,94.96 123.65,94.91 123.65,94.9
  IN1 w0.089: 123.65,94.9 123.65,94.74 123.59,94.68 123.59,93.63 123.89,93.33 123.89,91.78 122.82,90.7 122.82,90.13 122.31,89.62 121.63,89.62 121.15,89.14 119.82,89.14 119.7,89.02 119.09,89.02 118.71,88.64 115.46,88.64 115.18,88.92 107.75,88.92 v5(107.66,89.01)
  GND1 w0.089: v4(106.84,89.07) 106.98,88.93 107.59,88.93 v5(107.66,89.01)
  IN3 w0.084: v4(106.84,89.07) 106.65,88.89 104.37,88.89 104.14,89.12 102.45,89.12 102.02,88.68 102.02,87.88 101.23,87.1 101.23,86.31 101.19,86.27 99.59,86.27 99.08,86.78 92.2,86.78 89.08,83.66 74.94,83.66 74.3,84.3 62.46,84.3 61.48,85.28 58.65,85.28 58.45,85.49 54.37,85.49 54.16,85.28 46.05,85.28 45.56,85.77 44.23,85.77 41.5,83.04 39.02,83.04 36.47,80.49 36.47,50.72 32.12,46.38 30.8,46.38 30.27,45.85 30.27,45.64 v7(30.07,45.43)
TBT_REFCLK_100_P_R: length 8.8
  TOP w0.152: v2(29.95,42.8) L62.1 29.95,43.21 R1410.2
  IN2 w0.084: v2(29.95,42.8) 30.27,42.48 30.27,38.49 29.56,37.78 27.73,37.78 27.61,37.9 27.61,38.35 v2(27.85,38.59)
TBT_RESET_N: length 60
  TOP w0.119: v1(31.03,54.22) 31.62,54.81 D101.2 ; D100.2 33.05,35.44 33.05,41.76 32.81,41.99 30.57,41.99 v1(30.4,42.16)
  IN1 w0.089: v10(22.65,31.44) 22.84,31.25 22.84,28.11 22.78,28.05 22.78,27.82 22.84,27.76 22.84,27.59 23.06,27.38 v1(23.06,27.34) ; v3(24.15,33.52) 24.15,33.5 24.21,33.44 25.2,33.44 25.36,33.6 25.36,34.03 25.78,34.45 27.36,34.45 27.57,34.25 27.57,33.22 27.68,33.1 28.82,33.1 29.57,33.85 29.57,36.9 29.66,36.99 29.66,40.08 30.32,40.74 30.32,42.08 v1(30.4,42.16) 30.53,42.16 31.29,42.92 31.29,43.65 32.06,44.41 32.06,44.58 32.41,44.92 32.41,50.12 32.12,50.4 32.12,51.32 31.03,52.42 v1(31.03,54.22) 30.68,54.57 30.68,59.18 27.6,62.26 v1(27.6,63.51)
  GND1 w0.119: v10(22.65,31.44) 22.86,31.24 v4(22.86,31.07)
  IN2 w0.084: v4(22.86,31.07) 22.53,31.4 22.53,32.24 22.97,32.67 22.97,33.07 23.41,33.52 v3(24.15,33.52)
  GND4 w0.119: v4(22.86,31.07) 22.7,30.92 v9(22.7,30.72)
TBT_RSENSE: length 4.7
  IN1 w0.089: v1(23.95,32.74) 24.26,32.43 24.26,31.54 24.06,31.34 24.06,29.31 24.4,28.96 v1(24.4,28.41)
TBT_SLP_S3_N: length 1.7
  GND1 w0.119: v10(21.57,30.74) 21.5,30.74 21.16,30.41 v4(21.16,30.4)
  GND4 w0.119: v9(20.85,30.79) 20.85,30.72 v4(21.16,30.4)
  BOTTOM w0.119: RT9.1 v9(20.85,30.79)
TBT_SNK0_AUX_N: length 77.4
  TOP w0.152: UT1.W11 v7(28.83,35.01)
  IN2 w0.084: v7(28.83,35.01) 28.9,34.95 29.35,34.95 29.51,35.1 29.51,35.6 30.34,36.42 31.39,36.42 31.73,36.08 33.29,36.08 35.29,38.08 35.29,42.73 34.2,43.82 34.2,50.98 32.4,52.78 32.4,85.84 34.21,87.65 35.68,87.65 38.34,90.32 43.84,90.32 45.06,89.1 47.09,89.1 48.1,88.09 48.1,87.48 v2(48.46,87.11)
TBT_SNK0_AUX_N_L: length 4.6
  TOP w0.152: U23.29 49.51,89.98 49.45,90.04 49.08,90.04 49.02,89.98 48.3,89.98 47.95,89.62 47.95,89.52 48.04,89.43 48.47,89.43 R126.1 48.36,89.15 48.3,89.15 48.19,89.03 48.19,88.3 C1396.1
TBT_SNK0_AUX_P: length 77.4
  TOP w0.152: UT1.Y11 v7(28.83,34.36)
  IN2 w0.084: v2(47.57,87.11) 47.69,87.23 47.77,87.23 47.94,87.4 47.94,88.02 47.02,88.93 44.99,88.93 43.77,90.15 38.41,90.15 35.75,87.49 34.27,87.49 32.56,85.77 32.56,52.85 34.36,51.05 34.36,43.89 35.45,42.8 35.45,38.01 33.36,35.91 31.66,35.91 31.32,36.26 30.41,36.26 29.67,35.53 29.67,35.03 29.42,34.78 29.14,34.78 28.83,34.47 v7(28.83,34.36)
TBT_SNK0_AUX_P_L: length 4.7
  TOP w0.152: C1395.1 47.85,88.3 47.85,89.02 47.67,89.2 47.63,89.2 R129.1 47.61,89.47 47.61,89.76 48.16,90.32 48.88,90.32 48.94,90.38 49.53,90.38 49.54,90.38 49.93,90.38 49.93,90.38 U23.28
TBT_SNK0_DDC_CLK: length 3.6
  TOP w0.076: UT1.Y5 v7(28.83,32.41)
  BOTTOM w0.119: R1391.1 30.32,34.55 30.32,33.37 29.36,32.41 v7(28.83,32.41)
TBT_SNK0_DDC_DATA: length 6.3
  GND1 w0.119: v10(26.55,31.44) v4(26.24,31.75)
  GND4 w0.119: v9(26.54,31.24) 26.54,31.46 v4(26.24,31.75)
  BOTTOM w0.119: v9(26.54,31.24) 26.7,31.07 28.05,31.07 28.42,31.45 28.78,31.45 30.66,33.33 R1394.1
TBT_SNK0_HPD: length 331.6
  TOP w0.076: UT1.AA2 29.62,30.51 29.62,30.08
  TOP w0.102: 29.62,30.08 30.02,29.69 30.93,29.69 31.97,28.65 R1413.1
  TOP w0.119: R1413.1 32.28,28.53 v2(32.39,28.42) ; U23.38 v1(53.43,88.08) ; R5675.2 223.2,137.38 v10(223.98,136.6)
  IN1 w0.089: v3(36.38,27.41) 36.88,27.91 36.88,37.13 37.44,37.7 37.44,54.35 35.74,56.06 35.74,63.89 34.42,65.21 34.42,75.7 35.41,76.69 35.41,81.26 39.17,85.03 39.42,85.03 40.23,85.84 v8(40.47,85.84) 40.71,85.59 43.25,85.59 45.17,87.52 45.17,91.9 46.01,92.74 49.69,92.74 50.37,92.06 50.37,88.96 51.26,88.08 v1(53.43,88.08)
  GND1 w0.119: v10(223.98,136.6) v4(224.49,136.6) ; v4(40.95,85.94) 40.85,85.84 v8(40.47,85.84)
  IN2 w0.084: v4(49.76,80.7) 50.09,80.38 131.72,80.38 133.33,82 133.33,82.86 133.9,83.43 141.84,83.43 144.19,85.78 149.07,85.78 150.65,87.37 160.42,87.37 161.13,86.66 167.78,86.66 168.5,85.94 175.32,85.94 176.14,85.11 189.51,85.11 192.19,87.79 198.26,87.79 200.07,89.59 200.07,97.65 199.66,98.06 199.66,102.54 199.14,103.06 199.14,104.85 200.52,106.24 202.52,106.24 203.25,106.98 206.48,106.98 207.13,107.63 208.03,107.63 208.59,108.19 v4(208.59,108.42) ; v3(36.38,27.41) 33.4,27.41 v2(32.39,28.42)
  IN3 w0.084: v4(224.49,136.6) 225.61,135.47 225.61,126.95 224.97,126.31 224.97,125.66 224.24,124.93 224.24,121.93 219.46,117.16 217.9,117.16 217.06,116.31 216.82,116.31 214.79,114.28 213.57,114.28 v6(213.48,114.19)
  GND4 w0.119: v4(49.76,80.7) 49.64,80.83 49.64,81.06 49.28,81.42 v9(49.26,81.42) ; v4(40.95,85.94) 41.36,85.94 v9(41.41,85.89) ; v9(208.06,110.1) 208.36,109.8 208.36,108.64 v4(208.59,108.42)
  BOTTOM w0.119: v6(213.48,114.19) 213.48,112.3 212.52,111.34 209.29,111.34 v9(208.06,110.1) ; v9(49.26,81.42) 49.26,81.54 48.47,82.33 47.14,82.33 45.72,83.74 45.49,83.74 43.35,85.89 v9(41.41,85.89)
TBT_SNK0_ML0_N: length 80.6
  TOP w0.076: UT1.AC7 30.18,33.04 30.12,33.1 30.12,33.19 30.2,33.27 30.52,33.27
  TOP w0.119: 30.52,33.27 30.72,33.07 30.87,33.07 v2(30.91,33.11)
  IN2 w0.084: v2(53.57,85.72) 53.83,85.47 53.9,85.47 53.98,85.38 53.98,84.97 53.23,84.22 47.37,84.22 44.88,86.71 40.84,86.71 40.13,87.41 38.71,87.41 34.6,83.31 34.6,53.7 36.76,51.54 36.76,45.96 37,45.71 37,44.19 37.5,43.69 37.5,37.15 33.69,33.35 31.58,33.35 31.23,33 31.02,33 v2(30.91,33.11)
TBT_SNK0_ML0_N_L: length 2.7
  TOP w0.152: U23.39 53.83,88.35 53.85,88.32 53.85,87.18 53.67,86.99 53.67,86.4 C128.1
TBT_SNK0_ML0_P: length 80.7
  TOP w0.076: UT1.AB7 30.08,32.81 30.66,32.81
  TOP w0.119: v2(30.91,32.73) 30.83,32.81 30.66,32.81
  IN2 w0.084: v2(30.91,32.73) 31.02,32.84 31.3,32.84 31.65,33.19 33.76,33.19 37.66,37.09 37.66,43.76 37.17,44.25 37.17,45.78 36.92,46.02 36.92,51.61 34.76,53.77 34.76,83.24 38.77,87.25 40.07,87.25 40.77,86.55 44.81,86.55 47.3,84.06 53.3,84.06 54.15,84.91 54.15,85.66 v2(54.21,85.72)
TBT_SNK0_ML0_P_L: length 2.8
  TOP w0.152: C134.1 54.01,86.51 54.01,86.85 54.19,87.04 54.19,88.28 54.23,88.32 U23.40
TBT_SNK0_ML1_N: length 80.5
  TOP w0.076: 30.72,33.96 30.49,34.19 30.21,34.19 30.13,34.11 30.13,33.99 30.16,33.96 UT1.AC9
  TOP w0.081: 30.72,33.96 30.73,33.96
  TOP w0.119: 30.73,33.96 30.85,33.96 v2(30.92,34.03)
  IN2 w0.084: v2(30.92,34.03) 31.01,33.93 31.03,33.93 31.11,33.85 31.31,33.85 31.39,33.93 31.39,34.14 31.52,34.27 31.96,34.27 32.11,34.13 32.11,33.94 32.14,33.9 32.44,33.9 32.49,33.96 32.49,34.12 32.64,34.27 33.07,34.27 33.21,34.13 33.21,33.95 33.26,33.9 33.47,33.9 36.95,37.38 36.95,43.46 36.37,44.03 36.37,45.56 36.21,45.72 36.21,51.31 34.05,53.47 34.05,83.58 35.29,84.82 35.29,84.94 35.16,85.07 35.16,85.3 35.44,85.58 35.66,85.58 35.8,85.45 35.91,85.45 38.43,87.97 40.47,87.97 41.14,87.29 45.08,87.29 47.6,84.78 52.24,84.78 52.66,85.2 52.66,85.49 52.43,85.72 v2(52.3,85.72)
TBT_SNK0_ML1_N_L: length 2.8
  TOP w0.152: C147.1 52.48,86.48 52.48,87.35 52.67,87.53 52.67,88.29 52.63,88.33 U23.36
TBT_SNK0_ML1_P: length 80.5
  TOP w0.076: 30.7,33.73 30.12,33.73 29.89,33.96 UT1.AB9
  TOP w0.081: 30.7,33.73 30.73,33.7
  TOP w0.119: v2(30.92,33.65) 30.86,33.7 30.73,33.7
  IN2 w0.084: v2(30.92,33.65) 30.96,33.69 31.38,33.69 31.55,33.87 31.55,34.07 31.59,34.11 31.9,34.11 31.94,34.06 31.94,33.87 32.07,33.74 32.51,33.74 32.66,33.89 32.66,34.05 32.71,34.11 33,34.11 33.05,34.06 33.05,33.89 33.19,33.74 33.53,33.74 37.11,37.31 37.11,43.53 36.53,44.1 36.53,45.63 36.37,45.79 36.37,51.38 34.21,53.54 34.21,83.51 35.45,84.76 35.45,85.01 35.32,85.14 35.32,85.23 35.51,85.42 35.6,85.42 35.73,85.29 35.98,85.29 38.5,87.8 40.4,87.8 41.08,87.13 45.02,87.13 47.53,84.62 52.31,84.62 52.83,85.13 52.83,85.61 v2(52.94,85.72)
TBT_SNK0_ML1_P_L: length 2.7
  TOP w0.152: U23.37 53.03,88.31 53,88.29 53,87.39 52.82,87.21 52.82,86.42 C136.1
TBT_SNK0_ML2_N: length 80.3
  TOP w0.076: 30.73,34.95 30.56,35.11 30.18,35.11 30.11,35.03 30.11,34.93 30.16,34.88 UT1.AC11
  TOP w0.119: 30.73,34.95 30.76,34.92 30.87,34.92 v2(30.95,34.99)
  TOP w0.152: C154.2 v2(51.03,85.75)
  IN2 w0.084: v2(51.03,85.75) 51.19,85.75 51.31,85.62 51.31,85.48 51.17,85.34 50.86,85.34 50.63,85.57 50.07,85.57 49.84,85.34 47.9,85.34 45.36,87.88 41.43,87.88 40.76,88.54 38.19,88.54 36.2,86.55 35.63,86.55 35.21,86.12 35.14,86.12 34.81,86.45 34.57,86.45 34.31,86.19 34.31,85.95 34.63,85.63 34.63,85.55 34.37,85.29 34.37,85.05 34.48,84.94 34.48,84.79 34.36,84.67 34.2,84.67 34.09,84.78 33.86,84.78 33.5,84.42 33.5,53.24 35.31,51.42 35.31,51.19 35.49,51.01 35.56,51.01 35.65,50.93 35.65,50.68 35.56,50.59 35.49,50.59 35.31,50.42 35.31,50.03 35.49,49.85 35.56,49.85 35.65,49.77 35.65,49.52 35.56,49.43 35.49,49.43 35.31,49.25 35.31,47.21 35.49,47.03 35.58,47.03 35.66,46.95 35.66,46.69 35.58,46.61 35.49,46.61 35.31,46.43 35.31,44.29 36.39,43.21 36.39,37.61 33.6,34.82 31.12,34.82 v2(30.95,34.99)
TBT_SNK0_ML2_N_L: length 3
  TOP w0.152: U23.34 51.83,88.34 51.89,88.28 51.89,87.71 51.11,86.93 51.11,86.39 51.11,86.38 C154.1
TBT_SNK0_ML2_P: length 80.4
  TOP w0.076: UT1.AB11 30.08,34.65 30.59,34.65
  TOP w0.119: 30.59,34.65 30.91,34.65 v2(30.95,34.61)
  TOP w0.152: C152.2 v2(51.67,85.75)
  IN2 w0.084: v2(51.67,85.75) 51.57,85.75 51.48,85.65 51.48,85.41 51.24,85.17 50.79,85.17 50.56,85.41 50.14,85.41 49.91,85.17 47.83,85.17 45.29,87.71 41.36,87.71 40.7,88.37 38.26,88.37 36.27,86.38 35.7,86.38 35.27,85.96 35.07,85.96 34.74,86.29 34.64,86.29 34.47,86.12 34.47,86.01 34.79,85.69 34.79,85.48 34.54,85.22 34.54,85.12 34.64,85.01 34.64,84.72 34.42,84.51 34.14,84.51 34.02,84.62 33.93,84.62 33.66,84.35 33.66,53.31 35.48,51.49 35.48,51.26 35.56,51.18 35.63,51.18 35.81,51 35.81,50.61 35.63,50.43 35.56,50.43 35.48,50.35 35.48,50.1 35.56,50.01 35.63,50.01 35.81,49.83 35.81,49.45 35.63,49.27 35.56,49.27 35.48,49.18 35.48,47.27 35.56,47.19 35.65,47.19 35.82,47.02 35.82,46.62 35.65,46.45 35.56,46.45 35.48,46.36 35.48,44.36 36.56,43.28 36.56,37.54 33.67,34.66 30.99,34.66 v2(30.95,34.61)
TBT_SNK0_ML2_P_L: length 3
  TOP w0.152: U23.35 52.23,88.35 52.22,88.34 52.22,87.57 51.45,86.79 51.45,86.53 C152.1
TBT_SNK0_ML3_N: length 79.8
  TOP w0.076: 30.63,35.7 30.5,35.57 30.21,35.57 30.13,35.64 30.13,35.73 30.2,35.8 UT1.AC13
  TOP w0.119: 30.63,35.7 30.69,35.7 v2(30.8,35.59)
  TOP w0.152: C202.2 v2(48.88,85.77)
  IN2 w0.084: v2(48.88,85.77) 49.05,85.77 49.25,85.96 49.25,86.12 48.87,86.5 47.52,86.5 45.72,88.3 44.03,88.3 43.85,88.48 43.85,88.77 43.77,88.84 43.51,88.84 43.43,88.77 43.43,88.48 43.25,88.3 42.87,88.3 42.69,88.48 42.69,88.93 42.6,89.01 42.35,89.01 42.27,88.93 42.27,88.48 42.09,88.3 41.64,88.3 41,88.93 40.21,88.93 40.03,89.11 40.03,89.49 39.92,89.6 39.76,89.6 39.65,89.49 39.65,89.11 39.47,88.93 39.11,88.93 38.93,89.11 38.93,89.49 38.82,89.6 38.66,89.6 38.54,89.49 38.54,89.11 38.36,88.93 38,88.93 36.01,86.94 34.5,86.94 33.11,85.54 33.11,53.08 34.92,51.27 34.92,44.11 36.01,43.02 36.01,37.77 33.58,35.34 31.45,35.34 31.09,35.7 30.85,35.7 30.8,35.64 v2(30.8,35.59)
TBT_SNK0_ML3_N_L: length 3.6
  TOP w0.152: U23.31 50.63,88.37 50.68,88.32 50.68,88.02 50.24,87.58 49.76,87.58 49.01,86.83 49.01,86.44 C202.1
TBT_SNK0_ML3_P: length 79.8
  TOP w0.076: UT1.AB13 29.88,35.8 30.11,36.03 30.53,36.03
  TOP w0.119: 30.53,36.03 30.59,35.97 v2(30.8,35.97)
  TOP w0.152: C155.2 v2(49.51,85.77)
  IN2 w0.084: v2(30.8,35.97) 30.91,35.86 31.16,35.86 31.52,35.5 33.51,35.5 35.84,37.84 35.84,42.96 34.76,44.04 34.76,51.2 32.95,53.01 32.95,85.61 34.44,87.1 35.94,87.1 37.94,89.1 38.3,89.1 38.38,89.18 38.38,89.56 38.59,89.76 38.89,89.76 39.09,89.56 39.09,89.18 39.18,89.1 39.4,89.1 39.48,89.18 39.48,89.56 39.69,89.76 39.99,89.76 40.2,89.56 40.2,89.18 40.28,89.1 41.07,89.1 41.7,88.46 42.02,88.46 42.1,88.54 42.1,89 42.28,89.17 42.67,89.17 42.85,89 42.85,88.54 42.93,88.46 43.18,88.46 43.27,88.54 43.27,88.84 43.44,89.01 43.84,89.01 44.01,88.84 44.01,88.54 44.1,88.46 45.79,88.46 47.59,86.66 48.94,86.66 49.41,86.19 49.41,85.87 v2(49.51,85.77)
TBT_SNK0_ML3_P_L: length 3.6
  TOP w0.152: U23.32 51.03,88.35 51.02,88.34 51.02,87.88 50.38,87.24 49.9,87.24 49.35,86.69 49.35,86.47 C155.1
TBT_SNK1_AUX_N: length 179
  IN2 w0.06: v2(123.85,99.57) 123.85,99.36 123.65,99.16 123.65,98.99 123.7,98.94 123.7,98.94 123.73,98.91 123.73,97.73 123.64,97.64 123.64,95.57 123.55,95.48 123.51,95.48
  IN2 w0.084: v2(32.63,37) 33.39,37 34.73,38.34 34.73,42.22 33.64,43.31 33.64,50.47 31.62,52.49 31.62,61.04 29.14,63.52 29.14,65.84 21.73,73.26 21.73,79.26 23.81,81.35 23.81,93.77 23.82,93.78 23.82,95.21 24.79,96.18 29.36,96.18 30.34,97.16 32.66,97.16 33.16,97.67 34.96,97.67 35.73,96.89 45.97,96.89 46.02,96.95 50.76,96.95 51.76,95.94 60.66,95.94 65.66,90.95 74.9,90.95 75.34,90.51 87.08,90.51 88.29,89.3 102.31,89.3 102.49,89.12 103.27,89.12 103.36,89.03 105.43,89.03 106.1,89.71 107.36,89.71 108.11,88.96 109.19,88.96 109.41,88.74 110.39,88.74 110.82,89.17 112.5,89.17 112.69,88.99 114.35,88.99 114.7,89.34 116.31,89.34 116.89,89.92 117.93,89.92 118.08,90.07 118.08,90.3 118.43,90.65 120.1,90.65 122.34,92.9 122.34,94.32 123.51,95.48
TBT_SNK1_AUX_P: length 178.9
  IN2 w0.06: v2(123.85,99.07) 123.85,97.68 123.76,97.59 123.76,95.52 123.6,95.37 123.6,95.35
  IN2 w0.084: 123.6,95.35 122.51,94.25 122.51,92.83 120.16,90.49 118.5,90.49 118.24,90.23 118.24,90 118,89.75 116.96,89.75 116.38,89.17 114.76,89.17 114.42,88.83 112.62,88.83 112.44,89.01 110.89,89.01 110.45,88.58 109.34,88.58 109.12,88.8 108.04,88.8 107.29,89.54 106.17,89.54 105.49,88.87 103.3,88.87 103.21,88.96 102.42,88.96 102.24,89.14 88.22,89.14 87.01,90.35 75.28,90.35 74.83,90.79 65.59,90.79 60.6,95.78 51.69,95.78 50.69,96.78 46.09,96.78 46.03,96.73 35.67,96.73 34.89,97.51 33.23,97.51 32.72,97 30.41,97 29.43,96.02 24.86,96.02 23.98,95.14 23.98,93.71 23.98,93.7 23.98,81.28 21.89,79.19 21.89,73.33 29.3,65.91 29.3,63.59 31.78,61.11 31.78,52.56 33.8,50.54 33.8,43.38 34.89,42.29 34.89,38.27 33.46,36.84 33.04,36.84 32.99,36.79 32.99,36.65 32.93,36.59 32.7,36.59 32.63,36.53 v2(32.63,36.43)
TBT_SNK1_DDC_CLK: length 1
  TOP w0.102: v7(28.83,33.71) UT1.Y8
  BOTTOM w0.127: R1395.1 28.83,33.71 v7(28.83,33.71)
TBT_SNK1_DDC_DATA: length 1.2
  TOP w0.102: v7(25.58,31.76) UT1.N4
  BOTTOM w0.127: R1396.1 25.36,31.31 25.36,31.54 v7(25.58,31.76)
TBT_SNK1_HPD: length 270.8
  TOP w0.119: v2(32.23,32.74) R1414.1
  IN1 w0.089: v5(97.72,123.93) 97.72,122.87 96.63,121.78 96.63,112.23 96.18,111.78 96.18,106.35 95.38,105.55 95.38,101.96 92.88,99.46 92.88,98.34 91.75,97.21 91.75,95.05 88.17,91.47 76.88,91.47 76.1,90.7 66.06,90.7 62.28,94.48 58.33,94.48 58.14,94.29 57.13,94.29 56.01,95.41 54.16,95.41 52.43,93.68 49.72,93.68 49.36,93.33 45.37,93.33 43.55,91.51 43.03,91.51 42.57,91.05 41.36,91.05 37.88,87.57 37.88,84.81 35.01,81.93 35.01,81.93 34.83,81.76 34.83,76.92 33.85,75.93 33.85,64.97 35.16,63.66 35.16,55.83 36.87,54.12 36.87,38.79 36.03,37.95 v3(36.03,34.73)
  GND1 w0.119: v5(97.72,123.93) 97.83,123.82 v4(98.16,123.82)
  IN2 w0.06: 136.9,95.93 136.9,96.23 136.47,96.66 136.47,97.29 136.64,97.46 136.64,97.92 136,98.56 134.98,98.56 134.78,98.76 134.78,98.99 134.91,99.12 134.91,99.37 134.71,99.56 134.34,99.56 133.95,99.96 v2(133.17,99.96)
  IN2 w0.084: v2(29.15,32.74) 30.43,32.74 30.73,32.44 31.93,32.44 v2(32.23,32.74) 34.04,32.74 v3(36.03,34.73) ; 136.9,95.93 138.69,94.14 138.69,92.08 139.6,91.16 143.36,91.16 144.42,90.1 147.28,90.1 v4(147.45,89.92)
  GND3 w0.119: v4(151.21,115.35) 150.5,116.06 148.47,116.06 147.4,114.99 146.44,114.99 144.92,113.48 141.37,113.48 141.05,113.8 139.08,113.8 138.89,113.99 137.69,113.99 137.45,114.22 135.14,114.22 134.83,113.91 121.72,113.91 117.11,118.53 114.33,118.53 113.35,119.52 112.39,119.52 111.27,120.63 101.78,120.63 98.6,123.82 v4(98.16,123.82)
  IN3 w0.076: v4(151.21,115.35) 151.21,114.88 152.32,113.77 152.32,109.79 151.78,109.25 151.49,109.25 151.48,109.26 v6(151.48,109.27)
  IN3 w0.084: v6(154.59,104.38) 154.14,104.38 153.11,103.35 153.11,103 152.51,102.4 v6(152.51,102.27)
  GND4 w0.119: v9(147.96,89.34) 147.45,89.85 v4(147.45,89.92)
  BOTTOM w0.119: v6(152.51,102.27) 152.55,102.23 152.55,98.61 152.72,98.45 152.72,94.29 151.85,93.42 151.85,92.83 148.36,89.34 v9(147.96,89.34) ; v6(154.59,104.38) 152.01,106.95 152.01,108.81 151.56,109.27 v6(151.48,109.27)
