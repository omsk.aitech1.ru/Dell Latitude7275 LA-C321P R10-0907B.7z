# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_TBT_SX: length 24
  TOP w0.203: UT1.F8 v7(22.33,33.06)
  TOP w0.305: R1400.2 v10(28.95,28.08)
  TOP w0.381: R5756.2 v10(23.64,26.81) ; R1397.2 v10(26.98,27.99)
  GND1 w0.381: v10(23.64,26.81) 23.6,26.84 v4(23.6,27.48) ; v12(26.54,27.8) 26.79,27.8 v10(26.98,27.99)
  GND1 w0.508: v10(22.47,27.94) 22.47,27.78 v4(22.17,27.48) ; v10(21.02,24.72) 21.47,25.17 21.47,25.24 v4(21.47,25.25) ; v10(28.95,28.08) 28.81,28.08 v12(28.54,28.34)
  IN2 w0.508: v4(22.17,27.48) v4(23.6,27.48) 25.04,27.48 25.36,27.8 v12(26.54,27.8) 27.45,27.8 27.68,28.02 28.23,28.02 v12(28.54,28.34) ; v7(22.33,33.06) 22.33,32.87 21.88,32.42 21.88,31.68 21.56,31.35 21.56,30.87 22.08,30.35 v4(22.08,30.2)
  IN3 w0.508: v4(21.47,25.25) 20.54,25.25 20.07,25.71 20.07,26.21 20.57,26.7 21.6,26.7 22.17,27.28 v4(22.17,27.48) 22.59,27.9 v4(22.59,29.84)
  GND4 w0.381: v4(23.6,27.48) 23.96,27.83 v9(24.09,27.83)
  BOTTOM w0.356: C1284.1 22.1,32.72 22.33,32.95 v7(22.33,33.06)
  vias: v9(22.08,29.75)
+3VA_S: length 17.3
  IN2 w0.254: v2(169.99,124.4) 170.01,124.42 170.25,124.42 v4(170.35,124.52)
  IN3 w0.508: v7(183.47,122.06) 183.06,121.65 177.3,121.65 176.76,122.18 176.76,124.21 175.06,125.92 173.01,125.92 172.22,125.13 171.71,125.13 171.66,125.18 171.15,125.18 170.49,124.52 v4(170.35,124.52)
+3VALW: length 98.1
  TOP w0.254: U711.6 187.3,105.15 C1223.1 ; v7(192.79,128.16) 193.27,128.64 U31.1
  TOP w0.305: v7(192.95,127.45) 193.33,127.83 C216.1 ; JAPS2.3 v7(223.77,142.82)
  TOP w0.508: R157.1 235.87,129.19 v2(236.07,129.4) ; PQ211.1 55.93,139.63 v7(55.54,139.25) ; R218.1 237.45,133.08 236.96,132.6 v7(236.96,132.25) ; v7(23.63,25.95) 23.98,25.6 RA51.2
  IN1 w0.508: v7(55.54,139.25) 55.49,139.3 52.39,139.3 v1(52.17,139.52) ; v7(99.92,99.28) 99.24,99.96 99.24,103.99 100.69,105.43 100.69,107.36 100.92,107.59 v3(100.94,107.59)
  GND1 w0.508: v4(98.59,88.39) 98.66,88.32 v10(98.66,87.96) ; v10(22.42,24.72) v4(22.42,25.26) ; v4(236.3,129.93) 236.07,129.7 v2(236.07,129.4)
  IN2 w0.203: v2(166.79,124.8) 167,125.01
  IN2 w0.254: v4(165.18,127.31) 165.17,127.3 165.17,126.92 166.91,125.18 167.17,125.18 ; 167.17,125.18 v2(167.19,125.2) ; 167.17,125.18 167,125.01
  IN2 w0.508: v4(94.7,124.47) 94.7,124.11 95.51,123.3 95.51,114.97 98.3,112.17 98.3,109.74 100.45,107.59 v3(100.94,107.59)
  IN3 w0.508: v4(190.28,100.19) 189.87,99.78 189.87,98.97 v6(190.07,98.76) ; v7(23.63,25.95) 23.63,25.76 23.12,25.26 v4(22.42,25.26) 20.52,23.35 17.66,23.35 16.08,24.93 16.08,30.66 15.35,31.39 15.35,37.49 16.77,38.9 16.77,39.48 17.55,40.25 17.55,42.21 18.47,43.14 18.47,49.56 18.99,50.08
  GND4 w0.254: v4(165.18,127.31) 165.26,127.31 165.41,127.47 v16(165.41,127.64)
  GND4 w0.508: v16(236.3,130.31) v4(236.3,129.93) ; v4(98.59,88.39) v9(98.59,88.8) ; v4(94.7,124.47) v16(94.7,125.15)
  BOTTOM w0.102: v7(185.27,106.84) v14(185.85,106.84)
  BOTTOM w0.508: v7(99.92,99.28) 99.92,98.95 100.54,98.33 100.54,97.23 v14(99.92,96.6) 99.92,94.15 99.8,94.04 99.8,90.01 v9(98.59,88.8)
  vias: v4(31.85,95.96) v4(32.3,95.93) v4(32.76,95.93) v4(33.24,95.98) v4(33.71,95.94) v6(200.98,123.24) v6(201.21,122.94) v6(201.35,123.31) v6(201.54,123.03) v7(21.43,67.86) v7(21.43,67.23) v7(35.62,95.36) v7(36.18,95.35) v7(166.2,101.63) v7(166.76,101.63) v7(180.83,106.84) v7(180.83,106.21) v7(181.46,106.84) v7(181.46,106.21) v7(182.1,106.84) v7(182.1,106.21) v7(182.73,106.84) v7(182.73,106.21) v7(183.37,106.84) v7(183.37,106.21) v7(184,106.84) v7(184,106.21) v7(184.64,106.84) v7(184.64,106.21) v7(185.27,106.21) v7(234.07,137.92) v7(235.36,138.03) v10(31.88,95.58) v10(32.05,95.3) v10(32.19,95.57) v10(32.4,95.31) v10(32.59,95.59) v10(32.7,95.3) v10(190.52,100.62) v10(190.77,101.02) v10(192.83,100.94) v10(192.86,101.28) v10(193.19,101.49) v10(193.2,101.13) v16(32.68,96.45) v16(32.99,96.45) v16(33.29,96.45) v16(33.6,96.45) v16(33.9,96.45)
+3VALW_DSW: length 629.4
  TOP w0.203: v2(132.44,106.73) 132.09,106.73 UC1.AL15
  TOP w0.254: PU209.5 70.86,120.67 71.02,120.51 71.02,120.02 PC218.1 ; PR238.1 61.36,144.58 v1(61.12,144.83) ; U24.4 80.54,134.74 80.12,134.32 C161.1 ; PU101.5 41.49,131.44 41.26,131.68 v10(41.26,132.55) ; PC205.2 78.85,128.1 78.85,127.34 78.53,127.02 PU207.8
  TOP w0.305: 65.14,137.46 65.41,137.19 65.41,135.06 65.27,134.92 PU204.5 ; 65.14,137.46 PU205.5 ; 65.14,137.46 65.14,137.48 65.26,137.6 v1(65.26,138.11) ; v10(79.58,133.36) 79.58,133.69 79.83,133.93 C161.1 ; v1(144.04,120.3) RH82.1 RH117.1
  TOP w0.381: v7(180.24,106.21) 180.24,105.74 180.94,105.04 R1014.2 ; PR240.1 v7(72.73,128.15)
  TOP w0.457: PU206.8 66.92,124.23 PC214.1 66.14,124.87 v7(65.67,125.34)
  TOP w0.508: 199.16,136.94 195.62,136.94 R5717.2 ; v7(210.61,129.05) 210.61,128.75 214.52,124.84 216.8,124.84 v7(217.49,124.14) ; v7(17.39,24.48) 19.22,24.48 R1422.1 ; 165.08,118.38 165.73,118.38 v10(165.97,118.63) ; v7(72.27,123.68) 72.37,123.68 72.73,124.04 PR227.1 72.88,123.33 72.57,123.02 PR225.1 ; R5746.1 218.81,115.24 217.34,115.24 215.89,116.68 215.89,118.77 v7(215.78,118.88) ; v7(25.01,88.91) 24.96,88.96 PQ114.1 25.74,91.24 PR150.1 ; PR259.1 68.35,118.67 PD204.2 69.21,118.11 69.46,118.36 69.88,118.36 70.54,119.02 PC218.1 70.54,119.72 70.08,120.18 v7(70.01,120.18) ; v10(79.38,127.74) 79.38,127.92 79.1,128.2 PC205.2
  IN1 w0.254: v1(144.04,120.3) 144.04,119.72 143.66,119.34 v5(143.66,119.32)
  IN1 w0.508: v1(62.91,141.87) 62.91,142.25 63.23,142.57 63.23,143.73 62.66,144.31 61.64,144.31 v1(61.12,144.83) 61.32,145.03 61.32,146.82 61.84,147.34 61.84,148.05 v1(61.32,148.57) 60.66,147.91 59.49,147.91 v7(58.93,147.35) ; v1(65.26,138.11) 65.26,138.77 v1(64.73,139.3)
  GND1 w0.254: v2(132.44,106.73) 132.32,106.61 v4(132.09,106.61) ; v2(73.62,111.55) 74.26,111.55 v4(74.3,111.59)
  GND1 w0.381: v10(161.45,124.37) v4(161.45,124.85) ; v4(142.31,115.07) 142.42,114.97 v10(142.77,114.97) ; v5(143.66,119.32) 142.45,119.32 v4(142.35,119.43)
  GND1 w0.508: v10(41.26,132.55) 41.33,132.55 v4(41.64,132.85) ; v10(165.97,118.63) 165.97,118.55 v4(166.3,118.22) ; v4(69.38,108.8) 69.38,108.51 68.22,107.35 v10(68.1,107.35) ; v10(79.58,133.36) 79.58,132.73 79.76,132.55 v4(79.58,132.55) ; v10(79.38,127.74) 79.38,127.36 v4(79.58,127.16)
  IN2 w0.305: v4(69.38,108.8) 69.5,108.8 70.2,109.49 v4(70.2,109.55)
  GND2 w0.254: 139.91,109.66 139.63,109.38 138.69,109.38 138.69,109.36 139.22,108.82 139.22,108.57 139.55,108.24 139.93,108.24 139.99,108.29 140,108.29 140.27,108.56 140.27,108.57 140.62,108.92 140.62,109.05 141,109.43 141.33,109.43 v4(141.64,109.74) 141.46,109.91 140.82,109.91 140.57,109.66 139.91,109.66
  GND2 w0.508: v4(132.09,106.61) 133.44,107.95 133.44,108.89 134.66,110.12 137.29,110.12 138.03,109.38 138.69,109.38
  IN3 w0.381: v4(142.31,115.07) 142.17,114.93 142.17,113.05 142.87,112.36 142.87,111.01 ; v6(160.84,122.31) 160.84,123.4 161.45,124.01 v4(161.45,124.85)
  IN3 w0.508: v7(215.78,118.88) 215.78,118.78 216.1,118.46 216.82,118.46 217.29,118.93 217.29,123.93 v7(217.49,124.14) ; v6(72.55,110.93) 72.77,110.93 73.16,111.31 74.02,111.31 v4(74.3,111.59) 75.16,112.45 77.1,112.45 78.12,111.43 78.81,111.43 80.75,113.37 v6(82.56,113.37) ; v6(227.54,134.3) 227.54,132.13 227.25,131.83 227.25,130.88 227.86,130.26 227.86,128.99 227.27,128.4 227.27,127.72 225.56,126.01 225.56,125.15 ; v6(162.8,107.87) 162.8,108.4 163.79,109.39 164.68,109.39 165.29,110 165.29,113.27 165.07,113.49 165.07,114.74 164.84,114.97 164.84,117 166.07,118.22 v4(166.3,118.22) ; v6(119.97,121.9) 120.45,121.42 120.45,118.42 v6(121.01,117.86) ; v6(172.01,108.64) 173.74,108.64 v6(176.13,106.26) ; v7(72.27,123.68) 73.06,123.68 74.75,125.37 v6(77.07,125.37) 77.79,125.37 v4(79.58,127.16) 79.64,127.21 85.16,127.21 85.6,126.78 89.02,126.78 89.91,125.89 92.74,125.89 v6(93.3,126.45) ; v7(17.39,24.48) 16.71,25.17 16.71,30.9 15.96,31.64 15.96,37.23 17.38,38.65 17.38,39.21 18.16,39.99 18.16,41.8 19.08,42.72 19.08,47.56 19.88,48.36 19.88,49.27 v6(21.63,51.02) 25.01,51.02 25.79,51.8 30.51,51.8 32.93,54.22 32.93,81.89 39.14,88.1 v6(39.14,88.91) 39.14,89.19 40.27,90.32 v6(40.27,94.72) ; v7(65.67,125.34) 65.67,125.81 69.36,129.51 69.95,129.51 71.49,131.06 77.43,131.06 78.92,132.55 v4(79.58,132.55) v6(80.13,132.55)
  GND4 w0.305: v4(70.2,109.55) 70.4,109.55 v9(70.62,109.76)
  GND4 w0.381: v6(142.86,115.17) 142.42,115.17 v4(142.31,115.07) ; v4(142.35,119.43) 142.35,119.08 v9(142.47,118.96) ; v4(132.09,106.61) 132.25,106.61 v9(132.53,106.33)
  GND4 w0.508: v4(41.64,132.85) 41.87,132.85 v9(42.07,132.65)
  BOTTOM w0.305: v6(72.55,110.93) 72.24,110.93 71.08,109.76 v9(70.62,109.76) ; v6(21.63,51.02) 21.2,51.46 R5730.1
  BOTTOM w0.381: v6(160.84,122.31) 159.78,122.31 157.61,120.14 151.38,120.14 150.01,118.77 148.37,118.77 147.99,118.38 147.99,117.56 147.17,116.75 144.43,116.75 v6(142.86,115.17) 142.86,118.58 v9(142.47,118.96) ; RH115.1 143.32,110.36 144.91,111.95 146.81,111.95 147.53,111.23 148.24,111.23 148.67,111.67 148.67,113.14 149.59,114.05 151.33,114.05 154.15,111.23 159.71,111.23 160.66,110.29 160.66,109.81 160.89,109.58 ; R5699.1 R5730.1
  BOTTOM w0.508: v7(25.01,88.91) 26.63,88.91 27.74,87.81 31,87.81 32.1,88.91 v6(39.14,88.91) ; 46.82,130.39 47.68,130.39 48.37,131.07 48.37,132.34 47.91,132.8 47.91,136.71 48.66,137.46 48.66,139.64 53.49,144.47 55.78,144.47 58.62,147.3 58.93,147.3 ; 46.82,130.39 46.82,129.07 43.19,125.43 43.19,111.51 39.94,108.26 39.94,102.67 41.36,101.25 41.36,97.34 40.99,96.97 40.99,95.08 40.63,94.72 v6(40.27,94.72) ; 46.82,130.39 45.95,130.39 43.69,132.65 v9(42.07,132.65) ; v6(176.13,106.26) 176.28,106.1 177.73,106.1 ; 58.93,147.3 60.06,148.43 74.03,148.43 74.61,147.86 74.61,143.81 77.46,140.95 77.46,136.92 80.13,134.25 v6(80.13,132.55) 80.46,132.22 80.46,131.94 83.15,129.24 87.05,129.24 87.76,128.54 91.66,128.54 92.07,128.14 93.35,128.14 93.4,128.08 ; 58.93,147.3 v7(58.93,147.35) ; 217.91,124.7 217.91,126.82 224.07,132.98 225.57,132.98 226.21,133.61 226.71,133.61 227.03,133.93 ; 93.4,128.08 93.75,128.43 96.37,128.43 97.39,127.41 105.82,127.41 109.43,123.81 118.07,123.81 v6(119.97,121.9) ; 93.4,128.08 93.3,127.98 v6(93.3,126.45) ; v6(121.01,117.86) 134.47,117.86 137.17,115.17 v6(142.86,115.17) ; v7(70.01,120.18) 72.27,122.44 v7(72.27,123.68) 72.27,127.69 v7(72.73,128.15) ; 196.2,126.14 196.2,125.43 191.47,120.71 191.47,112.92 188.7,110.15 188.7,109.25 187.05,107.6 179.23,107.6 177.73,106.1 ; 177.73,106.1 178.55,105.29 179.73,105.29 180.24,105.8 v7(180.24,106.21) ; v6(82.56,113.37) 82.73,113.55 82.73,119.97 82.02,120.68 78.86,120.68 77.07,122.47 v6(77.07,125.37) ; v6(172.01,108.64) 168.31,108.64 166.83,107.17 163.5,107.17 v6(162.8,107.87) 162.43,108.24 162.24,108.24 160.89,109.58
  BOTTOM w0.762: 198.05,127.67 200.72,127.67 202.29,129.24 v14(205.82,129.24) 210.42,129.24 v7(210.61,129.05)
  vias: v2(193,133.41) v2(193.3,133.41) v2(199.55,137.89) v2(199.55,137.5) v6(142.68,110.42) v6(196.48,127.24) v6(196.75,127.44) v6(196.78,127.06) v6(197.19,127.21) v7(192.51,129.68) v7(192.69,130.21) v7(224.85,124.54) v7(225.41,124.54)
+3VALW_EC: length 404.3
  TOP w0.254: C185.1 236.9,124.67 236.48,124.25 U27.A6 ; v10(231.31,125.25) U27.L4 ; R5703.1 128.35,82.16 128.65,81.86 129.93,81.86 R1074.1 130.5,81.46 v1(130.86,81.11) ; U27.N4 229.7,125.36 C178.1 v10(227.7,125.36) ; v10(230.49,128.39) 230.49,127.74 231.31,126.92 U27.K1 U27.K2
  TOP w0.305: C185.1 237.79,125.07 237.9,125.18 ; R515.2 228.19,130.08 R1041.1 ; R1045.1 228.2,120.51 v7(228.48,120.79) 228.21,121.05 226.83,121.05 226.27,120.49 R1079.2 R1080.2 ; 237.9,125.18 R1053.2 ; 237.9,125.18 v7(237.31,125.18) ; v7(206.29,146.51) 206.29,145.3 207.3,144.29 R195.1 R5677.1 R5676.1 R1068.1 R1067.1 R1066.1 R1065.1 212.03,144.29 R192.1 ; v7(239.06,123.99) 239.01,124.04 R1050.2 238.37,123.77 237.97,123.36 R168.2 ; R1138.2 232.49,116.9 232.18,117.21 v7(232.18,117.72) 232.39,117.93 R1055.2 232.35,118.49 R1040.1 R1059.2 R171.1
  TOP w0.381: v7(234.68,129.83) 234.85,129.65 234.85,129 R1049.2
  TOP w0.508: R515.2 228.02,130.81 v7(228.02,131.45) ; v7(226.32,123.02) 226.32,123.41 226.04,123.69 R514.2 ; R1082.2 C1386.1 Q330.3 v7(220.55,121.9)
  IN1 w0.254: v1(191.15,93.96) 191.15,92.96 190.02,91.84 v3(189.57,91.84) ; v1(130.86,81.11) 131.78,81.11 131.86,81.03 133.44,81.03 133.55,81.14 134.89,81.14 140.51,86.76 140.51,86.81 142.93,89.24 146.72,89.24 147.25,88.71 149.1,88.71 150.31,89.92 153.57,89.92 154.33,89.17 160.65,89.17 163.48,86.34 166.67,86.34 166.94,86.06 v7(167.32,86.06) 167.6,86.06 168.23,86.69 169.89,86.69 171.63,84.95 182.96,84.95 185.25,87.24 186.25,87.24 v3(186.47,87.46)
  GND1 w0.254: v4(231.15,120.87) 231.31,121.03 v10(231.31,121.25) ; v10(227.7,125.36) 227.72,125.37 228.03,125.37 v4(228.09,125.32) ; v4(230.99,125.57) 231.31,125.26 v10(231.31,125.25) ; v4(233.39,120.87) 233.32,120.95 233.32,121.23 v10(233.31,121.25) ; v10(233.31,125.75) 233.31,125.69 233.1,125.48 v4(233.1,125.31) ; v4(230.08,128.76) 229.81,129.03 v10(229.81,129.04)
  GND1 w0.305: v4(230.08,128.76) 230.45,128.39 v10(230.49,128.39)
  GND1 w0.381: v4(239.02,119.16) 239.12,119.06 v10(239.63,119.06)
  IN2 w0.06: 168.36,121.66 168.05,121.96 168.05,122.33 v2(167.99,122.4)
  IN2 w0.254: v4(177.32,123.48) 177.03,123.19 177.03,122.08 175.47,120.51 175.47,120.01 174.58,119.12 170.33,119.12 169.06,120.39 169.06,120.96 168.36,121.66 ; v2(80.75,133.35) 80.73,133.35 80.19,132.81 80.19,131.87 80.18,131.86 80.18,130.92 80.45,130.65 81.04,130.65 81.98,131.59 82.82,131.59 83.14,131.91 84.68,131.91 v4(84.86,132.09) ; v3(186.47,87.46) 189.57,90.56 v3(189.57,91.84) ; v4(167.95,96.58) 167.65,96.88 164.75,96.88 163.46,95.59 162.46,95.59 v2(162.36,95.69)
  IN3 w0.254: 186.4,124.72 186.85,124.72 188.14,126.02 188.14,128.28 v6(187.89,128.53) 188.62,129.26 188.62,131.07 188.02,131.68 v6(188.02,133.1) ; 186.4,124.72 185.1,124.72 182.68,122.31 179.1,122.31 178.87,122.54 178.87,122.77 178.16,123.48 v4(177.32,123.48) ; 186.4,124.72 184.85,123.18 184.85,120.75 187.42,118.19 v6(187.42,114.84) ; v6(227.08,142.54) 227.08,140.32 227.74,139.66 227.74,139.29 230.99,136.04 v7(230.99,133.28)
  GND4 w0.254: v4(167.95,96.58) 167.87,96.5 167.87,96.17 v9(167.8,96.1) ; v9(85.25,132.09) v4(84.86,132.09) ; v9(232.77,124.93) 232.77,125 233.08,125.31 v4(233.1,125.31) ; v9(230.99,125.18) v4(230.99,125.57)
  GND4 w0.305: v9(230.03,129.32) 230.08,129.27 v4(230.08,128.76) ; v9(228.21,124.89) 228.21,125.19 v4(228.09,125.32) ; v4(231.15,120.87) 230.93,120.87 v9(230.74,121.06) ; v4(233.39,120.87) 233.58,120.68 233.58,120.29 v9(233.69,120.19)
  GND4 w0.381: v4(239.02,119.16) 239.13,119.05 v16(239.63,119.05)
  BOTTOM w0.254: v9(85.25,132.09) 86.42,132.09 88.99,129.52 96.83,129.52 97.77,128.58 105.19,128.58 108.29,131.68 112.87,131.68 113.8,130.75 113.8,129.72 114.55,128.97 114.55,127.99 115.81,126.73 119.83,126.73 120.08,126.98 125.15,126.98 126.27,125.87 137.01,125.87 138.45,127.3 144.76,127.3 148.31,130.86 153.62,130.86 154.66,131.91 161.01,131.91 161.93,130.98 162.69,130.98 163.11,130.56 165.35,130.56 165.52,130.39 172.81,130.39 173.8,131.38 177.26,131.38 177.41,131.22 187.44,131.22 188.02,131.81 v6(188.02,133.1) ; v6(227.08,142.54) 228.16,143.62 228.16,148.13 227.86,148.43 225.41,148.43 224.71,147.73 221.42,147.73 221.11,147.43 207.21,147.43 v7(206.29,146.51) 202.26,146.51 198.93,143.18 198.93,141.06 197.49,139.63 197.49,137.96 v14(195.01,135.48) 194.86,135.33 193.77,135.33 193.41,134.97 193.41,133.86 192.77,133.22 192.08,133.22 190.2,131.35 190.2,129.71 189.02,128.53 v6(187.89,128.53) ; v7(167.32,86.06) 167.32,87.1 167.8,87.59 167.8,96.09 v9(167.8,96.1) 167.8,96.1 167.8,100.4 174.73,107.32 175.34,107.32 176.84,108.82 186.19,108.82 187.42,110.05 v6(187.42,114.84)
  vias: v7(231.58,133.28) v17(236.25,120.66)
+3VALW_EC_L: length 6
  IN2 w0.254: 232.36,126.2 232.31,126.15 v2(232.31,125.75)
  IN2 w0.305: v2(231.37,130.68) 231.86,130.2 231.86,128.68 232.54,128 232.54,126.39 232.36,126.2 v4(232.36,126.18)
  IN3 w0.254: v6(232.24,125.78) 232.24,125.98 232.36,126.1 v4(232.36,126.18)
+3VALW_S: length 35.8
  IN2 w0.254: v4(176.26,113.88) 176,113.62 174.43,113.62 171.33,110.52 169.7,110.52 v4(169.53,110.35) ; v4(170.76,122.64) 170.6,122.8 v2(170.39,122.8)
  IN3 w0.508: v4(169.53,110.35) 169.2,110.68 169.2,111.46 171.35,113.62 171.35,117.76 169.48,119.64 169.48,120.23 170.77,121.52 170.77,122.63 v4(170.76,122.64) ; v6(176.76,113.9) 176.28,113.9 v4(176.26,113.88)
  BOTTOM w0.508: v6(176.76,113.9) 176.76,112.91 179.69,109.99 185.05,109.99 v7(186.11,111.06)
+3VLDO: length 344.2
  TOP w0.254: v11(76.58,129.04) 76.58,129.37 77.02,129.8 78.01,129.8 78.23,129.59 PR213.1 ; v1(58.71,145.63) 58.73,145.63 59.21,146.11 PR237.1 ; PD301.2 163.65,99.82 v7(163.85,99.62)
  TOP w0.381: PR242.1 69.96,128.71 v11(69.42,128.71) 69.27,128.71 68.97,129.01 PR239.2 68.17,129.32 PR220.1 ; PR202.1 PR224.2 PC215.2 52.02,148.68 51.5,148.17 51.5,148.06 51.34,147.9 v1(51.34,147.45) 51.7,147.09 52.43,147.09 53,146.53 PQ209.3 53.87,145.08 54.39,145.08 55.13,144.33 55.13,143.44 54.48,142.78 52.8,142.78 51.76,141.74 PC213.1 51.99,141.55 52.39,141.14 52.39,140.65 PQ211.3 ; PR218.1 65.27,120.37 65.27,122.58 v11(65.3,122.6)
  TOP w0.508: PR241.1 74.35,122.74 ; 74.35,122.74 74.35,122.13 74.48,122 PR245.1 ; 74.35,122.74 v7(75.22,122.74) ; R515.1 227.03,129.84 v7(227.03,129.85) 226.88,130.01 226.88,131.12 R5588.1
  IN1 w0.508: v1(62.28,143.6) 61.3,143.6 60.42,144.48 60.42,144.89 59.57,145.74 58.82,145.74 v1(58.71,145.63) 58.44,145.63 v3(57.28,144.47) 53.08,144.47 51.34,146.21 v1(51.34,147.45) ; v3(71.22,133.44) 69.44,133.44 68.98,132.98 64.6,132.98 63.18,134.4 63.18,134.96 62.66,135.48 61.77,135.48 61.39,135.1 59.8,135.1 58.41,136.48 58.41,137.92 v11(57.82,138.51)
  IN2 w0.508: v3(71.22,133.44) 71.22,132.79 71.89,132.11 71.89,130.49 70.11,128.71 v11(69.42,128.71) ; v4(57.82,143.96) 57.31,144.47 v3(57.28,144.47) ; v11(76.58,129.04) 76.58,132.18 79.22,134.81 81.1,134.81 82,135.72 v4(83.02,135.72)
  IN3 w0.254: v6(169.07,134.71) 169.07,134.5 169.38,134.18 169.75,134.18 170.14,133.8 170.14,132.53 166,128.39 166,126.41 169.03,123.38 170.71,123.38 172.57,121.51 172.57,119.3 175.08,116.8 175.08,115.61 175.29,115.39 v6(175.29,115.17)
  IN3 w0.508: v11(65.3,122.6) 65.3,124.07 69.42,128.2 v11(69.42,128.71) ; v6(162.62,133.6) 162.99,133.6 164.42,135.03 v6(166.8,135.03) 168.1,135.03 168.64,135.57 171.9,135.57 173.59,133.88 176.53,133.88 176.76,134.11 178.2,134.11 180.45,136.36 188.4,136.36 190.58,138.54 190.58,141.45 192.12,142.99 192.12,144 194.58,146.46 196.25,146.46 196.68,146.03 196.68,145.8 197.46,145.02 207.11,145.02 208.27,146.19 220.67,146.19 221.48,147 222.9,147 v6(224.3,145.6) ; v6(225.41,141.07) 225.41,140.75 226.87,139.28 226.87,138.85 229.88,135.85 229.88,132.76 v6(229.89,132.75) ; v11(57.82,138.51) v4(57.82,143.96)
  GND4 w0.508: v4(83.02,135.72) v9(83.41,136.1)
  BOTTOM w0.254: v6(166.8,135.03) 168.22,135.03 168.54,134.71 v6(169.07,134.71) ; v7(163.85,99.62) 163.85,100.38 168.05,104.58 168.05,105.42 169.46,106.83 172.7,106.83 174.18,108.31 174.85,108.31 176.28,109.75 176.28,113.31 175.29,114.3 v6(175.29,115.17)
  BOTTOM w0.508: v7(227.03,129.85) 227.44,130.26 227.44,132.28 227.91,132.75 v6(229.89,132.75) ; 76.43,128.89 v11(76.58,129.04) ; 76.43,128.89 71.96,128.89 71.89,128.96 69.68,128.96 v11(69.42,128.71) ; 76.43,128.89 74.76,127.22 74.76,123.2 v7(75.22,122.74) ; v6(225.41,141.07) 224.36,142.12 224.36,145.42 224.3,145.48 v6(224.3,145.6) ; v6(162.62,133.6) 162.1,134.12 146.86,134.12 145.43,132.69 142.34,132.69 140.27,130.61 128.19,130.61 127.29,131.52 127.29,134.64 125.71,136.22 107.8,136.22 106.1,134.51 105.5,134.51 104.04,135.97 92.62,135.97 92.06,136.53 83.84,136.53 v9(83.41,136.1)
+3VLDO_BATT: length 34.1
  TOP w0.254: PD302.2 166.76,105.08 v7(166.67,105.16)
  GND1 w0.254: v4(160.99,95.33) 160.69,95.64 v10(160.61,95.64)
  IN2 w0.254: v4(174.58,116.33) 174.07,115.82 v2(173.71,115.82)
  IN3 w0.254: v4(174.58,116.33) 174.61,116.3 v6(174.61,115.78)
  GND4 w0.254: v4(160.99,95.33) v9(160.71,95.61)
  BOTTOM w0.254: v6(174.61,115.78) 174.61,114.48 175.93,113.16 175.93,109.95 174.65,108.67 174.03,108.67 172.59,107.22 169.35,107.22 167.7,105.57 167.7,105.03 167.42,104.75 167.01,104.75 166.67,105.09 v7(166.67,105.16) 166.48,104.98 166.48,103.52 161,98.03 161,96.48 160.71,96.19 v9(160.71,95.61)
+3VS: length 800.5
  TOP w0.102: v1(217.99,108.91) 218.18,109.1 218.65,109.1 218.96,109.41 U20.1 ; v1(218.27,111.15) 223.11,111.15 223.96,110.29 U20.22 ; C156.1 223.13,110.4 223.53,110 U20.23 ; R5754.1 38.56,96.96 37.75,97.77 37.75,98.33 37.98,98.56 48.15,98.56 48.83,97.89 48.83,95.14 ; U20.3 219.63,108.3 219.54,108.21 v1(218.76,108.21)
  TOP w0.203: U23.5 56.63,94.45 56.74,94.56 56.74,95.13 57.32,95.72 C36.1 ; U23.57 59.69,91.98 v7(59.8,92.08) ; U23.30 49.42,89.58 49.28,89.44 v7(49.28,89.06)
  TOP w0.254: RH14.2 141.5,114.86 141.24,114.61 RH30.1 ; RH93.2 v10(140.99,99.79) ; PR228.2 76.84,125.31 v1(76.84,126.34) ; C160.1 60.28,88.76 59.46,89.58 U23.51 ; RH113.1 v10(139.16,97.28) ; v7(49.28,89.06) 48.98,88.76 R126.2 ; 47.99,90.68 47.13,89.81 v7(46.77,89.81)
  TOP w0.305: C36.1 57.59,95.72 58.34,96.46 R199.1 58.53,97.24 58.83,97.54 59.67,97.54 61.36,95.86 R198.1 R183.1 61.68,94.47 61.93,94.22 61.93,93.48 61.65,93.2 R185.1 R189.1 61.75,92.57 61.96,92.36 61.96,90.74 v7(61.88,90.66) ; RH30.1 141.64,114.33 v2(141.69,114.38) ; R191.1 61.68,89.39 61.89,89.61 61.89,90.65 v7(61.88,90.66) ; v7(61.88,90.66) R187.1 ; RH13.2 v2(145.36,114.84) 145.36,114.45 145.55,114.26 145.8,114.26 146.32,113.74 RH181.2
  TOP w0.381: v1(217.4,108.34) 217.13,108.34 216.9,108.11 216.9,106.85 217.15,106.6 R104.1 R91.1 ; 57.45,143.39 57.31,143.25 v7(56.62,143.25) ; 57.45,143.39 Q345.2 ; 57.45,143.39 Q345.5 ; v1(230.19,109.91) R395.2 ; v1(218.27,111.15) 218.27,110.45 C156.1 ; v10(144,109.43) 144.08,109.35 144.08,109.11 143.96,108.98 UH1.5 ; v7(29,73.58) 29.61,74.19 31.96,74.19 RH134.2 ; v7(64.96,146.49) 65.1,146.49 65.39,146.78 C1391.1 C150.1 C151.1 v1(66.12,148.28) R36.1 R34.1 ; R39.2 R38.2 v1(66.14,145.97) ; C160.1 v7(60.78,88.12)
  TOP w0.457: Q89.5 29.22,95.37 v1(29.72,94.86)
  TOP w0.508: v7(192.32,134.31) 192.31,134.31 192.31,134.77 R200.1 ; v7(169.88,99.6) 169.32,99.04 163.31,99.04 163.02,99.32 162.64,99.32 ; Q43.2 32,98.37 v7(31.68,98.69) ; Q86.2 16.68,94.98 v7(16.35,94.65) ; v7(57.23,94.98) 57.51,95.26 C36.1 ; v7(238.33,139.68) 231.93,139.68 231.66,139.4 v7(229.15,139.4) 222.7,139.4 222.09,138.79 v7(222.09,136.43)
  IN1 w0.06: v5(169.48,126.75) 169.47,126.75 169.47,125.94 169.39,125.86 169.39,125.51 169.27,125.4 169.11,125.4 168.99,125.28 168.99,124.6 v1(168.79,124.4)
  IN1 w0.254: v1(218.27,111.15) 218.27,109.19 v1(217.99,108.91) ; v1(218.76,108.21) 218.69,108.21 v1(217.99,108.91) ; v1(217.99,108.91) 217.42,108.34 v1(217.4,108.34) ; v1(76.84,126.34) 79.04,128.53 79.53,128.53 80.77,129.78 v5(82.73,129.78)
  IN1 w0.381: v1(66.12,148.28) 66.07,148.28 65.7,147.91 65.7,147.51 66.08,147.12 ; 66.08,147.12 65.72,146.76 65.72,146.32 66.07,145.97 v1(66.14,145.97) ; 66.08,147.12 v1(66.14,147.12)
  IN1 w0.508: v1(22.52,65.46) 22.52,65.82 v7(23.73,67.03) ; v1(15.5,34.78) 15.5,41.33 15.2,41.64 15.2,43.32 14.87,43.65 13.34,43.65 v5(13.21,43.77) ; v1(217.4,108.34) 214.94,108.34 213.75,109.53 211.93,109.53 v7(211.05,110.41) ; v1(230.19,109.91) 230.19,108.47 231.78,106.88 v10(231.78,106.68) 231.78,106.26 232.16,105.88 234.64,105.88 238.68,109.91 v5(239.38,109.91) ; v7(14.46,89.84) 14.79,90.16 23.74,90.16 23.91,90.33 25.85,90.33 27.46,91.94 28.71,91.94 29.36,92.59 29.36,94.5 v1(29.72,94.86) ; v7(162.1,85.02) 160.34,86.77 145.06,86.77 143.05,84.76 v5(142.82,84.76)
  GND1 w0.254: v5(239.38,109.91) 239.63,109.91 v4(239.91,110.19) ; v4(140.57,99.22) 140.99,99.64 v10(140.99,99.79) ; v5(169.48,126.75) 169.75,127.03 v4(169.75,127.21) ; v10(139.16,97.28) 139.19,97.28 v4(139.58,96.88)
  GND1 w0.381: v4(144.51,109.38) 144.05,109.38 v10(144,109.43)
  GND1 w0.508: v4(83.53,130.83) 83.53,130.57 v5(82.73,129.78) ; v5(13.21,43.77) 12.81,44.18 v4(12.81,44.25) ; v5(142.82,84.76) v4(142.31,84.76)
  IN2 w0.305: v4(147,117.15) 146.97,117.13 145.68,117.13 145.38,116.83 145.38,114.87 v2(145.36,114.84) 144.9,114.38 144.14,114.38 143.85,114.68 142.69,114.68 142.63,114.61 141.92,114.61 v2(141.69,114.38)
  IN2 w0.381: v4(148.9,102.55) 149.14,102.3 151.95,102.3 152.19,102.06 152.75,102.06 153.83,100.98 v4(155.78,100.98)
  IN2 w0.508: v7(14.46,89.84) 14.48,89.82 14.48,89.06 14.14,88.72 14.14,79.54 12.72,78.11 12.72,73.45 v4(11.94,72.68)
  IN3 w0.254: v4(169.75,127.21) 169.75,128.15 v6(170.67,129.07)
  IN3 w0.305: v6(142.93,96.27) 143.62,96.96 143.62,98.04 v6(144.37,98.79) ; v6(148.72,110.37) 147.78,111.32 147.78,112.16 148.16,112.54 148.16,117.25 148.77,117.86 148.77,119.08 v6(148.9,119.21) ; v6(148.6,124.6) 148.6,124.52 148.93,124.19 148.93,123.22 v6(149.43,122.72)
  IN3 w0.508: v6(11.51,61.49) 6.86,61.49 6.42,61.04 6.42,59.99 12.25,54.16 12.25,52.05 12.55,51.74 12.55,50.31 12.36,50.12 12.36,47.55 12.81,47.1 v4(12.81,44.25) ; v4(148.9,102.55) 147.89,101.53 147.11,101.53 v6(144.37,98.79) ; 23.73,72.69 v6(15.4,72.69) 11.96,72.69 v4(11.94,72.68) ; 23.73,72.69 v7(23.73,67.03) ; 23.73,72.69 25.65,72.69 26.77,71.57 27.44,71.57 29,73.14 v7(29,73.58) ; v6(178.72,95.87) 178.72,95.44 v6(180.42,93.73) ; v6(242.12,131.33) 241.41,132.04 241.41,134.67 240.58,135.5 240.58,137.61 238.5,139.68 v7(238.33,139.68) ; v6(82.15,131.12) 82.45,130.83 v4(83.53,130.83) 83.74,130.61 87.06,130.61 87.85,131.41 93.94,131.41 94.97,130.39 98.96,130.39 99.96,131.39 100.7,131.39 102.21,132.9 104.11,132.9 104.26,132.75 105.69,132.75 107.25,131.2 109.61,131.2 109.71,131.1 110.59,131.1 111.14,130.54 111.14,130.04 112.66,128.53 v6(112.66,128.46) ; v6(193.55,111.84) 193.73,111.67 197.83,111.67 198.23,112.06 203.66,112.06 204.79,113.19 209.59,113.19 v7(210.24,112.54) ; v6(176.78,90.11) 176.78,90.09 173.54,86.85 169.45,86.85 167.62,85.02 v7(162.1,85.02) ; v4(239.91,110.19) 240.95,110.19 243.74,112.99 243.74,114.61 244.18,115.04 v6(244.18,117.61) ; v7(229.15,139.4) 231.01,139.4 233.61,136.8 v7(233.61,134.04) ; v7(222.09,136.43) 222.51,136.01 222.51,124.85 222.14,124.48 222.14,122.57 v6(220.08,120.52) ; v7(73.83,145.05) 75.15,145.05 78.29,141.92 v6(78.29,140.8)
  IN3 w1.016: 55.92,82.27 54.62,82.27 53.61,83.27 47.61,83.27
  GND4 w0.305: v9(141.61,99.18) 140.61,99.18 v4(140.57,99.22) ; v9(147.05,117.58) 147.05,117.2 v4(147,117.15)
  GND4 w0.381: v9(144.96,109.88) 144.63,109.55 144.63,109.51 v4(144.51,109.38) ; v4(139.58,96.88) 139.93,96.53 v9(139.93,96.25)
  GND4 w0.508: v9(156.19,100.62) 156.14,100.62 v4(155.78,100.98) ; v9(142.24,85.22) 142.24,84.83 v4(142.31,84.76)
  BOTTOM w0.254: v7(229.15,139.4) JSER.18
  BOTTOM w0.305: v7(57.23,94.98) 56.78,94.52 R196.1 ; v6(149.43,122.72) 149.43,119.74 v6(148.9,119.21) 148.19,119.21 147.05,118.07 v9(147.05,117.58) ; v6(148.72,110.37) 146.98,110.37 146.34,111.02 145.17,111.02 144.96,110.82 RH35.1 v9(144.96,109.88) 144.92,109.84 144.43,109.84 144.39,109.88 141.7,109.88 141.58,109.76 RH37.1 139.97,109.52 139.78,109.33 139.06,109.33 RH28.1 RC90.2 137.2,109.72 136.76,109.28 136.76,108.59 137.04,108.31 137.04,107.57 137.95,106.66 137.95,106.1 138.28,105.77 138.94,105.77 139.25,106.09 RH25.2 ; C159.1 49.73,89.51 v7(49.28,89.06) ; 139.13,99.8 139.68,99.8 140.3,99.18 RC201.1 v9(141.61,99.18) RC202.1 RC203.1 RC200.1 143.88,98.79 v6(144.37,98.79) ; v6(142.93,96.27) 142.93,95.84 142.72,95.63 RC33.1
  BOTTOM w0.381: RC33.1 RC32.1 140.56,95.63 v9(139.93,96.25)
  BOTTOM w0.508: v7(14.46,89.84) 14.46,90.15 16.35,92.05 v7(16.35,94.65) 16.86,95.16 20.6,95.16 22.68,97.24 29.87,97.24 31.32,98.69 v7(31.68,98.69) ; v7(169.88,99.6) 169.88,99.6 173.82,103.54 179.33,103.54 180.3,102.57 180.3,97.44 v6(178.72,95.87) ; v9(156.19,100.62) 156.55,100.26 157.87,100.26 159.87,102.26 v7(161.8,102.26) v7(162.43,102.26) ; v7(210.24,112.54) 210.75,112.03 211.55,112.03 212.11,112.59 212.11,115.39 213.13,116.41 214.18,116.41 217.2,119.44 219.01,119.44 v6(220.08,120.52) ; v6(176.78,90.11) 176.8,90.11 v6(180.42,93.73) 182.96,93.73 186.29,97.06 186.29,100.69 190.34,104.74 190.34,108.63 v6(193.55,111.84) ; v6(11.51,61.49) 12.87,61.49 13.72,62.34 13.72,66.29 15.47,68.04 15.47,72.61 v6(15.4,72.69) ; v6(242.12,131.33) 242.68,130.77 242.68,119.11 v6(244.18,117.61) ; v9(142.24,85.22) 141.81,84.79 136.93,84.79 134.16,82.02 132.39,82.02 131.04,80.67 119.16,80.67 118.85,80.36 109.53,80.36 109.18,80.71 104.17,80.71 103.63,81.25 101.2,81.25 100.77,81.68 ; v6(112.66,128.46) 112.66,127.47 115.1,125.03 123.88,125.03 126.3,122.61 138.51,122.61 139.81,123.91 147.91,123.91 v6(148.6,124.6) 148.6,128 149.54,128.94 154.48,128.94 155.49,129.95 160.66,129.95 161.74,128.88 163.42,128.88 163.73,129.19 164.85,129.19 164.98,129.07 v6(170.67,129.07) 173.59,129.07 174.81,130.28 176.49,130.28 178.92,127.85 178.92,126.87 181.16,124.63 184.23,124.63 185.15,125.55 185.15,128.46 186.47,129.78 188.34,129.78 189.11,130.55 189.11,132.52 190.9,134.31 v7(192.32,134.31) ; v6(78.29,140.8) 78.11,140.62 78.11,137.14 80.74,134.51 80.74,132.93 81.1,132.57 81.1,132.18 v6(82.15,131.12)
  BOTTOM w1.016: v7(29,73.58) 29.36,73.58 31.69,75.92 31.69,80.44 38.59,87.33 43.02,87.33 44.75,85.61
  vias: v6(46.31,83.71) v6(46.66,83.72) v6(46.82,83.42) v6(47.01,83.71) v6(58.53,83.73) v6(58.72,83.41) v6(58.91,83.73) v6(59.1,83.41) v6(59.29,83.73) v6(59.48,83.41) v6(59.67,83.73) v6(59.86,83.41) v6(60.05,83.73) v6(76.46,81.8) v6(76.89,81.8) v6(77.37,81.8) v6(77.81,81.8) v6(78.21,81.8) v7(48.83,94.19) v7(97.88,83.09) v7(98.24,83.51) v7(98.55,83.03) v7(98.82,83.51) v14(55.63,137.4)
+3VS_AUDIO: length 228.7
  TOP w0.203: 85.45,132.92 85.73,132.92 86.08,133.27 JDMIC1.2
  TOP w0.305: v7(18.85,16.09) 18.76,16 RA13.1
  TOP w0.381: C278.1 C277.1 29.23,68.18 29.19,68.14 29.19,67.5
  TOP w0.508: v7(21.27,20.98) 20.94,21.31 RA27.1 ; v1(91.47,91.75) 90.2,90.48 90.2,87.46 92.09,85.57 v7(92.09,85.54) ; v1(35.02,67.31) 34.82,67.31 33.06,69.07 30.26,69.07 29.93,68.74 29.93,67.75 29.67,67.5 29.19,67.5 ; 85.45,132.92 85.27,132.75 84.45,132.75 84.07,133.13 v10(82.54,133.13)
  IN1 w0.508: v1(91.47,91.75) 93.87,94.16 93.87,96.46 94.29,96.87 94.29,98.08 96.63,100.42 96.63,105.04 97.44,105.85 97.44,111.18 97.87,111.62 97.87,119.3 101.57,123 101.57,125.7 v3(101.53,125.74) ; v3(38.16,55.56) 37.44,55.56 36.35,56.64 36.35,64.13 35.02,65.46 v1(35.02,67.31) 35.02,74.83 36.19,76 36.19,80.94 39.32,84.07 44.49,84.07 v7(45.1,84.68)
  GND1 w0.381: v4(82.97,133.22) 82.63,133.22 v10(82.54,133.13)
  GND1 w0.508: v4(26.56,24.4) 26.13,24.4 v10(26.07,24.47)
  IN2 w0.508: v3(101.53,125.74) 100.84,126.42 99.54,126.42 97.26,128.7 97.26,131.04 96.34,131.96 95.61,131.96 v4(95.31,131.66) ; v3(38.16,55.56) 38.16,55.85 38.25,55.94 v4(38.25,56.05) ; v7(38.82,25.94) 38.12,25.94 36.58,24.4 v4(26.56,24.4) 26.21,24.4 22.78,20.98 v7(21.27,20.98) 20.59,20.3 20.59,19.12 18.85,17.38 v7(18.85,16.09)
  IN3 w0.508: v4(82.97,133.22) 85.02,133.22 86.04,132.2 94.27,132.2 94.82,131.66 v4(95.31,131.66) ; v6(38.65,55.34) 38.65,55.71 38.31,56.05 v4(38.25,56.05) ; v7(92.09,85.54) 89.45,82.9 74.23,82.9 73.6,83.52 61.77,83.52 60.78,84.51 58.31,84.51 58.15,84.68 54.78,84.68 54.62,84.51 45.27,84.51 v7(45.1,84.68)
  BOTTOM w0.508: v6(38.65,55.34) 38.8,55.18 38.8,48.01 39.01,47.81 39.01,26.13 v7(38.82,25.94)
+3VS_CAM: length 186.3
  IN2 w1.016: 238.39,144.8 237.74,144.8 236.57,143.64 231.34,143.64 229.53,145.45
  IN3 w0.254: v6(224.59,148.14) 226.14,148.14 228.06,146.22
  IN3 w0.762: 199.78,146.52 199.83,146.52 ; v6(206.03,147.66) 206.46,147.66 206.95,147.16 217.14,147.16 217.84,147.86 223.63,147.86 224.54,146.95 226.42,146.95 227.31,146.06
  IN3 w1.016: 199.83,146.52 199.9,146.59 201.05,146.59 202.11,147.66 v6(206.03,147.66) ; 239.48,143.43 241.18,141.73 243.08,141.73 244.2,140.61 244.2,136.69 242.3,134.78 242.3,133.76
  BOTTOM w0.254: v6(224.59,148.14) 224.16,148.57 206.84,148.57 206.03,147.76 v6(206.03,147.66)
  BOTTOM w1.016: 102.22,129.95 102.34,129.83 105.39,129.83 108.02,132.46 111.37,132.46 112.93,134.02 119.82,134.02 120.62,133.22 123.41,133.22 127.11,129.52 143.72,129.52 v14(147.05,132.85) 147.45,133.25 161.56,133.25 162.17,132.65 164.01,132.65 164.34,132.32 167.31,132.32 167.89,131.73 171.16,131.73 172.61,133.18 178.28,133.18 178.88,132.58 183.64,132.58 185.1,134.04 188.55,134.04 193.32,138.82 194.78,138.82 197.58,141.62 197.58,144.65 198.42,145.49
  vias: v4(227.97,145.52) v4(228.33,145.22) v4(239.26,144.8) v4(239.85,144.83) v6(198.35,146.34) v6(198.74,146.34) v6(199.07,146.31) v7(95.26,133.09) v7(95.27,132.49) v7(100.51,130.05) v7(101.09,130.05) v7(242.2,132.7) v7(242.83,132.72)
+3VS_CR: length 6
  TOP w0.203: 28.38,82.92 UR1.11 ; CR7.1 27.18,75.58 UR1.27
  TOP w0.254: CR11.1 26.47,75.55 CR7.1
  TOP w0.305: RR9.1 27.78,74.77 v7(27.46,74.46)
  TOP w0.381: RR1.2 29.31,74.72 v7(29.03,74.44)
  TOP w0.61: v7(25.76,75.74) 26.28,75.74 CR11.1
  vias: v7(28.35,85.35) v7(28.94,85.35) v7(34.4,88.1) v7(35.03,88.07) v14(28.66,86.37)
+3VS_TPM: length 26.4
  TOP w0.254: v7(195.36,131.17) 195.56,131.38 C210.1 196.12,131.73 196.49,131.37 U15.8
  TOP w0.508: v7(194.16,134.45) 194.16,134.84 193.91,135.09 R201.2 193.91,135.17 192.64,136.44 R200.2
  IN2 w0.508: v2(200.51,143.9) v4(199.19,143.9)
  IN3 w0.508: v4(199.19,143.9) 197.72,143.9 196.74,144.88 195.62,144.88 195.31,144.56 195.31,143.92 195.76,143.47 195.76,141.68 194.28,140.2 194.28,136.52 193.58,135.82 193.58,135.52 194.16,134.94 v7(194.16,134.45) 194.16,132.37 v7(195.36,131.17)
  BOTTOM w0.102: v14(195.08,130.63) 195.36,130.91 v7(195.36,131.17)
+3VS_TS: length 73.9
  TOP w0.254: JLVDS1.5 190.65,94.52 v1(191.61,95.49) ; RC239.2 RC238.2 186.11,100.47 v2(186.25,100.6)
  TOP w0.305: R5757.1 164.13,94.66 v10(164.55,95.08)
  TOP w0.508: v10(164.55,95.08) 164.04,95.59 C415.1
  IN1 w0.508: v3(189.06,90.76) 189.29,90.99 190.21,90.99 191.83,92.6 191.83,94.31 191.5,94.64 191.5,95.41 191.57,95.49 v1(191.61,95.49)
  GND1 w0.508: v10(164.55,95.08) 164.9,95.08 v4(165.18,94.8)
  IN2 w0.254: v4(182.29,101.15) 182.42,101.02 185.83,101.02 v2(186.25,100.6)
  IN2 w0.508: v3(189.06,90.76) 185.79,87.5 v4(185.21,87.5) ; v4(177.55,94.9) 177.45,94.8 v4(165.18,94.8)
  IN3 w0.508: v6(175.39,92.08) 179.46,92.08 180.07,91.47 181.24,91.47 v4(185.21,87.5) ; v6(178.03,94.88) 178.01,94.9 v4(177.55,94.9)
  GND4 w0.254: v4(182.29,101.15) 182.26,101.15 v9(181.87,101.54)
  GND4 w0.508: v9(164.47,94.45) 164.83,94.45 v4(165.18,94.8)
  BOTTOM w0.254: JITOUCH.1 164.41,92.31 C1222.1
  BOTTOM w0.508: v9(164.47,94.45) 164.47,93.29 164.23,93.05 C1222.1 ; v6(175.39,92.08) 175.39,92.24 v6(178.03,94.88) 178.77,94.88 181.87,97.98 v9(181.87,101.54) 181.69,101.72 v14(181.69,103.97) 183.11,105.39 186.34,105.39 v7(187.99,107.04)
+3VS_WLAN: length 2.3
  TOP w0.356: U13.5 241.44,128.8 v7(241.84,129.19)
  BOTTOM w0.102: v7(243.36,138.96) 243.36,138.49 v13(243.54,138.31)
  vias: v7(242.75,139.53) v7(242.78,138.95) v7(243.33,139.53) v7(244.23,107.4) v7(244.25,107.97) v7(245.17,108.8) v7(246.16,132.8) v7(246.16,132.22) v7(246.16,131.63)
+3VS_WWAN: length 29.7
  TOP w0.203: Q89.2 24.48,95.37 23.84,94.74 v1(23.84,94.56)
  TOP w0.254: v1(19.59,95.13) 19.59,94.97 19.12,94.5 R51.1
  IN1 w0.203: v1(14.48,96.06) 14.81,95.73 15.41,95.73 15.88,95.26 16.49,95.26 16.62,95.13 v1(19.59,95.13) ; v1(23.84,94.56) 23.77,94.48 20.9,94.48 19.91,93.49 v7(18.99,93.49)
  IN2 w1.27: 31.53,103.28 15.27,103.28
  vias: v2(9.54,100.54) v2(9.59,100.22) v2(9.86,100.55) v2(9.94,100.25) v2(11.16,99.14) v2(11.59,99.14) v2(12.4,97.95) v2(12.43,97.57) v2(12.53,99.47) v2(12.72,97.96) v2(12.74,97.58) v2(12.91,99.5) v2(13.27,99.68) v2(36.32,105.82) v2(36.62,105.82) v4(14.97,94.23) v4(14.97,93.77) v4(14.97,93.32) v4(15.42,93.77) v4(15.42,93.32) v7(28.02,90.28) v7(28.31,90.78) v7(28.61,90.28) v7(29.06,90.77) v7(29.18,90.21)
+5VALW: length 354
  TOP w0.203: U32.4 34.27,95.16 v10(34.19,95.23) ; C1227.1 156.22,94.55 155.76,94.55 155.73,94.57 U40.4 ; U34.4 191.62,101.32 v10(191.7,101.24) ; U30.4 233.58,135.36 v2(233.46,135.49) ; U33.4 100.79,88.35 v7(100.82,88.37) ; v7(194.83,128.19) 194.78,128.24 U31.4 ; U41.4 140.53,127.69 140.71,127.87 v2(140.71,127.99) ; v7(23.81,65.71) U36.4 ; U37.6 195.58,128.03 v7(195.42,128.19) ; JDMIC1.6 86.88,133.07 v2(86.72,132.91)
  TOP w0.254: PU801.4 86.43,104.09 PC803.1 ; U38.4 v10(34.14,85.26) ; PC1002.1 72.42,107.73 PU800.E10 ; v2(75.55,109.77) 74.77,109.77 74.19,110.35 PU800.A6 ; C1227.1 156.7,94.9 157,94.6 157.61,94.6 v2(157.66,94.65)
  TOP w0.305: v10(99.93,94.61) 100.03,94.61 100.41,94.23 100.41,93.91 100.59,93.74 U709.3 ; v1(142.35,85.96) 142.28,86.03 C1236.1 141.85,85.29 140.86,84.3 140.36,84.3 140.12,84.55 U710.3
  TOP w0.381: PQ212.2 177.29,105.99 PC221.1
  TOP w0.508: PR812.1 65.82,110.9 v7(65.23,110.32) 65.54,110.02 PR813.1 ; v10(80.48,114.11) 80.48,114.38 80.07,114.79 PR817.1 ; R21.1 v11(214.81,138.92) ; PQ212.2 174.49,105.99 v11(174.43,106.05) ; PC803.1 v7(87.13,104.12)
  IN1 w0.254: v5(169.25,91.14) 167.84,91.14 165.35,93.63 163.41,93.63 v3(163.38,93.66)
  IN1 w0.508: v7(168.89,85.38) 167.98,84.46 163.56,84.46 160.1,87.92 153.67,87.92 153.17,87.43 144.19,87.43 142.72,85.96 v1(142.35,85.96)
  GND1 w0.254: v10(191.7,101.24) 191.7,101.23 191.46,100.99 v4(191.4,100.99) ; v10(99.93,94.61) 100.08,94.61 100.1,94.6 v4(100.51,94.6)
  GND1 w0.381: v10(143.12,123.4) 142.63,123.4 v4(142.64,123.42) ; v4(218.6,138.01) 218.55,138.06 v10(218.09,138.06) ; v10(34.19,95.23) 34.27,95.31 v4(34.27,95.87)
  GND1 w0.508: v10(68.1,114.46) v4(68.48,114.08) ; v10(34.14,85.26) 33.97,85.43 v4(33.97,85.85) ; v10(80.48,114.11) 80.48,114.09 v4(80.22,113.83) ; v10(85.71,114.77) v4(85.05,114.77) ; v4(72.37,107.04) 72.24,107.18 v10(71.99,107.18) ; v4(169.45,91.73) 169.45,91.42 169.25,91.22 v5(169.25,91.14)
  IN2 w0.254: v3(163.38,93.66) 163,94.04 160.3,94.04 159.97,94.37 157.92,94.37 157.66,94.63 v2(157.66,94.65)
  IN2 w0.381: v2(233.46,135.49) v4(232.99,135.49)
  IN2 w0.508: v7(89.21,99.4) 89.97,98.64 90.94,98.64 92.23,97.34 94.57,97.34 95.79,96.12 98.88,96.12 99.19,95.82 100.04,95.82 100.51,95.35 v4(100.51,94.6) ; v2(75.55,109.77) 74.99,109.22 74.99,106.84 74.78,106.64 v2(74.78,106.38) 74.86,106.38 v4(75.27,105.98) ; v2(86.72,132.91) 85.44,132.91 84.77,133.59 84.09,133.59 83.05,134.63 v2(82.53,134.63) 81.73,133.83 80.07,133.83 78.89,132.65 78.89,132.56 77.64,131.32 v4(77.64,130.41)
  IN3 w0.508: v4(29.83,90.6) 31.63,88.79 31.63,86.57 32.09,86.11 33.7,86.11 v4(33.97,85.85) 33.29,85.85 30.4,82.95 30.4,82.86 29.98,82.44 29.98,77.8 30.4,77.38 30.4,71.86 28.58,70.05 28.58,67.39 27.76,66.57 24.5,66.57 23.81,65.87 v7(23.81,65.71) ; v6(27.15,95.99) 27.36,95.78 30.65,95.78 31.11,95.32 33.98,95.32 34.27,95.61 v4(34.27,95.87) ; v4(72.37,107.04) 74.2,107.04 v4(75.27,105.98) ; 141.27,124.43 141.27,122.65 141.13,122.51 v6(141.13,121.65)
  GND4 w0.254: v9(233.32,135.92) 233.32,135.82 v4(232.99,135.49) ; v4(191.4,100.99) 191.08,100.99 v16(191.01,101.05)
  GND4 w0.381: v4(218.6,138.01) v9(218.6,138.54)
  GND4 w0.508: v4(80.22,113.83) v16(80.78,113.83) ; v4(29.83,90.6) 29.65,90.78 v9(29.65,91.09) ; v4(72.37,107.04) v9(71.86,107.04) ; v4(68.48,114.08) 68.48,114.05 68.79,113.75 v16(68.79,113.76) ; v4(169.45,91.73) 169.6,91.58 v9(170.19,91.58) ; v4(100.51,94.6) 100.56,94.55 v9(100.56,94.09) ; v9(76.99,129.62) 76.99,129.76 v4(77.64,130.41) ; v4(85.05,114.77) v9(85.05,114.33)
  BOTTOM w0.254: v6(237.31,136.7) 236.53,135.92 v9(233.32,135.92)
  BOTTOM w0.508: v7(234.88,112.4) 234.92,112.4 235.68,111.64 243.43,111.64 244.82,113.04 244.82,117.94 243.33,119.44 243.33,130.54 244.89,132.1 244.89,135.64 v7(245.47,136.23) ; v9(85.05,114.33) 85.27,114.33 86.54,113.06 86.54,111.18 85.15,109.78 85.15,105.42 86.44,104.12 v7(87.13,104.12) 87.26,104.12 89.21,102.17 v7(89.21,99.4) 88.22,98.41 88.22,95.89 86.37,94.04 76.64,94.04 73.97,96.7 v6(73.97,97.01) ; 222.09,141.35 220.9,140.15 220.52,140.15 218.91,138.54 v9(218.6,138.54) 217.77,138.54 216.6,139.71 215.6,139.71 v11(214.81,138.92) ; v6(27.15,95.99) 27.11,96.03 25.08,96.03 23.9,94.85 23.9,93.54 v14(25.11,92.33) 26.08,91.36 29.38,91.36 v9(29.65,91.09) ; v9(76.99,129.62) 76.99,129.6 77.43,129.17 77.43,128.23 75.37,126.17 v17(75.37,124.06) ; v7(100.82,88.37) 100.56,88.63 v9(100.56,94.09) ; v17(173.49,99.68) 173.49,99.09 174.3,98.28 175.67,98.28 176.26,97.7 176.26,95.54 174.5,93.78 172.39,93.78 v9(170.19,91.58) 169.35,90.74 169.35,85.84 v7(168.89,85.38)
  BOTTOM w0.762: 194.01,128.37 193.4,128.98 193.4,130.47 195.28,132.34 195.28,132.84 197.97,135.53 201.54,135.53 203.32,137.31 203.32,140.52 202.98,140.86 202.98,143.67 203.53,144.22 207.61,144.22 208.6,145.21 219.46,145.21 222.09,142.58 222.09,141.35 223.12,140.32 228.14,140.32 228.29,140.47 229.66,140.47 230.89,139.24 232.66,139.24 233.47,140.05 234.51,140.05 234.84,139.72 235.82,139.72
  vias: v2(139.67,128.01) v2(246.74,135.89) v2(249.22,139.66) v2(249.5,139.86) v2(249.9,139.89) v2(249.9,139.56) v4(141.83,126.45) v4(238.44,137.3) v4(238.56,137.8) v4(238.77,136.89) v4(238.92,137.41) v4(239.26,137.04) v6(236.44,139.76) v6(236.38,139.39) v6(236.68,139.23) v6(236.79,139.62) v6(237.01,139.35) v6(237.13,139.75) v7(16.38,58.56) v7(16.41,57.98) v7(16.36,57.39) v7(16.38,56.76) v7(17.01,58.56) v7(17.02,57.98) v7(17.02,57.39) v7(17.06,56.78) v7(23.82,64.42) v7(37.85,58.87) v7(37.85,58.28) v7(37.87,57.68) v7(37.88,57.06) v7(38.46,58.84) v7(38.47,58.26) v7(38.47,57.67) v7(38.47,57.07) v7(187.7,121.76) v7(188.2,121.18) v7(188.27,121.79) v7(188.83,121.15) v7(188.86,121.76) v7(189.43,121.79) v7(189.46,121.18) v7(189.99,121.79) v7(190.1,121.18) v7(190.59,121.76) v14(32.59,60.43)
+5VALW_S: length 20.3
  IN2 w0.102: v2(168.79,126) 168.87,125.92 169.48,125.92 170.29,126.73 175.7,126.73 v4(175.83,126.6)
  IN3 w0.102: v4(175.83,126.6) 179.13,126.6 180.22,125.51 185.05,125.51 186.01,126.47 v7(186.01,128.28)
+5VS: length 1.5
  TOP w0.102: v13(140.93,122.79) 141.38,123.25 C212.1
+5VS_AUDIO: length 53.1
  TOP w0.508: R229.2 29.86,64.09 31.1,64.09 v7(31.12,64.12)
  IN1 w0.508: v7(38.21,22) v7(38.21,22.64) 38.64,22.64 39.81,23.81 39.81,56.6 39.69,56.71 39.69,62.97 v7(38.26,64.41)
  BOTTOM w0.508: v7(31.12,64.12) 31.53,64.52 34.77,64.52 v14(34.88,64.41) v7(38.26,64.41)
+5VS_AUDIO_AMP: length 9.3
  TOP w0.305: v7(195,122.11) 195.24,121.86 C275.1 195.69,122.53 R234.2
  TOP w0.508: v7(210.51,127.92) 210.57,127.92 213.65,124.85 v7(213.65,123.67) 213.02,123.05 LA19.2 ; LA18.2 213.62,118.78 v7(213.74,118.91)
  vias: v14(197.9,123.63)
+AVDD1: length 1.9
  TOP w0.203: CA4.1 34.52,17.03 UA1.45
+DVDD: length 8.1
  TOP w0.203: v7(29.47,23.2) 29.71,22.96 UA1.7
  TOP w0.381: RA25.1 36.43,25.09 v7(36.63,25.29) ; v7(29.47,23.2) 29.21,23.2 27.82,24.6 CA37.1 ; LA4.2 25.24,25.87 RA23.1
  TOP w0.508: CA37.1 27.34,24.6 LA4.2
  BOTTOM w0.254: CA38.1 29.7,22.97 v7(29.47,23.2)
  vias: v14(34.03,22.82)
+DVDDIO: length 300.2
  TOP w0.203: UA1.19 24.89,19.83 24.85,19.87 24.23,19.87 23.92,20.18 CA44.1 ; UA2.12 201.81,124.55 201.67,124.4 200.81,124.4 200.46,124.75 RA64.1
  TOP w0.254: v7(200.58,126.73) 200.08,126.24 CA113.1 200.08,125.7 200.17,125.61 CA114.1 RA64.1 ; v7(209.09,128.3) 209.09,127.99 208.68,127.58 RA70.2 RA71.2 ; v7(21.85,22.66) 21.85,21.46 RA27.2 23.11,20.2 CA43.1 23.9,20.16 CA44.1 ; Q349.5 204.7,128.84 v7(204.15,128.28) 204.7,127.72 Q349.2
  IN3 w0.254: v6(30.19,27.01) 29.28,27.92 26.51,27.92 23.36,24.77 22.79,24.77 21.85,23.84 v7(21.85,22.66)
  BOTTOM w0.254: v7(200.58,126.73) 200.58,126.76 ; 200.58,126.76 199.2,126.76 196.45,124.01 195.49,124.01 192.28,120.81 192.28,112.14 189.21,109.07 189.21,106.89 186.85,104.53 183.42,104.53 182.39,103.5 182.39,97.81 178.57,93.99 178.29,93.99 174.48,90.18 171.76,90.18 170.19,88.6 170.19,85.68 169.4,84.89 164.77,84.89 162.69,86.98 156.46,86.98 155.83,87.6 148.62,87.6 145.62,84.6 143.52,84.6 142.19,83.27 141.61,83.27 140.84,84.05 137.18,84.05 134.24,81.11 132.16,81.11 131.23,80.18 119.35,80.18 119.05,79.88 109.33,79.88 108.98,80.23 103.97,80.23 103.43,80.77 47.35,80.77 45.37,82.75 45.13,82.75 43.4,84.49 38.96,84.49 34.27,79.8 34.27,71.47 38.97,66.78 38.97,56.35 38.16,55.54 38.16,51.58 38.32,51.42 38.32,47.81 38.52,47.61 38.52,36.95 37.37,35.79 37.37,32.11 34.23,28.98 32.16,28.98 v6(30.19,27.01) ; 200.58,126.76 200.83,126.76 201.48,127.41 v14(203.41,127.41) 204.15,128.15 v7(204.15,128.28) 205.75,128.28 206.61,127.41 208.21,127.41 209.09,128.29 v7(209.09,128.3)
+PVDD: length 4.6
  TOP w0.203: CA108.1 209.23,122.72 209.02,122.51 208.69,122.51 208.35,122.17 UA2.44
  TOP w0.508: CA106.1 LA18.1 v7(210.83,118.78)
  vias: v7(209.38,123.15) v7(209.96,123.25) v7(210.78,118.17)
+V0.85A_S: length 13
  IN1 w0.102: v1(169.59,121.6) 169.51,121.52 169.51,121.28 169.7,121.09 v5(169.7,120.35)
  GND1 w0.102: v4(170.08,120) 169.96,120.12 169.92,120.12 169.7,120.35 v5(169.7,120.35)
  IN3 w0.102: v7(169.81,111.23) 172.4,113.83 172.4,118.19 170.59,120 v4(170.08,120)
+VCC_CORE: length 101.3
  TOP w0.127: UC1.D64 UC1.F64 ; UC1.D64 116.34,98.94 116.34,98.98 116.57,99.21 ; UC1.D64 116.59,98.48 116.44,98.33 116.75,98.03 UC1.B64 116.8,98.02 116.57,97.8 ; UC1.F64 116.8,98.98 116.57,99.21 ; UC1.F64 117.07,99.21 v1(117.07,99.31) 117.07,99.36 v1(116.8,99.64) ; v1(122.89,100.31) v1(123.21,100.06) v1(123.53,100.31) ; v1(122.89,100.31) v10(123.21,100.55) ; v1(122.89,100.31) v1(122.56,100.06) 122.49,100.06 v1(122.24,100.31) 122.17,100.31 v1(121.92,100.06) v1(121.6,100.31) v1(121.28,100.06) 121.2,100.06 v1(120.95,100.31) 120.88,100.31 v17(120.63,100.06) v1(120.31,100.31) v1(119.99,100.06) v1(119.67,100.31) ; v10(124.5,100.55) v1(124.17,100.31) ; v10(124.5,100.55) 124.38,100.67 123.97,100.67 v1(123.85,100.55) ; v10(124.5,100.55) v1(124.82,100.31) 124.83,100.32 v1(125.14,100.55) ; v10(124.5,100.55) 124.61,100.67 125.02,100.67 v1(125.14,100.55) ; v1(124.17,100.31) v1(123.85,100.55) ; v1(124.17,100.31) 123.93,100.06 v1(123.85,100.06) 123.78,100.06 v1(123.53,100.31) ; 116.57,97.8 116.56,97.8 116.34,97.57 ; 116.57,97.8 116.34,98.03 ; 116.57,97.8 UC1.A64 116.64,97.26 ; v1(119.67,100.31) v1(119.34,100.06) v1(118.77,100.12) ; v1(119.67,100.31) UC1.N54 119.29,100.49 v1(118.93,100.49) ; v1(125.14,100.55) 125.39,100.31 v1(125.46,100.31) 125.54,100.31 v1(125.78,100.55) ; v1(125.14,100.55) 125.26,100.67 125.67,100.67 v1(125.78,100.55) ; v1(116.8,100.92) 116.59,101.13 116.21,101.13 ; v1(116.8,100.92) 116.8,100.87 v1(117.07,100.6) ; v1(116.8,100.92) 116.8,100.98 v1(117.07,101.25) ; v1(116.8,100.92) 116.59,100.72 ; 116.57,99.21 116.8,99.55 v1(116.8,99.64) ; 116.57,99.21 116.57,99.22 v1(116.34,99.45) v1(116.8,99.64) ; v1(116.8,99.64) 116.3,100.13 ; v1(116.8,99.64) UC1.L63 v1(116.8,100.28) ; v1(116.8,100.28) v1(117.07,100.6) ; v1(116.8,100.28) 116.36,100.72 ; v1(116.8,100.28) 116.38,99.87 ; v1(117.07,100.6) v1(117.31,100.28) ; v1(118.93,100.49) v1(118.55,100.6) ; v1(118.93,100.49) 118.93,100.38 118.77,100.21 v1(118.77,100.12) ; v1(118.93,100.49) v1(118.79,100.92) ; v1(118.55,100.6) 118.3,100.28 ; v1(118.55,100.6) v1(118.3,100.92) ; v10(123.21,100.55) 123.45,100.31 v1(123.53,100.31) ; v10(123.21,100.55) v1(123.53,101.01) v1(123.85,100.55) ; v1(118.55,101.25) 118.55,101.21 118.3,100.97 v1(118.3,100.92) ; v1(118.55,101.25) v1(118.05,101.25) ; v1(118.55,101.25) 118.79,101 v1(118.79,100.92) ; v1(123.53,100.31) 123.61,100.31 v1(123.85,100.55) ; v1(118.79,100.92) v1(118.3,100.92) ; v1(118.77,100.12) v1(118.3,100.28) ; v1(125.78,100.55) 126.03,100.31 v1(126.11,100.31) 126.18,100.31 v1(126.43,100.55) 126.31,100.67 125.9,100.67 v1(125.78,100.55)
  TOP w0.229: v10(126.5,101.57) UC1.R32 ; v1(126.5,107.71) v10(126.5,108.27) v1(126.01,108.27) v1(125.51,108.27) v1(125.02,108.27) v10(124.52,108.27) v1(124.03,108.27) v10(123.53,108.27) v1(123.53,107.71)
  TOP w0.254: v7(89.41,114) 89.41,113.37 PR811.2 ; PL802.2 90.28,108.87 89.99,109.16 89.99,110.11 91.29,111.41 91.29,111.97 v1(91.48,112.16) ; v10(123.53,101.57) v1(123.53,101.01) ; PR814.2 76.52,112.95 PC807.2 v7(78.14,112.95)
  TOP w0.381: v1(126.5,104.36) v10(126.5,103.8) v1(126.5,103.24) v10(126.5,102.68) v1(126.5,102.12) v10(126.5,101.57) ; v1(126.5,104.36) v10(126.5,104.92) v1(126.5,105.48) v10(126.5,106.04) v1(126.5,106.59) v10(126.5,107.15) v1(126.5,107.71) ; v1(126.5,104.36) v1(126.01,104.36) v1(125.51,104.36) v1(125.02,104.36) v1(124.52,104.36) v1(124.03,104.36) v1(123.53,104.36) ; v1(123.53,107.71) v10(123.53,107.15) v1(123.53,106.59) v10(123.53,106.04) v1(123.53,105.48) v10(123.53,104.92) v1(123.53,104.36) ; v1(123.53,104.36) v10(123.53,103.8) v1(123.53,103.24) v10(123.53,102.68) v1(123.53,102.12) v10(123.53,101.57)
  TOP w0.508: PR833.2 PR834.2 76.55,105.32 v1(76.8,105.06)
  IN1 w0.254: v7(89.41,114) 89.39,113.98 89.39,113.17 90.39,112.16 v1(91.48,112.16)
  IN1 w0.508: v1(76.8,105.06) 77.4,105.66 80.94,105.66 82.51,107.22 83.42,107.22 84.33,106.31 85.89,106.31 86.06,106.48 88.2,106.48 88.65,106.03 v7(89.13,106.03)
  GND1 w0.254: v4(123.98,100.47) 124.07,100.55 v10(124.5,100.55) ; v4(123.07,102.71) 123.1,102.68 v10(123.53,102.68) ; v10(126.5,103.8) 126.4,103.9 v4(126.14,103.9) ; v4(126.17,102.76) 126.43,102.76 v10(126.5,102.68) ; v10(123.53,107.15) 123.09,107.15 v4(123.06,107.18) ; v4(123.06,106.07) 123.07,106.04 v10(123.53,106.04) ; v4(122.85,100.48) 122.93,100.55 v10(123.21,100.55) ; v4(123.07,103.77) 123.1,103.8 v10(123.53,103.8) ; v10(123.53,104.92) 123.11,104.92 v4(123.07,104.96) ; v4(126.22,106.97) 126.33,107.08 126.37,107.08 126.45,107.15 v10(126.5,107.15) ; v4(126.17,105.02) 126.4,105.02 v10(126.5,104.92) ; v4(123.06,101.6) 123.09,101.57 v10(123.53,101.57) ; v5(126.09,100.55) 126.2,100.55 126.35,100.7 v4(126.39,100.7) ; v10(126.5,101.57) 126.43,101.64 126.19,101.64 126.17,101.67 v4(126.17,101.68)
  IN2 w0.254: v7(89.41,114) 89.14,113.73 80.99,113.73 80.15,112.89 78.2,112.89 v7(78.14,112.95)
  GND4 w0.254: v16(126.7,102.65) 126.6,102.75 126.18,102.75 v4(126.17,102.76) ; v16(122.15,100.08) 121.57,100.08 v16(121.55,100.06) v16(120.94,100.06) v16(120.33,100.06)
  vias: v1(117.07,99.96) v1(117.31,100.92) v1(117.56,101.25) v1(117.56,100.6) v1(117.81,100.92) v1(117.81,100.28) v1(118.05,100.6) v4(123.18,108.2) v4(124.17,108.22) v4(125.23,108.24) v4(126.19,108.09) v4(126.17,106.14) v5(123.79,108.29) v5(124.78,108.26) v7(89.15,107.74) v7(89.11,107.18) v7(89.15,106.61) v7(89.72,107.75) v7(89.68,107.2) v7(89.72,106.62) v7(89.72,106.04) v7(90.3,107.74) v7(90.27,107.18) v7(90.3,106.61) v7(90.3,106.03) v7(90.85,107.2) v7(90.86,106.61) v7(90.86,106.03) v7(91.41,107.2) v7(91.42,106.61) v7(91.42,106.03) v7(91.97,107.2) v7(91.98,106.61) v7(91.98,106.03) v7(92.53,107.2) v7(92.54,106.61) v7(92.54,106.03) v7(93.08,107.2) v7(93.1,106.61) v7(93.1,106.03) v7(93.25,107.87) v7(93.26,109.61) v7(93.26,109.04) v7(93.26,108.45) v7(93.64,107.2) v7(93.75,108.16) v7(93.66,106.61) v7(100.02,101.1) v7(100.58,101.07) v7(101.14,101.29) v7(101.49,100.77) v7(106.89,99.79) v7(107.82,99.78) v7(108.77,99.75) v7(109.68,99.75) v7(111.08,99.2) v7(111.64,99.2) v7(112.22,99.2) v7(112.78,99.2) v7(113.42,99.2) v7(113.98,99.2) v7(114.53,99.2) v9(123.64,106) v9(123.65,107.12) v9(123.65,104.88) v9(123.65,103.74) v9(123.65,102.62) v9(123.65,101.51) v9(126.73,107.4) v9(126.73,106.28) v9(126.67,105.06) v9(126.73,103.61) v9(126.69,101) v14(111.49,100.31) v16(122.76,100.06) v16(122.86,108.4) v16(123.22,106.89) v16(123.42,106.18) v16(123.42,105.09) v16(123.42,103.97) v16(123.42,102.85) v16(123.42,101.74) v16(123.37,100.08) v16(123.82,108.3) v16(123.98,100.08) v16(126.5,107.15) v16(126.54,106.04) v16(126.47,104.86) v16(126.49,103.83) v16(126.52,101.35) v17(120.02,100.06) v17(121.24,100.06) v17(121.85,100.06) v17(122.46,100.08) v17(123.07,100.08) v17(123.58,107.73) v17(123.6,106.59) v17(123.64,105.44) v17(123.65,104.28) v17(123.65,103.18) v17(123.65,102.09) v17(123.68,100.08) v17(124.26,100.1) v17(126.7,106.86) v17(126.69,105.77) v17(126.68,104.15) v17(126.69,102.98) v17(126.69,101.68) v17(126.69,100.36)
