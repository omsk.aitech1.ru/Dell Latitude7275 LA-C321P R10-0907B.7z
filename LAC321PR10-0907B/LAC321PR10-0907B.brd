# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_COMP: length 4
  TOP w0.191: 135.58,100.6 UC1.N2
  TOP w0.254: 135.58,100.6 135.85,100.87 136.9,100.87 137.31,100.47 138.66,100.47 RC87.1
USB2_VBUSSENSE: length 1.9
  IN2 w0.06: v4(135.54,104.76) 135.52,104.78 135.37,104.78 135.05,104.47 134.16,104.47 v2(134.16,104.47)
  IN3 w0.084: v6(135.54,104.38) v4(135.54,104.76)
USB3RN1: length 140.4
  TOP w0.152: v2(243.76,111.74) ML15.1 243.51,111.84 RH137.1
  IN1 w0.06: 133.56,95.03 133.56,95.08 133.52,95.12 133.52,95.47 131.85,97.14 131.85,97.32 131.78,97.38 131.78,97.49 131.78,97.68 131.65,97.81 131.65,98.02 v1(131.58,98.09)
  IN1 w0.089: 133.56,95.03 133.56,93.61 133.79,93.38 133.79,92.35 136.17,89.97 137.97,89.97 v3(138.05,90.04)
  IN2 w0.084: v3(138.05,90.04) 138.14,89.95 139.42,89.95 139.64,90.16 142.92,90.16 144.87,88.22 147.95,88.22 150.47,90.74 153.66,90.74 154.47,89.92 161.87,89.92 162.4,89.4 163.06,89.4 163.61,89.95 172.02,89.95 173.96,88.01 183.04,88.01 190.41,95.38 190.41,96.81 191.16,97.57 191.63,97.57 194.06,100 194.06,100.98 196.18,103.1 196.18,104.1 197.23,105.14 197.23,105.4 199.97,108.14 201.64,108.14 202.47,108.96 206.04,108.96 206.87,109.8 210.11,109.8 210.31,109.6 211.51,109.6 212.15,108.96 216.37,108.96 217.94,110.53 217.94,113.42 218.79,114.27 230.36,114.27 231.77,112.86 231.77,111.55 233.24,110.08 235.33,110.08 236.66,111.4 243.42,111.4 v2(243.76,111.74)
USB3RN1_RC_CON: length 4.2
  TOP w0.152: RH137.2 242.02,111.84 ML15.2 241.68,111.74 241.5,111.92 241.23,111.92 241.08,111.77 241.08,111.4 240.95,111.27 240.58,111.27 240.02,110.71 239.85,110.71 239.69,110.86 239.69,111.04 239.77,111.12 JDEBUG1.10
USB3RN2: length 107.1
  TOP w0.152: R102.1 37.82,102.29 ML12.1 v2(38.27,102.29)
  IN1 w0.06: v3(132.72,97.15) 132.27,97.15 131.9,97.51 v1(131.9,97.84)
  IN2 w0.06: v3(132.72,97.15) 132.73,97.16 132.73,97.7 v4(132.73,97.7)
  IN2 w0.084: v2(38.27,102.29) 38.51,102.05 38.71,102.05 39.12,101.64 39.12,100.86 v4(39.26,100.71)
  IN3 w0.084: v4(39.26,100.71) 39.14,100.59 39.14,99.99 39.85,99.28 41.81,99.28 42.03,99.05 62.2,99.05 65.91,95.34 74.24,95.34 74.67,94.92 75.38,94.92 76.31,93.99 86.82,93.99 89.4,96.56 101.49,96.56 103.12,98.19 105.94,98.19 107.27,99.53 107.27,100.1 108.14,100.97 110.54,100.97 111.11,100.4 113.03,100.4 113.13,100.3 115.54,100.3 116.15,99.69 118.65,99.69 119.84,98.5 121.52,98.5 121.72,98.3 122.07,98.3 123.05,97.32 124.15,97.32 125.12,98.29 126.39,98.29 126.56,98.46 131.83,98.46 131.99,98.31 132.37,98.31 132.57,98.11 132.57,97.87 v4(132.73,97.7)
USB3RN2_RC_CON: length 12.8
  TOP w0.152: R102.2 36.69,102.29 ML12.2 v2(36.29,102.29) ; JNGFF1.21 v2(25.8,101.93)
  IN2 w0.084: v2(36.29,102.29) 36.29,101.99 36.16,101.86 35.34,101.86 35.13,101.66 31.98,101.66 31.68,101.35 30.52,101.35 30.24,101.64 26.45,101.64 26.32,101.51 25.71,101.51 25.65,101.57 25.65,101.78 v2(25.8,101.93)
USB3RN3: length 76.8
  TOP w0.152: R88.1 119.75,125.01 ML4.1 119.75,124.43 v10(119.74,124.42)
  GND1 w0.089: v10(130.94,98.09) 131.08,98.09 v4(131.28,97.89) ; v4(119.74,124.04) v10(119.74,124.42)
  IN3 w0.084: v4(131.28,97.89) 131.66,97.89 131.87,97.68 131.87,97.58 132.23,97.22 134.06,97.22 134.29,97.44 134.29,97.82 133.22,98.89 133.22,99.31 132.56,99.97 131.53,99.97 131.08,99.53 126.07,99.53 125.87,99.33 123.28,99.33 122.84,99.77 122.41,99.77 122.18,100 120.38,100 119.16,101.22 119.16,102.73 116.92,104.96 113.93,104.96 110.48,108.41 105.7,108.41 102.28,111.83 102.28,122.3 103.06,123.08 106.49,123.08 106.6,123.19 106.6,123.56 106.77,123.74 107.33,123.74 107.51,123.56 107.51,123.19 107.6,123.11 107.96,123.11 108.61,123.75 115.64,123.75 116.9,122.48 117.74,122.48 118.47,123.21 118.47,124.35 118.83,124.7 119.31,124.7 119.55,124.46 119.55,124.22 v4(119.74,124.04)
USB3RN3_RC_CON: length 35.7
  TOP w0.152: v7(119.08,129.93) 118.98,129.82 118.98,129.61 119,129.59 MD1.1 MD1.9 119,127.98 118.98,127.96 118.98,127.73 119.46,127.25 119.46,127.03 119.75,126.75 ML4.2 119.75,126.14 R88.2 ; JCAM2.2 98.94,133.35 98.91,133.38 98.91,133.59 v7(99.04,133.72)
  IN2 w0.084: v7(99.04,133.72) 98.81,133.49 98.81,132.51 99.69,131.62 99.69,129.85 100.15,129.4 101.14,129.4 101.69,128.85 106.8,128.85 106.89,128.76 109.6,128.76 110.33,129.48 112.54,129.48 113.18,130.12 113.18,132.99 113.68,133.5 117.27,133.5 118.91,131.85 118.91,130.1 v7(119.08,129.93)
USB3RN4: length 27.1
  TOP w0.152: v1(122.9,82.25) 122.82,82.34 122.82,82.47 122.9,82.56 JPOGO.78
  IN1 w0.06: 132.28,95.03 132.28,96.13 131.38,97.03 131.38,97.65 131.51,97.79 131.51,97.87 131.41,97.98 131.32,97.98 131.26,97.91 v1(131.26,97.84)
  IN1 w0.089: v1(122.9,82.25) 122.82,82.25 122.75,82.32 122.75,82.44 122.9,82.58 123.27,82.58 124.47,83.78 127.84,83.78 128.86,82.76 130.79,82.76 132.18,84.15 132.18,86.25 132.58,86.66 132.58,90.56 131.96,91.18 131.96,92.87 132.16,93.07 132.16,94.72 132.26,94.81 132.26,94.88 132.28,94.9 132.28,95.03
USB3RP1: length 140.3
  TOP w0.152: v2(243.76,110.94) ML15.4 243.51,110.83 RH138.1
  IN1 w0.06: 133.34,95.03 133.34,95.06 133.4,95.12 133.4,95.42 131.73,97.09 131.73,97.27 131.67,97.33 131.56,97.33 131.5,97.38 131.5,97.49 v1(131.58,97.57)
  IN1 w0.089: v3(138.05,89.69) 137.98,89.75 136.09,89.75 133.57,92.26 133.57,93.29 133.34,93.52 133.34,95.03
  IN2 w0.084: v3(138.05,89.69) 138.14,89.78 139.49,89.78 139.71,90 142.86,90 144.8,88.06 148.02,88.06 150.54,90.57 153.59,90.57 154.41,89.76 161.8,89.76 162.33,89.24 163.13,89.24 163.67,89.78 171.95,89.78 173.89,87.84 183.1,87.84 190.57,95.31 190.57,96.74 191.23,97.4 191.7,97.4 194.23,99.93 194.23,100.91 196.35,103.03 196.35,104.03 197.39,105.08 197.39,105.33 200.03,107.97 201.71,107.97 202.53,108.8 206.1,108.8 206.94,109.63 210.04,109.63 210.24,109.43 211.44,109.43 212.08,108.8 216.44,108.8 218.1,110.46 218.1,113.35 218.86,114.11 230.29,114.11 231.61,112.79 231.61,111.48 233.18,109.91 235.4,109.91 236.73,111.24 243.46,111.24 v2(243.76,110.94)
USB3RP1_RC_CON: length 4.2
  TOP w0.152: RH138.2 242.02,110.83 ML15.3 240.72,110.94 240.16,110.37 239.71,110.37 239.35,110.72 239.35,110.99 239.27,111.07 JDEBUG1.9
USB3RP2: length 107.2
  TOP w0.152: v2(38.27,101.49) ML12.4 37.82,101.49 R105.1
  IN1 w0.06: v1(131.9,98.34) 131.9,98.13 132.11,97.92 132.11,97.63 132.38,97.37 v3(132.44,97.37)
  IN2 w0.06: v4(132.22,97.71) 132.35,97.58 132.35,97.45 v3(132.44,97.37)
  IN2 w0.084: v4(38.65,100.71) 38.79,100.71 38.96,100.88 38.96,101.57 38.64,101.88 38.37,101.88 38.27,101.78 v2(38.27,101.49)
  IN3 w0.084: v4(132.22,97.71) 132.26,97.71 132.4,97.85 132.4,98.04 132.3,98.14 131.92,98.14 131.76,98.3 126.63,98.3 126.46,98.13 125.19,98.13 124.22,97.16 122.98,97.16 122,98.13 121.65,98.13 121.45,98.33 119.77,98.33 118.58,99.52 116.08,99.52 115.47,100.13 113.06,100.13 112.96,100.24 111.04,100.24 110.47,100.81 108.21,100.81 107.44,100.03 107.44,99.46 106,98.03 103.19,98.03 101.56,96.4 89.47,96.4 86.89,93.82 76.24,93.82 75.31,94.75 74.6,94.75 74.17,95.18 65.84,95.18 62.13,98.89 41.97,98.89 41.74,99.12 39.78,99.12 38.98,99.92 38.98,100.51 38.77,100.71 v4(38.65,100.71)
USB3RP2_RC_CON: length 12.8
  TOP w0.152: v2(36.29,101.49) ML12.3 36.69,101.49 R105.2 ; JNGFF1.23 v2(25.3,101.93)
  IN2 w0.084: v2(36.29,101.49) 36.08,101.7 35.4,101.7 35.2,101.49 32.05,101.49 31.75,101.19 30.45,101.19 30.17,101.47 26.52,101.47 26.39,101.34 25.65,101.34 25.48,101.51 25.48,101.74 v2(25.3,101.93)
USB3RP3: length 76.8
  TOP w0.152: v10(118.94,124.42) 118.95,124.43 ML4.4 118.95,125.01 R89.1
  GND1 w0.089: v10(118.94,124.42) 118.94,124.11 v4(119.01,124.04) ; v10(130.94,97.57) 131.07,97.43 v4(131.51,97.43)
  IN3 w0.084: v4(119.01,124.04) 119.15,123.9 119.3,123.9 119.39,123.99 119.39,124.39 119.24,124.53 118.89,124.53 118.64,124.28 118.64,123.15 117.81,122.32 116.83,122.32 115.57,123.59 108.68,123.59 108.03,122.94 107.53,122.94 107.35,123.12 107.35,123.49 107.27,123.58 106.84,123.58 106.76,123.49 106.76,123.12 106.55,122.92 103.13,122.92 102.44,122.23 102.44,111.9 105.77,108.57 110.55,108.57 113.99,105.12 116.99,105.12 119.32,102.79 119.32,101.29 120.45,100.16 122.24,100.16 122.47,99.93 122.91,99.93 123.35,99.49 125.8,99.49 126,99.69 131.02,99.69 131.46,100.13 132.62,100.13 133.38,99.38 133.38,98.96 134.45,97.89 134.45,97.37 134.13,97.06 132.16,97.06 131.78,97.43 v4(131.51,97.43)
USB3RP3_RC_CON: length 35.7
  TOP w0.152: JCAM2.3 98.54,133.31 98.57,133.34 98.57,133.61 v7(98.46,133.72) ; R89.2 118.95,126.14 ML4.3 118.95,126.82 119.12,127 119.12,127.11 118.64,127.59 118.64,127.92 118.5,128.06 MD1.8 MD1.2 v7(118.5,129.93)
  IN2 w0.084: v7(98.46,133.72) 98.64,133.54 98.64,132.44 99.53,131.55 99.53,129.78 100.08,129.23 101.07,129.23 101.62,128.68 106.74,128.68 106.83,128.6 109.67,128.6 110.39,129.32 112.6,129.32 113.34,130.06 113.34,132.93 113.75,133.33 117.2,133.33 118.75,131.78 118.75,130.18 v7(118.5,129.93)
USB3RP4: length 27.2
  TOP w0.152: JPOGO.76 v1(122.5,82.25)
  IN1 w0.06: 132.06,95.03 132.06,95.04 132.07,95.04 132.1,95.04 132.16,95.1 132.16,96.08 131.26,96.98 131.26,97.53 131.04,97.75 131.04,97.91 131.26,98.13 v1(131.26,98.34)
  IN1 w0.089: v1(122.5,82.25) 122.54,82.29 122.54,82.53 122.81,82.8 123.18,82.8 124.38,83.99 127.93,83.99 128.95,82.98 130.7,82.98 131.96,84.24 131.96,86.34 132.37,86.75 132.37,90.47 131.74,91.09 131.74,92.96 131.95,93.16 131.95,94.81 132.04,94.9 132.04,94.97 132.06,94.99 132.06,95.03
USB3TN1: length 149.5
  IN2 w0.06: 136.51,95.54 136.5,95.54 136.5,95.57 136.34,95.74 136.34,96.02 135.64,96.71 135.36,96.71 134.74,97.33 134.74,97.87 133.66,98.95 133.03,98.95 132.44,99.53 131.84,99.53 131.66,99.36 131.58,99.36 131.51,99.3 131.51,99.14 v2(131.58,99.07)
  IN2 w0.084: v2(242.55,105.84) 242.41,105.98 242.32,105.98 242.27,105.92 242.27,105.52 242.41,105.38 242.75,105.38 242.92,105.55 242.92,109.14 244.65,110.87 244.65,111.83 243.87,112.61 236.96,112.61 235.05,110.69 233.57,110.69 232.36,111.9 232.36,113.14 230.59,114.92 218.41,114.92 217.29,113.8 217.29,110.8 216.11,109.62 213.48,109.62 211.98,111.12 209.76,111.12 209.47,110.83 206.5,110.83 205.71,110.04 200.5,110.04 195.23,104.77 195.23,103.35 193.22,101.34 193.22,100.36 191.39,98.52 190.95,98.52 189.58,97.15 189.58,95.7 182.73,88.85 174.45,88.85 172.89,90.41 154.54,90.41 153.8,91.14 150.31,91.14 148.29,89.13 147.23,89.13 146.83,89.53 144.21,89.53 143.13,90.61 139.35,90.61 138.11,91.85 138.11,93.93 136.51,95.54
USB3TN1_R: length 1.6
  TOP w0.152: CH45.2 242.43,106.54 242.43,106.97 242.66,107.2 ML13.1 242.77,107.58 RH136.1
USB3TN1_RC_CON: length 7.7
  TOP w0.152: RH136.2 242.77,109.07 ML13.2 242.66,109.51 242.43,109.75 242.43,110.05 242.12,110.36 241.01,110.36 240.64,109.99 240.41,109.99 240.07,109.64 238.49,109.64 238.19,109.94 238.19,110.79 238.27,110.87 JDEBUG1.7
USB3TN2: length 130.4
  GND1 w0.06: v10(131.9,98.83) 132.14,98.83 v4(132.29,98.67)
  IN2 w0.084: v2(18.27,96.26) 18.43,96.1 18.43,95.88 v4(18.27,95.72)
  IN3 w0.084: v4(132.29,98.67) 132.16,98.8 131.83,98.8 131.73,98.7 126.45,98.7 126.28,98.53 124.93,98.53 123.96,97.55 123.18,97.55 122.2,98.53 121.85,98.53 121.65,98.74 119.93,98.74 118.75,99.92 116.25,99.92 115.58,100.59 113.19,100.59 112.97,100.81 111.4,100.81 110.8,101.4 107.74,101.4 106.48,100.15 106.48,99.42 105.65,98.59 102.95,98.59 101.82,97.46 100.76,97.46 100.24,97.98 98.61,97.98 98.14,97.51 89.76,97.51 86.66,94.41 76.49,94.41 75.57,95.32 74.82,95.32 74.38,95.77 66.04,95.77 62.36,99.45 42.22,99.45 41.99,99.68 40.91,99.68 39.45,101.14 38.21,101.14 37.6,100.52 37.6,99.65 36.83,98.88 35.45,98.88 34.38,97.8 28.96,97.8 27.64,99.12 26.52,99.12 25.86,99.78 24.98,99.78 24.41,100.35 23.07,100.35 22.57,99.85 22.57,97.91 19.8,95.14 18.71,95.14 18.51,95.34 18.51,95.49 v4(18.27,95.72)
USB3TN2_R: length 1.9
  TOP w0.152: C137.2 18.44,97.02 18.44,97.54 18.17,97.81 ML11.4 18.17,98.43 R101.1
USB3TN2_RC_CON: length 11
  TOP w0.152: R101.2 18.17,99.56 ML11.3 v2(18.17,100.12) ; v2(24.64,100.9) 24.64,101.07 24.25,101.46 24.25,101.61 24.3,101.65 JNGFF1.27
  IN2 w0.084: v2(18.17,100.12) 18.19,100.14 18.19,100.63 19.87,102.3 23.87,102.3 24.55,101.62 24.55,100.99 v2(24.64,100.9)
USB3TN3: length 72.5
  GND1 w0.089: v4(117.45,123.58) 117.77,123.25 v10(117.77,123.19)
  IN2 w0.06: v2(130.94,99.07) 130.94,98.7 131.13,98.51 131.42,98.51 131.92,98.01 132.97,98.01 133.16,97.82 133.22,97.82 133.43,97.6 v4(133.43,97.6)
  IN3 w0.084: v4(117.45,123.58) 117.51,123.58 117.66,123.43 117.66,123.31 117.57,123.22 116.94,123.22 115.69,124.47 105.38,124.47 104.59,123.68 102.85,123.68 101.71,122.54 101.71,111.61 105.55,107.77 110.23,107.77 112.9,105.1 112.9,104.6 112.57,104.27 112.57,103.59 113.34,102.82 115.09,102.82 115.93,101.98 116.27,101.98 117.31,100.94 118.87,100.94 120.24,99.57 122.01,99.57 122.21,99.36 122.65,99.36 123.08,98.93 126.07,98.93 126.24,99.11 131.31,99.11 131.76,99.55 132.4,99.55 132.79,99.16 132.79,98.66 133.56,97.89 133.56,97.73 v4(133.43,97.6)
USB3TN3_RC_CON: length 33.5
  TOP w0.152: v7(97.8,134.1) 97.8,134.1 97.71,134.01 97.71,133.4 97.74,133.37 JCAM2.5 ; R87.2 117.86,126.46 ML3.2 117.86,127.01 117.5,127.37 MD1.7 MD1.4 117.5,129.8 v7(117.68,129.98)
  IN2 w0.084: v7(117.68,129.98) 117.66,129.95 117.66,129.5 116.85,128.68 115.88,128.68 115.38,128.18 114.81,128.18 114.59,128.39 110.25,128.39 109.84,127.99 106.5,127.99 106.36,128.13 100.35,128.13 98.98,129.49 98.98,131.32 96.61,133.7 96.61,134.34 97,134.73 97.42,134.73 97.59,134.55 97.59,134.32 v7(97.8,134.1)
USB3TN4: length 24.1
  IN2 w0.06: 136.43,94.64 136.42,94.64 136.42,94.66 136.37,94.71 136.37,94.72 134.34,96.76 134.34,97.68 133.91,98.1 133.37,98.1 133.23,98.25 132.04,98.25 131.54,98.75 131.45,98.75 131.34,98.86 131.3,98.86 v2(131.26,98.83)
  IN2 w0.084: 136.43,94.64 136.66,94.41 136.66,91.81 136.42,91.57 136.42,90.22 135.46,89.26 135.46,88.14 133.82,86.51 133.39,86.51 130.72,83.85 130.03,83.85 129.87,84.01 129.87,84.23 130.07,84.43 130.77,84.43 130.83,84.37 130.83,84.23 130.74,84.15 v2(130.26,84.15)
USB3TN4_R: length 10.1
  TOP w0.152: v1(122.89,86.93) 122.89,86.92 122.89,86.68 122.9,86.66 JPOGO.77
  IN1 w0.089: v1(122.89,86.93) 122.76,87.06 122.76,87.17 122.84,87.25 125.29,87.25 125.52,87.02 128.11,87.02 128.72,86.41 128.72,84.97 129.37,84.32 129.5,84.32 v1(129.68,84.15)
USB3TP1: length 149.5
  IN2 w0.06: v2(131.58,99.57) 131.67,99.65 132.49,99.65 133.08,99.07 133.71,99.07 134.86,97.92 134.86,97.38 135.41,96.83 135.69,96.83 136.46,96.07 136.46,95.79 136.57,95.68 136.6,95.68 136.62,95.65
  IN2 w0.084: v2(241.98,105.84) 242.11,105.71 242.11,105.46 242.35,105.22 242.82,105.22 243.08,105.48 243.08,109.07 244.81,110.8 244.81,111.9 243.94,112.77 236.9,112.77 234.98,110.85 233.64,110.85 232.52,111.97 232.52,113.21 230.65,115.08 218.34,115.08 217.13,113.87 217.13,110.87 216.04,109.78 213.55,109.78 212.05,111.29 209.7,111.29 209.4,110.99 206.43,110.99 205.64,110.21 200.44,110.21 195.07,104.84 195.07,103.41 193.06,101.41 193.06,100.43 191.32,98.69 190.89,98.69 189.41,97.21 189.41,95.77 182.66,89.01 174.52,89.01 172.96,90.57 154.61,90.57 153.87,91.31 150.24,91.31 148.22,89.29 147.3,89.29 146.89,89.7 144.28,89.7 143.2,90.77 139.42,90.77 138.27,91.92 138.27,94 136.62,95.65
USB3TP1_R: length 1.6
  TOP w0.152: CH44.2 242.09,106.53 242.09,106.97 241.86,107.2 ML13.4 241.75,107.58 RH133.1
USB3TP1_RC_CON: length 7.7
  TOP w0.152: RH133.2 241.75,109.07 ML13.3 241.86,109.5 242.09,109.73 242.09,109.91 241.98,110.02 241.15,110.02 240.78,109.65 240.55,109.65 240.21,109.31 238.35,109.31 237.85,109.8 237.85,110.79 237.77,110.87 JDEBUG1.6
USB3TP2: length 130.4
  GND1 w0.06: v4(132.27,99.18) 132.13,99.32 v10(131.9,99.32)
  IN2 w0.084: v4(18.88,95.72) 18.75,95.72 18.59,95.88 18.59,96.11 18.74,96.26 v2(18.9,96.26)
  IN3 w0.084: v4(132.27,99.18) 132.05,98.96 131.76,98.96 131.66,98.86 126.38,98.86 126.21,98.69 124.86,98.69 123.89,97.72 123.25,97.72 122.27,98.7 121.92,98.7 121.71,98.9 120,98.9 118.82,100.08 116.31,100.08 115.65,100.75 113.26,100.75 113.04,100.97 111.46,100.97 110.87,101.57 107.67,101.57 106.32,100.22 106.32,99.49 105.58,98.75 102.88,98.75 101.76,97.62 100.83,97.62 100.31,98.14 98.55,98.14 98.08,97.67 89.69,97.67 86.59,94.57 76.55,94.57 75.64,95.48 74.89,95.48 74.45,95.93 66.11,95.93 62.43,99.61 42.29,99.61 42.06,99.84 40.98,99.84 39.52,101.3 38.14,101.3 37.44,100.59 37.44,99.72 36.76,99.04 35.39,99.04 34.31,97.96 29.03,97.96 27.71,99.28 26.59,99.28 25.93,99.94 25.05,99.94 24.48,100.51 23,100.51 22.41,99.92 22.41,97.98 19.73,95.3 18.78,95.3 18.67,95.41 18.67,95.51 v4(18.88,95.72)
USB3TP2_R: length 1.9
  TOP w0.152: C158.2 18.7,97.05 18.7,97.55 18.97,97.82 ML11.1 18.97,98.43 R100.1
USB3TP2_RC_CON: length 11.1
  TOP w0.152: v2(18.97,100.12) ML11.2 18.97,99.56 R100.2 ; v2(24.29,100.9) 24.29,100.95 23.92,101.32 23.92,101.56 23.8,101.68 JNGFF1.29
  IN2 w0.084: v2(18.97,100.12) 18.89,100.03 18.57,100.03 18.44,100.16 18.44,100.23 18.36,100.32 18.36,100.56 19.93,102.14 23.81,102.14 24.39,101.56 24.39,101 v2(24.29,100.9)
USB3TP3: length 72.6
  GND1 w0.089: v10(117.14,123.19) v4(117.45,122.87)
  IN2 w0.06: v2(130.94,99.57) 130.94,99.36 131.14,99.15 131.14,98.99 131.06,98.91 131.06,98.75 131.18,98.63 131.47,98.63 131.97,98.13 133.02,98.13 133.21,97.94 133.6,97.94 v4(133.94,97.6)
  IN3 w0.084: v4(117.45,122.87) 117.26,123.06 116.87,123.06 115.63,124.31 105.45,124.31 104.66,123.52 102.92,123.52 101.87,122.47 101.87,111.68 105.62,107.93 110.29,107.93 113.06,105.17 113.06,104.53 112.73,104.2 112.73,103.65 113.4,102.98 115.16,102.98 116,102.14 116.34,102.14 117.38,101.1 118.94,101.1 120.31,99.73 122.08,99.73 122.28,99.53 122.72,99.53 123.15,99.09 126,99.09 126.18,99.27 131.24,99.27 131.69,99.71 132.47,99.71 132.96,99.23 132.96,98.73 133.72,97.96 133.72,97.81 v4(133.94,97.6)
USB3TP3_RC_CON: length 33.5
  TOP w0.152: v7(116.88,130.11) 116.88,130.03 117,129.91 MD1.5 MD1.6 117,127.97 117.16,127.81 117.16,127.23 117.16,127.14 117.06,127.03 ML3.3 117.06,126.46 R86.2 ; JCAM2.6 97.34,133.36 97.37,133.39 97.37,133.96 v7(97.22,134.1)
  IN2 w0.084: v7(97.22,134.1) 97.43,134.32 97.43,134.48 97.35,134.57 97.06,134.57 96.77,134.27 96.77,133.76 99.14,131.39 99.14,129.56 100.42,128.29 106.42,128.29 106.56,128.15 109.77,128.15 110.18,128.56 114.66,128.56 114.88,128.34 115.31,128.34 115.82,128.85 116.78,128.85 117.5,129.56 117.5,129.64 117.3,129.83 117.3,130.28 117.24,130.35 117.06,130.35 116.88,130.17 v7(116.88,130.11)
USB3TP4: length 24
  IN2 w0.06: v2(131.26,99.32) 131.31,99.27 131.31,99.06 131.43,98.95 131.43,98.95 131.5,98.87 131.59,98.87 132.09,98.37 133.28,98.37 133.42,98.22 133.96,98.22 134.46,97.73 134.46,96.81 136.5,94.77 136.51,94.77
  IN2 w0.084: 136.51,94.77 136.53,94.77 136.82,94.48 136.82,91.74 136.58,91.5 136.58,90.15 135.62,89.19 135.62,88.08 133.89,86.35 133.45,86.35 130.79,83.68 129.97,83.68 129.7,83.94 129.7,84.3 130.01,84.6 130.16,84.6 v2(130.26,84.7)
USB3TP4_R: length 10.5
  TOP w0.152: JPOGO.75 122.5,86.66 122.55,86.71 122.55,86.91 v1(122.54,86.93)
  IN1 w0.089: v1(122.54,86.93) 122.54,86.93 122.54,87.26 122.75,87.47 125.38,87.47 125.61,87.24 128.2,87.24 128.94,86.5 128.94,85.06 129.46,84.54 129.62,84.54 129.68,84.59 v1(129.68,84.7)
USB20_N1: length 55.8
  TOP w0.152: v2(130.26,90.68) 130.26,90.67 131.22,89.7 131.22,88.92 130.85,88.54 ML5.1 129.27,88.38 R82.1
  IN1 w0.06: 140.06,104.16 140.05,104.16 140.01,104.11 139.53,104.11 139.39,103.97 139.17,103.97 138.76,104.38 138.76,105.04 138.11,105.69 137.5,105.69 137.2,105.99 136.12,105.99 136.07,105.93 135.4,105.93 135.25,106.08 134.48,106.08 v1(134.16,105.76)
  IN1 w0.089: 140.06,104.16 140.15,104.16 140.35,104.36 140.35,105.99 141.74,107.37 142.27,107.37 142.35,107.45 144.23,107.45 144.43,107.25 144.58,107.25 146.43,105.4 146.43,103.52 147.45,102.5 147.94,102.5 148.8,101.63 148.8,101.1 150.27,99.64 150.27,99.25 v7(150.45,99.07)
  IN2 w0.084: v4(130.11,92.51) 130.11,91.27 130.26,91.12 v2(130.26,90.68)
  IN3 w0.084: v7(150.45,99.07) 150.2,98.81 150.2,98.56 150,98.37 148.94,98.37 148.45,97.87 147.78,97.87 147.17,97.26 145.4,97.26 144.89,96.76 144.89,96.25 144.43,95.79 143.95,95.79 143.44,95.28 142.27,95.28 142.17,95.18 140.62,95.18 139.89,94.45 139.16,94.45 138.88,94.17 136.84,94.17 136.4,93.73 133.81,93.73 133.55,94 131.04,94 130.82,93.77 130.82,93.29 130.52,93 130.24,93 130.11,92.86 v4(130.11,92.51)
USB20_N1_R: length 8.8
  TOP w0.152: JPOGO.71 121.7,86.7 121.69,86.71 121.69,86.73 121.66,86.76 121.66,86.87 122.13,87.34 124.86,87.34 125.11,87.59 125.25,87.59 125.39,87.45 D74.3 125.59,87.23 125.81,87.45 125.81,87.64 126.14,87.96 126.49,87.96 127.06,88.53 127.5,88.53 127.6,88.63 127.83,88.63 127.92,88.54 ML5.2 128.36,88.37 R82.2
USB20_N3: length 126
  TOP w0.152: R37.1 238.07,117.5 ML1.4 v2(237.64,117.5)
  IN1 w0.06: v1(134.16,106.4) 134.37,106.4 134.57,106.6 134.74,106.6 134.85,106.48 135.41,106.48 135.54,106.35 138.21,106.35 138.21,106.35 138.74,106.35 138.89,106.2 138.89,105.96 139.71,105.14 v3(139.71,104.63)
  IN2 w0.06: v3(139.71,104.63) 139.61,104.53 139.61,104.39 139.7,104.3 139.93,104.3
  IN2 w0.084: v2(237.64,117.5) 237.64,117.38 237.41,117.16 237.32,117.16 236.94,116.78 236.94,115.94 236.02,115.02 236.02,112.97 234.63,111.58 233.94,111.58 233.25,112.27 233.25,113.49 230.91,115.83 226.83,115.83 225.43,117.23 218,117.23 217.2,116.43 213.1,116.43 210.71,114.04 209.87,114.04 209.59,114.32 206.97,114.32 206.18,113.52 202.93,113.52 202.28,112.87 197.25,112.87 195.4,111.02 195.4,110.03 192.36,106.99 192.36,105.16 189.77,102.57 185.07,102.57 184.55,102.05 181.83,102.05 180.85,101.07 176.43,101.07 176.03,100.67 173.11,100.67 172.48,100.04 170.48,100.04 170.26,100.26 169.35,100.26 168.47,99.38 164.56,99.38 164.3,99.12 163.2,99.12 162.89,99.43 157.85,99.43 156.78,98.37 151.94,98.37 150.63,99.68 147.83,99.68 147.57,99.94 146.02,99.94 144.18,101.79 142.04,101.79 140.3,103.53 140.3,104.06 140.06,104.3 139.93,104.3
USB20_N3_R: length 12.5
  TOP w0.152: R37.2 239.15,117.5 ML1.3 v2(239.69,117.5)
  IN2 w0.084: v2(246.39,109.37) 246.25,109.23 246.13,109.23 246.07,109.29 246.07,111.96 242.4,115.63 241.65,115.63 240.13,117.15 239.82,117.15 239.69,117.28 v2(239.69,117.5)
USB20_N5: length 149.6
  TOP w0.152: R45.1 37.8,103.37 ML2.4 v2(38.26,103.37)
  IN1 w0.06: v1(134.41,105.43) 134.45,105.48 134.66,105.48 134.82,105.63 135.11,105.63 135.25,105.49 136.24,105.49 136.38,105.36 136.64,105.36 136.74,105.46 136.74,105.54 v5(136.68,105.6)
  GND1 w0.089: v5(136.68,105.6) 136.71,105.62 v4(136.71,105.98)
  IN2 w0.084: v4(39.09,103.66) 38.97,103.79 38.74,103.79 38.66,103.71 38.34,103.71 38.26,103.63 v2(38.26,103.37)
  IN3 w0.084: v4(39.09,103.66) 38.98,103.78 38.69,103.78 38.49,103.97 38.49,104.38 38.92,104.81 39.38,104.81 40.09,104.1 40.09,103.83 41.76,102.16 43.09,102.16 43.28,101.97 60.97,101.97 62.87,103.87 62.87,107.58 62.61,107.84 62.61,119.21 67.75,124.35 67.75,125.61 71.75,129.61 77.18,129.61 77.6,130.03 79.13,130.03 79.24,130.14 82.12,130.14 82.25,130.01 92.29,130.01 92.71,129.59 94.68,129.59 94.89,129.38 98.8,129.38 100.21,130.79 100.95,130.79 101.99,131.83 104.32,131.83 104.64,132.15 105.45,132.15 107,130.6 109.21,130.6 110.33,129.47 110.78,129.47 112.9,127.35 121.08,127.35 123.92,124.51 123.92,119.81 125.43,118.31 132.51,118.31 134.47,116.34 134.47,109.02 134.65,108.85 134.65,108.05 134.5,107.9 134.5,106.31 134.4,106.21 134.4,105.82 134.75,105.47 136.56,105.47 136.71,105.62 v4(136.71,105.98)
USB20_N5_R: length 7.5
  TOP w0.152: v2(30.8,102.21) JNGFF1.9 ; R45.2 36.72,103.37 ML2.3 v2(36.28,103.37)
  IN2 w0.084: v2(36.28,103.37) 36.28,103.55 36.19,103.64 36.03,103.64 34.48,102.09 31.86,102.09 31.52,101.75 31.13,101.75 30.89,101.98 30.89,102.11 v2(30.8,102.21)
USB20_N7: length 72.7
  TOP w0.152: R1012.1 181.18,99.68 ML9.1 180.48,99.68 180.24,99.92 180.1,99.92 179.77,100.26 179.77,100.83 180.22,101.29 v2(180.22,101.53)
  IN1 w0.06: v3(137.75,104.8) 137.7,104.8 137.44,104.54 136.33,104.54 135.8,105.08 134.9,105.08 134.62,104.79 v1(134.41,104.79)
  IN2 w0.06: 139.81,104.99 139.8,104.99 139.78,105.01 139.38,105.01 139.05,104.68 138.83,104.68 138.4,104.25 138.1,104.25 137.83,104.52 137.83,104.72 v3(137.75,104.8)
  IN2 w0.084: 139.81,104.99 140.11,104.99 140.68,104.41 140.68,103.69 142.17,102.21 144.52,102.21 145.78,100.95 147.3,100.95 147.77,100.48 150.69,100.48 150.95,100.22 150.95,100.04 152.2,98.79 156.62,98.79 157.66,99.83 163.46,99.83 164.11,100.48 166.47,100.48 167.79,101.8 167.95,101.8 168.04,101.72 168.04,100.59 168.22,100.41 168.52,100.41 168.7,100.59 168.7,101.72 168.78,101.8 169.16,101.8 169.62,102.26 170.39,102.26 170.48,102.17 170.48,101.66 170.39,101.58 169.65,101.58 169.48,101.4 169.48,101.1 169.65,100.92 170.39,100.92 170.48,100.83 170.48,100.62 170.66,100.44 170.96,100.44 171.14,100.62 171.14,102.17 171.22,102.26 171.39,102.26 171.47,102.17 171.47,100.62 171.65,100.44 171.95,100.44 172.13,100.62 172.13,102.17 172.22,102.26 173.1,102.26 173.71,102.87 173.9,102.87 173.98,102.78 173.98,101.43 174.16,101.25 174.46,101.25 174.64,101.43 174.64,102.78 174.73,102.87 174.9,102.87 174.98,102.78 174.98,101.43 175.16,101.25 175.46,101.25 175.64,101.43 175.64,102.78 175.72,102.87 176.06,102.87 176.99,101.94 180.32,101.94 180.44,101.82 180.44,101.67 180.3,101.53 v2(180.22,101.53)
USB20_N7_CONN: length 12.8
  TOP w0.152: R1012.2 182.26,99.68 ML9.2 182.91,99.68 183.06,99.84 183.17,99.84 R1016.2 183.74,99.63 183.74,99.68 183.89,99.83 184.78,99.83 v2(185.16,99.45) ; v2(186.33,97.32) 186.33,97.31 186.64,97.31 187.37,96.58 187.66,96.58 DI4.3 188.28,96.4 188.4,96.4 188.79,96.01 188.79,95.79 189.1,95.48 189.1,94.77 189.15,94.73 JLVDS1.8
  IN2 w0.084: v2(185.16,99.45) 185.16,99.64 185.06,99.74 184.91,99.74 184.8,99.64 184.8,98.5 186.09,97.21 186.23,97.21 v2(186.33,97.32)
USB20_N9: length 122.4
  TOP w0.152: R125.1 232.26,110.97 ML14.4 232.37,111.38 232.6,111.61 232.6,111.96 233.04,112.39 234.24,112.39 v2(234.26,112.42)
  IN2 w0.06: 139.81,105.71 139.74,105.71 139.72,105.68 139.45,105.68 139.35,105.59 139.22,105.59 138.86,105.22 138.22,105.22 138.03,105.41 136.35,105.41 136.3,105.46 135.29,105.46 135.14,105.32 134.42,105.32 134.22,105.11 v2(134.16,105.11)
  IN2 w0.084: 139.81,105.71 140.83,105.71 142.11,106.98 144.09,106.98 145.7,105.37 145.7,104.12 148.62,101.2 151.36,101.2 151.64,100.92 152.33,100.92 152.97,100.29 152.97,99.8 153.22,99.55 156.37,99.55 157.44,100.63 163.11,100.63 163.73,101.25 165,101.25 166.36,102.61 168.77,102.61 169.14,102.97 172.79,102.97 173.41,103.59 176.71,103.59 177.63,102.67 182.92,102.67 183.46,103.22 189.45,103.22 191.28,105.05 191.28,107.06 194.6,110.37 194.6,111.41 197.27,114.09 205.32,114.09 206.8,115.56 209.69,115.56 209.89,115.36 211.25,115.36 212.9,117.01 216.95,117.01 217.74,117.8 225.66,117.8 227.07,116.39 231.35,116.39 231.59,116.15 231.97,116.15 234.23,113.89 234.23,112.77 233.91,112.45 233.91,112.39 234,112.3 234.15,112.3 v2(234.26,112.42)
USB20_N9_R: length 8.3
  TOP w0.152: R125.2 232.37,109.65 ML14.3 232.37,109.09 232.6,108.86 232.6,108.48 233.07,108.01 235.11,108.01 236.69,109.6 236.69,110.98 236.77,111.06 JDEBUG1.4
USB20_P1: length 55.8
  TOP w0.152: R68.1 129.27,89.21 ML5.4 129.77,89.04 130.05,89.33 130.22,89.33 130.33,89.22 130.33,89.04 130.49,88.88 130.71,88.88 130.88,89.06 130.88,89.56 v2(129.76,90.69)
  IN1 w0.06: v1(134.65,105.76) 134.46,105.76 134.43,105.79 134.43,105.85 134.53,105.96 135.2,105.96 135.35,105.81 136.12,105.81 136.17,105.87 137.15,105.87 137.45,105.57 138.06,105.57 138.64,104.99 138.64,104.33 139.12,103.85 139.44,103.85 139.58,103.99 140.01,103.99 140.05,103.94 140.06,103.94
  IN1 w0.089: 140.06,103.94 140.23,103.94 140.57,104.28 140.57,105.9 141.83,107.16 142.36,107.16 142.44,107.23 144.14,107.23 144.34,107.03 144.49,107.03 146.22,105.31 146.22,103.43 147.24,102.41 147.36,102.28 147.85,102.28 148.58,101.54 148.58,101.01 150.05,99.55 150.05,99.23 v7(149.89,99.07)
  IN2 w0.084: v2(129.76,90.69) 129.88,90.69 130.09,90.9 130.09,91.05 129.94,91.2 129.94,92.18 129.61,92.51 v4(129.57,92.51)
  IN3 w0.084: v4(129.57,92.51) 129.61,92.51 129.94,92.85 129.94,92.93 130.18,93.16 130.46,93.16 130.65,93.36 130.65,93.84 130.98,94.16 133.61,94.16 133.88,93.9 136.34,93.9 136.77,94.33 138.82,94.33 139.09,94.61 139.82,94.61 140.55,95.34 142.1,95.34 142.2,95.45 143.37,95.45 143.88,95.95 144.36,95.95 144.73,96.32 144.73,96.82 145.33,97.43 147.11,97.43 147.72,98.04 148.38,98.04 148.87,98.53 149.94,98.53 150.03,98.63 150.03,98.93 v7(149.89,99.07)
USB20_P1_R: length 8.8
  TOP w0.152: JPOGO.69 121.3,86.68 121.32,86.7 121.32,87.01 121.99,87.68 124.72,87.68 124.97,87.93 D74.2 125.62,87.93 126,88.3 126.35,88.3 126.92,88.86 127.36,88.86 127.54,89.04 ML5.3 128.36,89.22 R68.2
USB20_P3: length 126
  TOP w0.152: R35.1 238.07,116.65 ML1.1 v2(237.65,116.65)
  IN1 w0.06: v3(139.36,104.63) 139.36,104.72 139.41,104.77 139.54,104.77 139.59,104.82 139.59,105.09 138.77,105.91 138.77,106.15 138.69,106.23 138.26,106.23 138.26,106.23 135.49,106.23 135.36,106.36 134.72,106.36 134.69,106.4 v1(134.65,106.4)
  IN2 w0.06: v3(139.36,104.63) 139.49,104.5 139.49,104.34 139.65,104.18 139.87,104.18 139.88,104.17 139.9,104.17 139.93,104.14 139.93,104.14
  IN2 w0.084: v2(237.65,116.65) 237.78,116.65 237.84,116.71 237.84,116.91 237.76,117 237.38,117 237.1,116.71 237.1,115.87 236.19,114.95 236.19,112.91 234.69,111.42 233.87,111.42 233.09,112.2 233.09,113.42 230.84,115.67 226.76,115.67 225.37,117.07 218.07,117.07 217.27,116.27 213.17,116.27 210.78,113.88 209.8,113.88 209.52,114.16 207.04,114.16 206.24,113.36 202.99,113.36 202.34,112.71 197.31,112.71 195.56,110.96 195.56,109.96 192.52,106.93 192.52,105.1 189.84,102.41 185.14,102.41 184.61,101.89 181.9,101.89 180.92,100.91 176.5,100.91 176.1,100.51 173.17,100.51 172.55,99.88 170.41,99.88 170.19,100.1 169.42,100.1 168.54,99.22 164.63,99.22 164.37,98.96 163.13,98.96 162.82,99.27 157.92,99.27 156.85,98.2 151.87,98.2 150.56,99.52 147.77,99.52 147.5,99.78 145.95,99.78 144.11,101.62 141.97,101.62 140.13,103.46 140.13,103.99 139.99,104.14 139.93,104.14
USB20_P3_R: length 12.6
  TOP w0.152: R35.2 239.15,116.65 ML1.2 v2(239.71,116.65)
  IN2 w0.084: v2(239.71,116.65) 239.71,116.88 239.82,116.99 240.06,116.99 241.58,115.47 242.33,115.47 245.91,111.89 245.91,109.23 246.07,109.07 246.2,109.07 v2(246.39,108.87)
USB20_P5: length 149.6
  TOP w0.152: v2(38.26,104.22) ML2.1 37.8,104.22 R44.1
  IN1 w0.06: v5(137.04,105.6) 136.99,105.6 136.86,105.47 136.86,105.41 136.69,105.24 136.33,105.24 136.19,105.37 135.2,105.37 135.06,105.51 134.98,105.51 v1(134.9,105.43)
  GND1 w0.089: v5(137.04,105.6) 137.08,105.6 137.22,105.74 v4(137.22,105.98)
  IN2 w0.084: v4(39.09,104.17) 39.09,104.15 38.89,103.95 38.67,103.95 38.59,103.87 38.27,103.87 38.17,103.97 38.17,104.13 v2(38.26,104.22)
  IN3 w0.084: v4(39.09,104.17) 39.09,104.15 38.88,103.94 38.75,103.94 38.65,104.04 38.65,104.31 38.99,104.65 39.31,104.65 39.92,104.03 39.92,103.76 41.69,102 43.02,102 43.22,101.81 61.04,101.81 63.03,103.8 63.03,107.64 62.77,107.91 62.77,119.15 67.91,124.29 67.91,125.54 71.82,129.45 77.25,129.45 77.67,129.87 79.19,129.87 79.31,129.98 82.05,129.98 82.19,129.84 92.23,129.84 92.64,129.42 94.61,129.42 94.82,129.22 98.87,129.22 100.28,130.63 101.02,130.63 102.06,131.67 104.39,131.67 104.71,131.99 105.38,131.99 106.93,130.43 109.14,130.43 110.26,129.31 110.71,129.31 112.83,127.19 121.01,127.19 123.76,124.44 123.76,119.74 125.36,118.14 132.44,118.14 134.31,116.27 134.31,109.4 134.33,109.38 134.33,108.97 134.51,108.79 134.51,108.11 134.36,107.96 134.36,106.37 134.25,106.27 134.25,105.76 134.69,105.33 136.62,105.33 136.85,105.56 136.85,105.69 137.14,105.98 v4(137.22,105.98)
USB20_P5_R: length 7.5
  TOP w0.152: v2(36.28,104.22) ML2.2 36.72,104.22 R44.2 ; v2(31.3,102.21) JNGFF1.7
  IN2 w0.084: v2(36.28,104.22) 36.28,103.9 36.18,103.8 35.96,103.8 34.42,102.26 31.79,102.26 31.45,101.91 31.19,101.91 31.06,102.05 31.06,102.12 31.14,102.21 v2(31.3,102.21)
USB20_P7: length 72.6
  TOP w0.152: R1013.1 181.18,100.53 ML9.4 180.59,100.53 180.32,100.26 180.24,100.26 180.11,100.4 180.11,100.69 180.6,101.19 180.6,101.46 180.67,101.53 v2(180.68,101.53)
  IN1 w0.06: v3(138.13,104.79) 138.2,104.79 138.26,104.73 138.26,104.59 138.2,104.53 138,104.53 137.95,104.58 137.65,104.58 137.49,104.42 136.28,104.42 135.75,104.96 134.97,104.96 134.9,104.89 v1(134.9,104.79)
  IN2 w0.06: v3(138.13,104.79) 138.04,104.79 137.95,104.7 137.95,104.57 138.15,104.37 138.35,104.37 138.78,104.8 139,104.8 139.33,105.13 139.78,105.13 139.8,105.15 139.81,105.15
  IN2 w0.084: v2(180.68,101.53) 180.6,101.61 180.6,101.89 180.39,102.1 177.06,102.1 176.13,103.03 175.66,103.03 175.48,102.85 175.48,101.5 175.39,101.42 175.23,101.42 175.14,101.5 175.14,102.85 174.96,103.03 174.66,103.03 174.48,102.85 174.48,101.5 174.4,101.42 174.23,101.42 174.15,101.5 174.15,102.85 173.97,103.03 173.64,103.03 173.03,102.42 172.15,102.42 171.97,102.24 171.97,100.69 171.89,100.6 171.72,100.6 171.64,100.69 171.64,102.24 171.46,102.42 171.15,102.42 170.98,102.24 170.98,100.69 170.89,100.6 170.72,100.6 170.64,100.69 170.64,100.9 170.46,101.08 169.72,101.08 169.64,101.16 169.64,101.33 169.72,101.42 170.46,101.42 170.64,101.6 170.64,102.24 170.46,102.42 169.55,102.42 169.09,101.96 168.71,101.96 168.53,101.78 168.53,100.66 168.45,100.58 168.28,100.58 168.2,100.66 168.2,101.78 168.02,101.96 167.72,101.96 166.4,100.64 164.04,100.64 163.39,99.99 157.6,99.99 156.56,98.95 152.27,98.95 151.11,100.11 151.11,100.29 150.76,100.64 147.84,100.64 147.37,101.11 145.84,101.11 144.58,102.37 142.24,102.37 140.85,103.76 140.85,104.48 140.17,105.15 139.81,105.15
USB20_P7_CONN: length 12.8
  TOP w0.152: R1013.2 182.26,100.53 ML9.3 183.52,100.53 R1015.2 183.58,100.39 183.89,100.09 184.78,100.09 v2(185.16,100.47) ; v2(186.33,96.96) 186.34,96.97 186.5,96.97 187.23,96.24 187.44,96.24 DI4.2 188.14,96.06 188.26,96.06 188.45,95.87 188.45,95.65 188.76,95.34 188.76,94.85 188.65,94.73 JLVDS1.9
  IN2 w0.084: v2(185.16,100.47) 185.16,100.22 184.64,99.7 184.64,98.43 186.02,97.05 186.24,97.05 v2(186.33,96.96)
USB20_P9: length 121.3
  TOP w0.152: v2(234.26,112.03) 234.24,112.06 233.18,112.06 232.94,111.82 232.94,111.6 233.17,111.37 ML14.1 233.28,110.97 R124.1
  IN2 w0.06: 139.81,105.54 139.74,105.54 139.72,105.56 139.5,105.56 139.4,105.47 139.27,105.47 138.91,105.1 138.17,105.1 137.98,105.29 136.3,105.29 136.25,105.34 135.34,105.34 135.11,105.11 v2(134.65,105.11)
  IN2 w0.084: v2(234.26,112.03) 234.16,112.14 233.94,112.14 233.75,112.32 233.75,112.52 234.07,112.83 234.07,113.82 231.91,115.98 231.53,115.98 231.28,116.23 227,116.23 225.59,117.64 217.8,117.64 217.02,116.85 212.96,116.85 211.31,115.2 209.82,115.2 209.62,115.4 206.87,115.4 205.39,113.93 197.34,113.93 194.76,111.35 194.76,110.31 191.45,106.99 191.45,104.98 189.52,103.06 183.53,103.06 182.98,102.51 177.56,102.51 176.65,103.43 173.48,103.43 172.86,102.81 169.2,102.81 168.84,102.45 166.43,102.45 165.07,101.09 163.8,101.09 163.18,100.47 157.51,100.47 156.43,99.39 153.15,99.39 152.8,99.74 152.8,100.22 152.26,100.76 151.58,100.76 151.3,101.04 148.55,101.04 145.54,104.06 145.54,105.3 144.02,106.82 142.17,106.82 140.9,105.54 139.81,105.54
USB20_P9_R: length 7.1
  TOP w0.152: R124.2 233.17,109.65 ML14.2 233.17,109.12 232.94,108.89 232.94,108.62 233.21,108.35 234.97,108.35 236.35,109.74 236.35,111.01 236.27,111.09 JDEBUG1.3
USB_ID: length 8.7
  TOP w0.119: RC91.1 139.9,102.08 139.9,103.48 v1(139.76,103.61)
  IN1 w0.06: v1(139.76,103.61) 139.68,103.54 138.7,103.54 138,104.24 137.12,104.24 137.06,104.3 135.43,104.3 135.14,104.59 134.32,104.59 134.12,104.79 v1(133.91,104.79)
USB_OC2#: length 6.6
  TOP w0.06: 135.48,96.8 135.48,96.94 v1(135.2,97.22)
  TOP w0.119: 135.48,96.8 135.74,96.54 135.74,96.05 136.15,95.64 137.03,95.64 137.64,95.02 137.64,94.75 RH123.1
  IN1 w0.06: v1(135.2,97.22) 135.2,97.38 134.55,98.03 134.47,98.03 134.3,98.2 134.07,98.2 133.91,98.36 133.91,98.55 133.7,98.76 v1(133.7,98.86)
USB_OC3#: length 6
  TOP w0.06: UC1.B8 133.8,97.9 133.8,97.35 134.45,96.71 134.96,96.71 135.11,96.55
  TOP w0.119: 135.11,96.55 135.26,96.4 135.26,95.89 135.74,95.42 136.94,95.42 137.17,95.19 137.17,94.78 137.02,94.62 RH124.1
USBC1_USB2_D_N_R: length 7.2
  TOP w0.112: v1(14.2,31.19) 14.2,31.19 ML6.2 14.39,31.58 R93.2
  IN1 w0.066: v1(14.2,31.19) 14.11,31.19 14.04,31.12 14.04,30.85 13.8,30.6 13.2,30.6 12.58,31.22 11.11,31.22 11.01,31.13 9.63,31.13 8.91,30.41 8.71,30.41 8.66,30.36 v1(8.66,30.26)
USBC1_USB2_D_P_R: length 6.9
  TOP w0.112: R94.2 13.51,31.58 ML6.3 13.7,31.19 v1(13.7,31.19)
  IN1 w0.066: v1(8.66,30.76) 8.66,30.66 8.73,30.59 8.83,30.59 9.56,31.31 10.94,31.31 11.03,31.41 12.65,31.41 13.28,30.78 13.72,30.78 13.86,30.92 13.86,31.12 13.8,31.19 v1(13.7,31.19)
USBC2_USB2_D_N_R: length 6
  TOP w0.112: R95.2 14.13,16.39 ML7.2 13.12,16.55 v1(12.96,16.39)
  IN1 w0.066: v1(8.66,16.26) 8.82,16.41 11.82,16.41 12.1,16.69 12.66,16.69 v1(12.96,16.39)
USBC2_USB2_D_P_R: length 6
  TOP w0.112: R121.2 14.13,17.2 ML7.3 13.6,17.05 13.37,16.81 13.1,16.81 v1(12.96,16.95)
  IN1 w0.066: v1(8.66,16.76) 8.82,16.6 11.74,16.6 12.02,16.87 12.88,16.87 v1(12.96,16.95)
VBOS: length 121
  TOP w0.254: v10(76.56,124.16) 76.38,124.34 76.38,125.66 74.67,127.37 74.67,127.7 ; v10(81.63,128.62) 82.15,128.1 82.15,127.4 83.81,125.74 86.98,125.74 87.08,125.84 91.21,125.84 91.59,125.45 91.59,123.6 92.53,122.66 95.67,122.66 96.15,122.19 96.15,112.86 95.71,112.42 95.71,98.36 95.15,97.8 93.33,97.8 92.73,97.2 PC204.1 93.2,96.04 PU202.1 93.2,94.62 92.74,94.16 PR253.2 ; 74.67,127.7 75.23,127.7 v10(75.58,127.35) ; 74.67,127.7 74.17,127.7 73.62,128.26 v2(73.62,128.38)
  TOP w0.508: v1(59.16,140.85) 59.16,139.8 v1(59.06,139.7) ; v1(60.68,136.19) 60.77,136.1 PC225.1 ; PC226.1 66.49,134.48 67.11,135.1 PC232.1 PC224.1 ; PR205.1 v7(63.79,141.85)
  IN1 w0.508: 59.8,138.65 59.8,138.15 60.68,137.26 v1(60.68,136.19) ; 59.8,138.65 60.8,138.65 v1(61.58,137.88) 61.82,137.64 63.76,137.64 65.35,136.05 66.95,136.05 v1(67.14,136.24) 68.57,137.68 v7(69.83,137.68) ; 59.8,138.65 59.8,138.96 v1(59.06,139.7) ; v1(59.16,140.85) 58.8,140.85 58.73,140.91 58.73,140.91 58.39,141.26 58.39,141.26 58.14,141.51 56.79,141.51 56.47,141.2 56.46,141.2 56.46,141.19 55.65,141.19 55.11,140.66 52.74,140.66 52.23,140.15 51.87,140.15 50.2,138.48
  GND1 w0.254: v4(81.64,129.02) 81.64,128.63 v10(81.63,128.62) ; v4(76.08,127.59) 75.82,127.59 v10(75.58,127.35) ; v4(76.21,123.71) 76.56,124.06 v10(76.56,124.16) ; v10(76.38,119.79) 76.38,120.15 v4(76.51,120.28)
  IN2 w0.254: v2(73.45,137.66) 74.82,136.29 74.82,132.02 73.39,130.59 73.39,128.61 v2(73.62,128.38)
  IN3 w0.254: v4(76.08,127.59) 76.75,127.59 78.18,129.02 v4(81.64,129.02)
  GND4 w0.254: v9(76.56,123.43) 76.28,123.71 v4(76.21,123.71) ; v4(76.51,120.28) v9(76.51,120.86)
  BOTTOM w0.254: v9(76.56,123.43) 76.56,121.19 76.51,121.14 v9(76.51,120.86)
  BOTTOM w0.508: v7(69.83,137.68) 69.5,138.01 69.5,138.72 v14(69.09,139.12) 68.74,139.48 68.59,139.48 66.21,141.85 v7(63.79,141.85)
  vias: v1(49.73,138.34) v1(49.73,138.03)
VCM_OUT_2.8V: length 67.9
  TOP w0.203: JP1.1 142.71,136.98 142.46,137.23 v7(142.4,137.23)
  BOTTOM w0.508: v7(197.52,147.12) 191.34,147.12 190.23,146.01 190.23,136.95 188.19,134.91 184.75,134.91 183.28,133.44 179.24,133.44 178.64,134.04 v14(176.35,134.04) 172.25,134.04 170.8,132.6 168.25,132.6 167.66,133.18 165.93,133.18 164.39,134.72 147.84,134.72 146.21,136.36 144.33,136.36 143.87,136.81
VGATE: length 5.4
  TOP w0.089: PR801.2 v1(75.67,105.44)
  IN1 w0.06: v1(73.22,109.15) 73.42,108.95 74.2,108.95 74.34,108.81
  IN1 w0.254: 74.34,108.81 74.43,108.72 74.43,107.02 74.58,106.87 75.01,106.87 75.67,106.21 v1(75.67,105.44)
VIBRATOR_EN#: length 29.2
  TOP w0.119: R1082.1 C1164.1 221.61,122.96 221.49,122.84 Q330.2 223.78,121.9 v7(224.96,120.72)
  IN1 w0.089: v3(227.66,131.94) 227.58,131.85 227.58,130.95 228.24,130.29 228.24,128.61 228.99,127.86 231.01,127.86 231.6,127.26 231.6,127.01 231.81,126.8 v1(231.81,126.25)
  IN2 w0.084: v4(226.93,132.37) 227.36,131.94 v3(227.66,131.94)
  IN3 w0.084: v4(226.93,132.37) 226.24,132.37 226.01,132.14 226.01,127.02 225.16,126.17 225.16,125.59 224.42,124.85 224.42,121.26 v7(224.96,120.72)
VOUT4: length 8
  TOP w0.254: PR505.2 160.25,121.98 v2(160.03,122.21)
  IN1 w0.06: v3(164.4,121.39) 164.57,121.57 164.85,121.57 165.48,122.2 166.11,122.2 166.31,122.4 v1(166.39,122.4)
  IN2 w0.254: v3(164.4,121.39) 163.78,121.39 162.94,122.24 160.06,122.24 v2(160.03,122.21)
VPRO: length 29.9
  TOP w0.119: v10(149.64,99.5) 149.71,99.58 150.65,99.58 151.13,99.1 153.68,99.1 154.18,99.6 RH178.1 155.07,98.99 155.91,98.99 156.29,99.37 RH177.1
  GND1 w0.119: v10(149.64,99.5) 149.66,99.53 149.66,100.08 v4(149.69,100.11)
  IN2 w0.06: 138.93,98.28 138.54,98.67 138.54,99.37 137.9,100.01 137.9,100.12 137.58,100.44 136.89,100.44 136.33,101 136.22,101 135.92,101.3 135.28,101.3 134.92,101.66 134.68,101.66 134.65,101.7 134.45,101.89 v2(133.17,101.89)
  IN2 w0.084: v4(144.28,97.01) 144.11,97.18 142.14,97.18 141.87,97.44 141.18,97.44 140.84,97.1 140.84,96.92 140.7,96.78 140.17,96.78 139.45,97.5 139.45,97.76 138.93,98.28
  IN3 w0.084: v4(149.69,100.11) 149.46,99.88 147.08,99.88 144.28,97.08 v4(144.28,97.01)
VSET_1641: length 5.1
  TOP w0.119: v1(235.06,118.07) 235.11,118.07 235.44,117.74 R193.1 235.35,117.58 C199.1
  IN1 w0.089: v1(235.06,118.07) 235.06,119.21 234.5,119.77 234.5,120.33 234.05,120.77 234.05,120.99 v1(234.31,121.25)
WAKE#: length 6.2
  TOP w0.076: UC1.BP9 133.51,112.89 134.1,113.48 136.92,113.48 137.39,113.95 137.82,113.95 138.59,113.18 RH63.2
WC_ACOK: length 22.4
  GND1 w0.119: v12(233.1,117.71) 233.1,117.53 233.52,117.11 233.52,116.75 233.46,116.68 v4(233.46,116.43)
  IN2 w0.084: v12(233.1,117.71) 233.13,117.74 233.4,117.74 235.71,120.05 236.28,120.05 236.4,120.17 236.4,121.89 236.77,122.25 236.77,123.57 238.83,125.64 240.39,125.64 240.71,125.96 240.71,129.85 239.17,131.39 237.88,131.39 v2(237.79,131.48)
  GND4 w0.119: v9(233.53,117.04) 233.45,116.95 233.45,116.44 v4(233.46,116.43)
WF_AVDD_2.8V: length 52.4
  TOP w0.127: v1(150.97,136.39) v14(152.69,136.39)
  TOP w0.254: JP1.23 147.11,137.13 v7(146.92,137.32)
  TOP w0.508: v1(150.97,136.39) 150.97,136.96 149.92,138.02 147.99,138.02 147.85,138.16 147.2,138.16 146.96,137.92
  IN1 w0.508: v7(178.96,137.49) 179.17,137.28 179.17,136.03 178.7,135.56 174.6,135.56 173.75,136.41 173.24,136.41 171.96,137.68 162.25,137.68 162.15,137.58 159.27,137.58 159.16,137.69 154.8,137.69 153.22,136.1 151.26,136.1 v1(150.97,136.39)
  BOTTOM w0.305: v7(146.92,137.32) 146.28,137.32 C120.1
  BOTTOM w0.508: v7(188.3,141.02) 188.3,138.69 186.84,137.23 179.22,137.23 v7(178.96,137.49)
WF_DOVDD_1.8V: length 54.3
  TOP w0.203: JP1.25 v10(147.51,137.65)
  GND1 w0.254: v10(147.51,137.65) 147.51,137.29 v4(147.54,137.26)
  GND4 w0.254: v9(148.01,137.26) v4(147.54,137.26)
  BOTTOM w0.508: v7(189.56,143.96) 189.62,143.9 189.62,137.2 187.94,135.52 184.38,135.52 182.92,134.05 v14(180.26,134.05) 179.57,134.05 178.97,134.65 172,134.65 171.85,134.5 171.85,134.5 170.55,133.21 168.5,133.21 167.92,133.79 166.19,133.79 164.64,135.33 152.03,135.33 151.21,136.15 150.18,136.15 149.71,136.62 148.76,136.62 148.57,136.81 C122.1 148.51,137.26 v9(148.01,137.26)
WF_DVDD_1.2V: length 59.9
  TOP w0.203: JP1.27 147.91,137.14 v1(148.23,137.46)
  TOP w0.381: v7(190.27,147.56) 190.21,147.61 C1416.2
  TOP w0.508: v7(190.27,147.56) 190.27,147.84 C110.1 R81.2
  IN1 w0.254: v5(152.32,137.3) 152.2,137.18 148.51,137.18 v1(148.23,137.46)
  GND1 w0.254: v2(160.09,136.46) v4(160.09,136.08)
  GND1 w0.508: v4(152.61,136.91) 152.32,137.21 v5(152.32,137.3)
  GND4 w0.254: v9(160.05,137.4) 160.06,137.4 160.09,137.37 v4(160.09,136.08)
  GND4 w0.508: v9(152.44,137.45) 152.44,137.08 v4(152.61,136.91)
  BOTTOM w0.381: v9(152.44,137.45) 152.32,137.32 C123.1
  BOTTOM w0.508: v9(152.44,137.45) 153.92,137.45 154,137.37 160.08,137.37 v9(160.05,137.4) 160.06,137.4 160.09,137.37 174.5,137.37 174.93,136.94 177.74,136.94 178.25,136.43 187.22,136.43 188.96,138.17 188.96,142.63 188.44,143.15 188.44,145.72 v7(190.27,147.56)
WF_HCLK: length 52
  TOP w0.089: C169.1 189.66,136.6 189.05,137.2 189.05,138.08 v2(188.08,139.04)
  TOP w0.119: R70.1 189.97,137.16 C169.1 ; JP1.11 144.71,137.26 v2(144.66,137.31)
  IN2 w0.084: v2(144.66,137.31) 144.66,137.26 145.17,136.75 147.75,136.75 148.06,137.07 150.78,137.07 151.67,136.18 154.42,136.18 154.92,136.68 154.92,137.41 155.04,137.52 157.45,137.52 157.87,137.1 159.28,137.1 159.36,137.18 173.48,137.18 173.69,136.96 177.83,136.96 177.9,136.9 179.51,136.9 179.77,137.17 182.77,137.17 183.14,137.54 187.45,137.54 187.84,137.93 187.84,138.8 v2(188.08,139.04)
WF_HCLK_R: length 8
  TOP w0.119: R70.2 189.58,138.79 C207.1 190.04,139.06 190.33,139.35 v2(190.33,139.73)
  IN2 w0.06: v2(194.17,142.5) 193.86,142.81 193.27,142.81
  IN2 w0.084: v2(190.33,139.73) 190.33,141.28 190.89,141.84 191.71,141.84 192.68,142.81 193.27,142.81
WF_SENSOR_RST#: length 4.2
  GND1 w0.119: v10(194.57,142.9) 194.94,142.9 v4(195.2,143.16)
  GND4 w0.119: v4(195.2,143.16) 195.1,143.26 v9(194.8,143.26)
  BOTTOM w0.119: v9(194.8,143.26) 194.47,143.26 194.23,143.02 R73.2 193.01,142.83 R111.2 192.93,143.42 R72.2
WF_SENSOR_RST#_L: length 58.2
  TOP w0.119: JP1.17 v2(145.91,137.27)
  IN2 w0.084: v2(145.91,137.27) 146.34,137.27 v4(146.35,137.26)
  IN3 w0.084: v6(192.21,145.37) 191.35,144.52 191.35,143.3 189.69,141.64 189.69,138.76 188.08,137.16 180.17,137.16 177.88,134.88 176.44,134.88 176.21,134.65 173.91,134.65 172.22,136.34 164.08,136.34 163.76,136.02 161.3,136.02 160.76,135.48 159.63,135.48 159.13,135.98 159.08,135.98 158.31,136.75 155.5,136.75 154.42,135.67 v6(151.01,135.67)
  GND4 w0.119: v9(146.67,136.94) v4(146.35,137.26)
  BOTTOM w0.119: R72.1 192.25,144.51 C111.1 192.31,145.27 v6(192.21,145.37) ; v9(146.67,136.94) 146.76,136.85 147.95,136.85 148.68,136.11 149.63,136.11 150.08,135.67 v6(151.01,135.67)
WIFI_RF_KILL: length 9
  IN1 w0.06: v1(133.91,101.57) 133.95,101.53 134.16,101.53 134.4,101.29 134.55,101.29 134.59,101.25 135.24,101.25 135.81,100.68 136.23,100.68 137.32,99.59 137.49,99.59 137.67,99.41 139.68,99.41 v5(139.69,99.4)
  GND1 w0.119: v4(140.05,99.23) 139.88,99.4 v5(139.69,99.4)
  GND4 w0.119: v9(140.42,99.63) 140.42,99.6 v4(140.05,99.23)
  BOTTOM w0.119: v9(140.42,99.63) 140.42,100.01 TC69.1 140.19,100.24 RH119.1
WL_OFF#_R: length 62
  TOP w0.119: R43.1 222.64,123.64 D5.1 v10(223.65,124.39)
  GND1 w0.119: v10(223.65,124.39) 223.65,124.67 v4(223.86,124.87)
  IN2 w0.084: v7(249.78,138.03) 249.78,137.71 246.95,134.88 246.95,130.13 245.84,129.02 245.84,124.28 247.99,122.12 JNGFF3.48
  IN3 w0.084: v4(223.86,124.87) 224.75,125.76 224.75,126.35 225.27,126.87 v6(225.27,127.45)
  BOTTOM w0.119: v7(249.78,138.03) 245.35,138.03 244.25,136.93 244.25,135.42 242.73,133.9 239.92,133.9 239.06,133.04 239.06,129.9 238.47,129.31 236.71,129.31 234.34,131.69 234.34,131.78 232.21,133.9 228.46,133.9 226.96,132.4 226.96,130.73 225.61,129.38 225.61,127.8 v6(225.27,127.45)
WLAN_EN: length 2.9
  TOP w0.119: U30.3 234.23,135.76 233.7,136.29 R209.2 232.39,136.29 D10.1
WLAN_ON: length 110.1
  TOP w0.089: UC1.BB2 136.6,109.62 v1(136.89,109.33)
  TOP w0.119: v1(220.24,124.2) 220.43,124.39 220.43,125.78 220.9,126.24 D5.3
  IN1 w0.06: 141.68,109.92 141.54,109.78 140.49,109.78 140.42,109.71 139.68,109.71 139.13,109.16 137.06,109.16 v1(136.89,109.33)
  IN1 w0.089: v1(220.24,124.2) 219.93,123.9 218.93,123.9 217.09,122.06 216.07,122.06 214.74,120.72 213.75,120.72 213.21,120.18 212.31,120.18 211.36,119.23 209.86,119.23 208.78,118.14 208.32,118.14 206.11,115.92 206.11,115.17 205.19,114.26 203.48,114.26 200.85,111.63 199.7,111.63 196.63,108.56 196.63,107.63 194.64,105.64 194.47,105.64 194.05,105.22 194.05,104.35 193.53,103.83 193.53,102.76 192.45,101.68 192.45,100.92 191.9,100.38 191.11,100.38 190.83,100.09 190.35,100.09 190.08,99.82 189.01,99.82 188.58,99.39 187.01,99.39 186.73,99.11 186.14,99.11 185.54,98.52 183.71,98.52 183.51,98.72 180.94,98.72 180.63,99.03 179.34,99.03 179.14,99.23 176.53,99.23 176.31,99.45 173.5,99.45 172.86,98.81 164.16,98.81 163.6,98.24 156.81,98.24 156.2,98.85 153.04,98.85 152.36,99.54 151.71,99.54 151.27,99.98 151.27,100.58 149.56,102.29 149.56,102.81 147.86,104.51 147.86,106.65 145.38,109.14 145.08,109.14 144.16,110.06 143.37,110.06 143.25,110.19 142.43,110.19 142.3,110.06 141.82,110.06 141.68,109.92
WLAN_PWR_EN: length 157.4
  TOP w0.119: v1(234.17,138.98) 233.55,138.98 233.03,138.47 232.44,138.47 231.1,137.13 D10.2
  IN1 w0.06: v3(138.69,111.46) 138.69,111.53 138.95,111.78 139.5,111.78 139.66,111.94 139.81,111.94
  IN1 w0.089: 139.81,111.94 141.3,111.94 141.67,112.32 143.12,112.32 143.72,111.71 143.75,111.71 144.26,111.2 144.7,111.2 145.11,110.79 145.3,110.79 145.62,110.46 145.62,110.43 146.23,109.82 146.23,109.36 147.1,108.49 v3(147.83,108.49) ; v1(234.17,138.98) 234.58,138.98 234.85,138.7 235.96,138.7 238.4,136.26 238.4,135.32 241.01,132.71 241.01,132.48 241.98,131.52 v3(241.98,131.06)
  IN2 w0.06: v3(138.69,111.46) 138.41,111.18 138.41,110.8 137.82,110.22 136.27,110.22 135.9,109.85 135.19,109.85 134.69,109.36 133.8,109.36 133.62,109.18 133.58,109.18 133.38,108.98 133.29,108.98 v2(133.17,108.98)
  IN2 w0.084: v3(147.83,108.49) 148.52,107.81 149.19,107.81 150.95,106.05 151.16,106.05 151.48,105.74 151.48,105.22 152.03,104.66 152.9,104.66 153.16,104.4 159.09,104.4 159.73,103.76 162.15,103.76 162.77,104.39 163.42,104.39 163.54,104.26 164.78,104.26 166.29,105.78 171.05,105.78 171.11,105.84 172.35,105.84 172.5,105.99 173.49,105.99 174.15,106.65 175.34,106.65 176,105.99 177.61,105.99 178.17,105.43 185.9,105.43 186.74,106.27 188.37,106.27 189.08,106.97 189.08,108.22 195.99,115.13 195.99,115.49 198.54,118.04 199.61,118.04 200.12,118.55 208.76,118.55 209.88,117.43 210.94,117.43 212.53,119.03 212.53,121.41 214.17,123.05 218.12,123.05 220.13,121.03 223.09,121.03 225.32,118.8 226.14,118.8 227.55,117.39 231.72,117.39 231.95,117.16 232.45,117.16 232.74,116.86 234.73,116.86 235.12,117.25 235.12,118.31 237.89,121.08 237.89,121.41 237.71,121.59 237.71,123.22 239.12,124.63 240.68,124.63 241.62,125.58 241.62,128.31 242.21,128.9 242.21,130.83 v3(241.98,131.06)
WLAN_RST#: length 144.5
  TOP w0.119: U13.2 v2(242.09,125.05)
  IN1 w0.06: v1(134.13,98.86) 134.17,98.86 134.37,98.65 134.74,98.65 135.74,97.66 136.75,97.66 v5(136.93,97.48)
  IN1 w0.089: v5(220.26,116.21) 220.12,116.07 218.18,116.07 217.02,114.92 217.02,112.71 215.77,111.45 215.58,111.45 214.6,110.47 v3(214.2,110.47)
  GND1 w0.119: v4(137.15,96.99) 137.15,97.26 v5(136.93,97.48) ; v5(220.26,116.21) 220.28,116.2 220.52,116.2 v4(220.67,116.35)
  IN2 w0.06: 137.85,96.68 137.55,96.99 v4(137.15,96.99)
  IN2 w0.084: 137.85,96.68 138.31,96.22 138.31,96.09 140.1,94.3 141.49,94.3 142.16,93.63 143.53,93.63 144.29,92.87 145.95,92.87 146.21,92.62 146.3,92.62 146.51,92.41 149.49,92.41 149.69,92.62 151,92.62 151.42,93.04 154.58,93.04 154.92,92.69 156.88,92.69 157.66,91.91 166.82,91.91 167.21,92.3 174.59,92.3 176.4,90.49 182.41,90.49 188.19,96.28 188.19,98.05 189.93,99.78 191.12,99.78 192.08,100.74 192.08,101.31 194.45,103.68 194.45,105.07 200.31,110.92 205.23,110.92 205.94,111.63 209.16,111.63 209.43,111.91 212.77,111.91 v3(214.2,110.47) ; v2(242.09,125.05) 241.9,124.86 v4(241.71,124.86)
  IN3 w0.084: v6(242.09,125.1) 241.85,124.86 v4(241.71,124.86) ; v6(221.75,117.39) 221.74,117.38 221.7,117.38 v4(220.67,116.35)
  GND4 w0.119: v9(136.85,97.23) 136.92,97.23 137.15,97.01 v4(137.15,96.99)
  BOTTOM w0.119: 137.19,97.21 137.29,97.11 v13(138.33,97.11) ; v6(221.75,117.39) 222.78,117.39 223.63,118.25 226.24,118.25 227.15,117.33 231.18,117.33 233.99,114.52 241.26,114.52 242.25,115.51 242.25,118.17 241.92,118.5 241.92,124.93 v6(242.09,125.1)
  BOTTOM w0.127: 137.19,97.21 137.18,97.23 RH127.1
