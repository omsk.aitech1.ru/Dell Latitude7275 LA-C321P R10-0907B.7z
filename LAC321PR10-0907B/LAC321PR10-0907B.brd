# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SKYCAM_USER_CSI0_D: length 71.5
  TOP w0.152: R1116.1 103.57,127.89 v10(103.57,127.58)
  IN1 w0.06: 122.29,93.51 122.29,93.52 122.25,93.57 122.25,93.98 122.56,94.29 122.56,94.52 122.82,94.78 122.82,95.19 124.66,97.03 125.08,97.03 125.46,97.41 v1(125.46,97.84)
  IN1 w0.089: 122.29,93.51 122.29,93.01 121.72,92.44 121.72,92.16 120.38,90.81 119.18,90.81 118.08,89.71 116.36,89.71 116.16,89.91 112.06,89.91 111.7,90.27 105.83,90.27 105.14,90.97 104.6,90.97 103.76,91.8 103.36,91.8 101.05,94.11 101.05,96.71 101.61,97.26 101.61,97.89 103.28,99.56 103.28,99.71 v5(103.23,99.75)
  GND1 w0.089: v4(103.78,127.2) 103.78,127.37 v10(103.57,127.58) ; v4(103.08,100.13) 103.23,99.98 v5(103.23,99.75)
  IN3 w0.084: v4(103.78,127.2) 103.95,127.02 103.95,126.51 103.32,125.88 102.28,125.88 99.75,123.35 99.75,119.11 99.44,118.8 99.44,108.55 99.85,108.14 100.16,108.14 100.53,108.51 100.65,108.51 100.95,108.21 100.95,108.09 100.55,107.69 100.55,107.44 101.06,106.93 101.06,103.07 103.24,100.89 103.24,100.29 v4(103.08,100.13)
SKYCAM_USER_CSI0_D#: length 71.5
  TOP w0.152: R1115.1 104.42,127.89 v10(104.42,127.58)
  IN1 w0.06: 122.08,93.51 122.08,93.52 122.13,93.57 122.13,94.03 122.44,94.34 122.44,94.57 122.7,94.83 122.7,95.24 124.61,97.15 125.03,97.15 125.34,97.46 125.34,97.68 125.25,97.77 125.25,97.92 125.46,98.13 v1(125.46,98.34)
  IN1 w0.089: 122.08,93.51 122.08,93.1 121.51,92.53 121.51,92.25 120.29,91.03 119.09,91.03 117.99,89.92 116.45,89.92 116.25,90.13 112.15,90.13 111.79,90.49 105.92,90.49 105.23,91.18 104.69,91.18 103.85,92.02 103.45,92.02 101.26,94.2 101.26,96.62 101.82,97.18 101.82,97.8 103.5,99.47 103.5,99.66 v5(103.59,99.75)
  GND1 w0.089: v5(103.59,99.75) 103.59,100.02 v4(103.69,100.13) ; v4(104.29,127.2) 104.29,127.45 v10(104.42,127.58)
  IN3 w0.084: v4(103.69,100.13) 103.59,100.13 103.4,100.31 103.4,100.95 101.22,103.13 101.22,107 100.71,107.51 100.71,107.62 101.11,108.02 101.11,108.28 100.72,108.67 100.46,108.67 100.09,108.3 99.92,108.3 99.6,108.62 99.6,118.73 99.91,119.04 99.91,123.28 102.34,125.71 103.38,125.71 104.12,126.44 104.12,127.03 v4(104.29,127.2)
SKYCAM_USER_CSI0_D#_L: length 33
  TOP w0.152: v2(128.46,137.3) 128.44,137.28 J3.8 ; v2(104.42,129.46) L29.2 104.42,128.97 R1115.2
  IN2 w0.084: v2(128.46,137.3) 128.62,137.46 128.62,137.55 128,138.17 125.67,138.17 125.11,137.61 125.11,136.75 124.39,136.02 121.22,136.02 120.12,137.12 110.82,137.12 108.37,134.68 107.5,134.68 104.71,131.88 104.71,130.65 103.85,129.8 103.85,129.59 103.98,129.46 v2(104.42,129.46)
SKYCAM_USER_CSI0_D_L: length 33
  TOP w0.152: J3.6 128.84,137.3 v2(128.84,137.3) ; v2(103.57,129.46) L29.3 103.57,128.97 R1116.2
  IN2 w0.084: v2(128.84,137.3) 128.78,137.36 128.78,137.61 128.06,138.33 125.61,138.33 124.95,137.68 124.95,136.82 124.32,136.18 121.29,136.18 120.18,137.29 110.75,137.29 108.3,134.84 107.43,134.84 104.54,131.95 104.54,130.72 103.69,129.87 103.69,129.58 v2(103.57,129.46)
SKYCAM_USER_CSI1_D: length 74.1
  TOP w0.152: v10(107.38,127.58) 107.38,127.89 R1109.1
  IN1 w0.06: 121.46,93.51 121.46,93.51 121.41,93.56 121.41,93.74 121.66,93.99 121.66,94.46 124.9,97.7 125.01,97.7 v1(125.14,97.57)
  IN1 w0.089: v5(104.99,99.46) 104.99,99.2 104.89,99.11 103.7,99.11 102.43,97.84 102.43,97.21 101.66,96.44 101.66,94.37 103.55,92.48 103.99,92.48 104.54,91.93 105.11,91.93 106.16,90.88 112.64,90.88 112.78,90.74 116.81,90.74 116.92,90.85 118.42,90.85 119.2,91.63 119.97,91.63 121.46,93.11 121.46,93.51
  GND1 w0.089: v4(104.86,99.84) 104.99,99.72 v5(104.99,99.46) ; v4(107.54,127.22) 107.38,127.38 v10(107.38,127.58)
  IN3 w0.084: v4(104.86,99.84) 104.94,99.91 104.94,100.95 106.66,102.68 106.66,104.72 105.58,105.8 104.42,105.8 100.82,109.41 100.51,109.41 100,109.92 100,118.51 100.31,118.83 100.31,123.12 102.5,125.31 103.64,125.31 104.87,126.54 107.43,126.54 107.54,126.64 v4(107.54,127.22)
SKYCAM_USER_CSI1_D#: length 74.1
  TOP w0.152: v10(108.23,127.58) 108.23,127.89 R1106.1
  IN1 w0.06: v1(125.14,98.09) 125.14,97.96 125,97.82 124.85,97.82 121.54,94.51 121.54,94.04 121.29,93.78 121.29,93.56 121.24,93.51 121.24,93.51
  IN1 w0.089: v5(105.36,99.46) 105.36,99.38 105.2,99.22 105.2,99.11 104.98,98.89 103.79,98.89 102.65,97.75 102.65,97.13 101.87,96.35 101.87,94.46 103.64,92.69 104.08,92.69 104.63,92.15 105.2,92.15 106.25,91.1 112.73,91.1 112.87,90.95 116.72,90.95 116.83,91.07 118.33,91.07 119.11,91.84 119.88,91.84 121.24,93.2 121.24,93.51
  GND1 w0.089: v10(108.23,127.58) 108.23,127.41 v4(108.05,127.22) ; v4(105.4,99.84) 105.4,99.84 105.31,99.75 105.31,99.51 v5(105.36,99.46)
  IN3 w0.084: v4(105.4,99.84) 105.36,99.84 105.1,100.1 105.1,100.88 106.83,102.61 106.83,104.78 105.65,105.96 104.49,105.96 100.88,109.57 100.58,109.57 100.16,109.99 100.16,118.45 100.47,118.76 100.47,123.05 102.56,125.14 103.7,125.14 104.93,126.37 107.5,126.37 107.71,126.59 107.71,126.9 108.04,127.22 v4(108.05,127.22)
SKYCAM_USER_CSI1_D#_L: length 31
  TOP w0.152: J3.20 126.04,137.29 v2(126.05,137.3) ; v2(108.23,129.6) L28.2 108.23,128.97 R1106.2
  IN2 w0.084: v2(126.05,137.3) 126.13,137.22 126.13,136.15 124.74,134.77 120.38,134.77 120.29,134.85 120.29,135.03 120.08,135.25 119.78,135.25 119.55,135.02 119.55,134.85 119.47,134.77 118.49,134.77 118.31,134.59 118.31,134.29 118.23,134.21 117.97,134.21 117.89,134.29 117.89,134.59 117.71,134.77 117.33,134.77 117.15,134.59 117.15,134.29 117.06,134.21 116.81,134.21 116.73,134.29 116.73,134.59 116.55,134.77 116.33,134.77 115.9,135.2 114.6,135.2 113.8,136 112.2,136 111.8,135.6 111.8,135.1 111.58,134.88 111.08,134.88 110.5,134.3 110.18,134.3 108.67,132.79 108.67,131.41 108.48,131.22 107.77,131.22 106.9,130.36 106.9,129.46 107.21,129.15 107.8,129.15 108.23,129.58 v2(108.23,129.6)
SKYCAM_USER_CSI1_D_L: length 31
  TOP w0.152: v2(126.43,137.3) 126.44,137.29 J3.18 ; R1109.2 107.38,128.97 L28.3 v2(107.38,129.6)
  IN2 w0.084: v2(126.43,137.3) 126.29,137.16 126.29,136.09 124.81,134.61 120.31,134.61 120.13,134.78 120.13,134.96 120.01,135.09 119.84,135.09 119.71,134.96 119.71,134.78 119.53,134.61 118.56,134.61 118.47,134.52 118.47,134.22 118.29,134.04 117.91,134.04 117.73,134.22 117.73,134.52 117.64,134.61 117.39,134.61 117.31,134.52 117.31,134.22 117.13,134.04 116.74,134.04 116.56,134.22 116.56,134.52 116.48,134.61 116.26,134.61 115.83,135.04 114.54,135.04 113.74,135.84 112.27,135.84 111.97,135.53 111.97,135.03 111.65,134.72 111.15,134.72 110.57,134.14 110.25,134.14 108.83,132.72 108.83,131.34 108.55,131.06 107.83,131.06 107.06,130.29 107.06,129.53 107.27,129.32 107.74,129.32 107.85,129.44 107.85,129.51 107.78,129.58 107.7,129.58 107.55,129.74 107.46,129.74 107.38,129.66 v2(107.38,129.6)
SKYCAM_USER_CSI_CLK_D: length 75.3
  TOP w0.152: R1092.1 105.47,127.89 v10(105.47,127.58)
  IN1 w0.06: 122.83,93.51 122.83,93.52 122.78,93.57 122.78,93.61 123.19,94.01 123.19,95.03 124.78,96.62 125.3,96.62 125.7,97.03 125.7,97.49 v1(125.78,97.57)
  IN1 w0.089: v5(101.94,99.73) 101.98,99.69 101.98,99.42 100.78,98.22 100.78,97.33 100.3,96.85 100.3,96.34 99.41,95.45 99.41,94.44 102.81,91.04 103.46,91.04 104.32,90.18 104.87,90.18 105.38,89.66 111.47,89.66 111.82,89.31 115.74,89.31 115.99,89.06 118.57,89.06 119.41,89.9 120.91,89.9 122.83,91.82 122.83,93.51
  GND1 w0.089: v5(101.94,99.73) 101.94,99.97 v4(101.79,100.12) ; v10(105.47,127.58) 105.5,127.56 105.68,127.56 v4(105.88,127.76)
  IN3 w0.084: v4(101.79,100.12) 101.92,100.25 101.92,101.4 99.74,103.59 99.74,107.46 98.84,108.36 98.84,123.27 103.28,127.72 105.66,127.72 105.66,127.72 105.85,127.72 105.88,127.74 v4(105.88,127.76)
SKYCAM_USER_CSI_CLK_D#: length 75.3
  TOP w0.152: R1091.1 106.32,127.89 v10(106.32,127.58)
  IN1 w0.06: 122.61,93.51 122.61,93.52 122.66,93.57 122.66,93.66 123.07,94.06 123.07,95.08 124.73,96.74 125.25,96.74 125.58,97.08 125.58,97.67 125.86,97.95 125.86,98.02 v1(125.78,98.09)
  IN1 w0.089: v5(102.29,99.73) 102.19,99.63 102.19,99.33 101,98.13 101,97.24 100.51,96.76 100.51,96.25 99.63,95.36 99.63,94.53 102.9,91.26 103.55,91.26 104.41,90.39 104.96,90.39 105.47,89.88 111.56,89.88 111.91,89.53 115.83,89.53 116.08,89.28 118.48,89.28 119.32,90.11 120.82,90.11 122.61,91.91 122.61,93.51
  GND1 w0.089: v10(106.32,127.58) 106.17,127.43 106.14,127.43 v4(105.93,127.21) ; v4(102.4,100.12) 102.29,100.01 v5(102.29,99.73)
  IN3 w0.084: v4(102.4,100.12) 102.27,100.12 102.09,100.3 102.09,101.47 99.9,103.66 99.9,107.53 99,108.43 99,123.21 103.35,127.55 105.59,127.55 v4(105.93,127.21)
SKYCAM_USER_CSI_CLK_D#_L: length 29.7
  TOP w0.152: J3.14 127.24,137.28 v2(127.26,137.3) ; R1091.2 106.32,128.97 L23.2 v2(106.32,129.47)
  IN2 w0.084: v2(127.26,137.3) 127.39,137.43 127.39,137.53 127.31,137.62 125.93,137.62 125.68,137.37 125.68,136.45 124.42,135.19 121.11,135.19 120.24,136.06 116.47,136.06 116,135.6 114.91,135.6 114.09,136.42 112.06,136.42 110.44,134.81 110.07,134.81 107.57,132.31 107.57,131.59 105.94,129.95 105.94,129.7 105.8,129.56 105.8,129.46 105.86,129.4 106.25,129.4 v2(106.32,129.47)
SKYCAM_USER_CSI_CLK_D_L: length 29.6
  TOP w0.152: v2(105.47,129.47) L23.3 105.47,128.97 R1092.2 ; J3.12 127.64,137.3 v2(127.64,137.3)
  IN2 w0.084: v2(105.47,129.47) 105.77,129.77 105.77,130.02 107.41,131.66 107.41,132.38 110,134.97 110.38,134.97 111.99,136.58 114.16,136.58 114.98,135.76 115.93,135.76 116.4,136.23 120.3,136.23 121.18,135.35 124.35,135.35 125.52,136.52 125.52,137.44 125.86,137.78 127.37,137.78 127.55,137.6 127.55,137.39 v2(127.64,137.3)
SLEEVE: length 7.2
  TOP w0.381: v7(18.45,14.33) 18.66,14.55 QA1.3
  IN3 w0.508: v7(22.36,10.07) 20.53,11.9 19.52,11.9 18.95,12.47 18.95,13.83 v7(18.45,14.33)
  vias: v7(19.13,6.54) v7(19.72,6.54) v7(22.26,9.41)
SM_INTRUDER#: length 14.4
  TOP w0.119: RH64.2 v1(141.31,116.92)
  IN1 w0.06: v1(130.62,110.9) 130.98,110.9 131.06,110.99 131.44,111.36 131.6,111.36 131.86,111.62 131.96,111.62 132.15,111.8 132.15,112.28 132.17,112.28 132.17,112.47 133.79,114.09 136.31,114.09 137.63,115.41 138.07,115.41 138.25,115.58 138.25,115.59 138.25,115.93 138.38,116.06
  IN1 w0.076: v1(141.31,116.92) 141.08,116.7 139.5,116.7 138.96,116.16 138.47,116.16 138.38,116.06
SMBALERT#: length 11.1
  TOP w0.119: RH101.1 140.4,96.36 140.63,96.59 140.63,97.02 v2(140.53,97.13)
  IN2 w0.06: 139.19,98.25 138.99,98.45 138.96,98.45 138.66,98.74 138.66,99.44 138.09,100.01 138.09,100.1 137.17,101.02 137.17,101.3 136.81,101.66 136.66,101.66 136.62,101.62 136.39,101.62 136.2,101.81 136.2,102.09 135.95,102.34 134.96,102.34 134.72,102.58 133.71,102.58 v2(133.67,102.54)
  IN2 w0.084: v2(140.53,97.13) 140.53,97.33 140.51,97.35 140.51,97.51 140.24,97.77 139.66,97.77 139.19,98.25
SMBCLK: length 63.5
  TOP w0.152: v2(142.02,101.07) 141.57,100.63 RH94.1
  IN1 w0.089: v3(147.33,98.86) 147.44,98.86 v8(148.45,97.84)
  GND1 w0.089: v4(149,97.49) 148.8,97.49 v8(148.45,97.84)
  IN2 w0.06: v2(132.68,103.82) 132.7,103.84 132.91,103.84 133.15,104.09 133.15,104.2 133.3,104.35 133.97,104.35 134.05,104.27 135.98,104.27 136.66,103.59 137.32,103.59 137.47,103.44 137.85,103.44 138.21,103.79 138.66,103.79 139.45,103.01 139.55,103.01
  IN2 w0.084: v3(147.33,98.86) 146.99,98.86 146.54,99.31 145.76,99.31 144.31,100.76 142.79,100.76 142.47,101.07 v2(142.02,101.07) 141.85,101.07 139.92,103.01 139.55,103.01
  IN3 w0.084: v6(126.6,83.22) 126.14,83.22 v6(123.55,85.81)
  GND4 w0.089: v9(149.33,97.84) 149,97.51 v4(149,97.49)
  BOTTOM w0.152: JXDP2.53 121.05,90.57 123.98,87.64 123.98,86.24 v6(123.55,85.81) ; v6(126.6,83.22) 128.13,84.76 133.59,84.76 135.79,86.95 137.73,86.95 138.74,87.96 143,87.96 147.05,92.01 147.05,92.45 149.5,94.9 149.5,97.67 v9(149.33,97.84)
SMBDATA: length 66.6
  IN1 w0.06: 139.92,101.1 139.84,101.18 139.3,101.18 139.22,101.1 138.74,101.1 138.69,101.15 137.2,101.15 136.5,101.86 136.5,102.17 135.93,102.74 134.36,102.74 v1(134.16,102.54) ; 140.16,101 140.13,100.97
  IN1 w0.089: v1(142.13,100.53) 141.47,100.53 140.85,101.15 140.31,101.15 140.16,101 ; 140.13,100.97 140.09,100.93 ; 140.09,100.93 140.09,100.6 140.61,100.08 141.08,100.08 141.23,99.93 141.23,99.53 142.35,98.41 142.35,97.36 142.9,96.81 147.05,96.81 147.61,97.38 150.32,97.38 v8(150.4,97.46) ; 140.09,100.93 139.92,101.1
  GND1 w0.089: v8(150.4,97.46) v4(149.82,97.46)
  IN3 w0.084: v6(123.32,86.14) 123.63,86.14 126.27,83.5 127.21,83.5 v6(127.64,83.07)
  GND4 w0.089: v9(150.17,97.61) 150.02,97.46 v4(149.82,97.46)
  BOTTOM w0.152: JXDP2.51 120.55,90.29 123.32,87.51 v6(123.32,86.14) ; v9(150.17,97.61) 150.17,94.82 147.63,92.28 147.63,91.84 143.22,87.43 138.96,87.43 137.95,86.42 136.01,86.42 133.81,84.22 128.8,84.22 v6(127.64,83.07)
SML0ALERT#: length 7.1
  IN1 w0.06: v5(139.6,101.86) 139.39,101.65 137.9,101.65 137.73,101.82 137.19,101.82 136.03,102.98 134.74,102.98 134.36,102.98 v1(134.16,103.18)
  GND1 w0.119: v4(139.93,101.66) 139.72,101.87 139.61,101.87 v5(139.6,101.86)
  GND4 w0.119: v9(139.5,101.51) 139.78,101.51 v4(139.93,101.66)
SML0CLK: length 6.8
  IN1 w0.06: v5(139.6,100.96) 139.49,100.84 138.59,100.84 138.4,101.03 137.15,101.03 136.38,101.81 136.38,102.12 135.96,102.54 134.66,102.54 v1(134.65,102.54)
  GND1 w0.089: v4(140.02,100.88) 139.68,100.88 v5(139.6,100.96)
  GND4 w0.089: v9(139.59,100.87) 139.68,100.78 139.91,100.78 v4(140.02,100.88)
SML0DATA: length 7.1
  IN2 w0.06: v4(138.54,103.49) 138.37,103.32 137.42,103.32 137.27,103.47 136.61,103.47 135.93,104.15 133.71,104.15 133.5,103.95 133.3,103.95 v2(133.17,103.82)
  GND4 w0.089: v9(138.94,103.44) 138.89,103.49 v4(138.54,103.49)
  BOTTOM w0.152: v9(138.94,103.44) 138.94,103.13 139.05,103.03 RH100.1
SML1_SMBCLK: length 153
  TOP w0.06: v1(237.29,126.07) 237.08,126.28 236.25,126.28 235.96,126 234.56,126 U27.D3
  IN1 w0.06: v5(137.29,102.04) 137.09,102.24 136.94,102.24 136.02,103.16 134.67,103.16 v1(134.65,103.18)
  IN1 w0.089: v1(237.29,126.07) 237.32,126.09 238.06,126.09 238.41,125.74 240.52,125.74 241.18,126.4 243.45,126.4 245.12,124.73 245.12,118.11 244.09,117.08 242.42,117.08 239.22,113.88 233.24,113.88 233.04,114.07 218.23,114.07 217.97,113.81 217.97,111.76 217.65,111.44 217.65,111.03 217.29,110.68 v3(215.89,110.68)
  GND1 w0.119: v4(137.55,101.74) 137.29,101.99 v5(137.29,102.04)
  IN2 w0.06: v4(137.55,101.74) 137.41,101.59 137.41,101.12 138.33,100.2 138.36,100.2 139.01,99.55 139.01,99.4 139.55,98.85
  IN2 w0.084: v3(215.89,110.68) 215.87,110.68 215.1,111.45 214.17,111.45 212.52,113.11 209.71,113.11 208.99,112.39 203.69,112.39 202.98,111.68 200.14,111.68 193.76,105.29 193.76,105 188.78,100.02 188.78,99.55 187.45,98.22 187.45,96.46 182.26,91.28 177.06,91.28 175.37,92.97 163.12,92.97 162.7,93.4 160.03,93.4 159.7,93.73 158.99,93.73 158.58,93.32 157.73,93.32 157.05,94 155.38,94 154.68,94.69 153.47,94.69 152.84,94.06 150.19,94.06 149.04,95.21 148.4,95.21 146.74,96.86 146.21,96.86 145.89,97.19 145.31,97.19 144.76,97.74 142.37,97.74 142.06,98.04 141.51,98.04 140.86,98.69 139.71,98.69 139.55,98.85
  IN3 w0.084: v6(137.22,101.98) 137.22,101.96 137.45,101.74 v4(137.55,101.74)
  BOTTOM w0.119: RH96.1 137.38,102.14 v6(137.22,101.98)
SML1_SMBDAT: length 151.4
  TOP w0.119: v1(237.38,123.78) 235.84,123.78 U27.A7
  IN1 w0.089: v3(215.49,110.68) 215.77,110.96 216.27,110.96 216.79,111.48 217.41,111.48 217.78,111.84 217.78,114.44 218.72,115.38 225.67,115.38 225.82,115.53 230.52,115.53 230.88,115.88 232.04,115.88 233.44,114.49 239.02,114.49 242.18,117.65 243.84,117.65 244.55,118.36 244.55,123.98 243.16,125.37 241.04,125.37 240.81,125.14 239.26,125.14 237.9,123.78 v1(237.38,123.78)
  IN2 w0.06: v2(133.17,102.54) 133.37,102.74 134.77,102.74 135.04,102.46 136.06,102.46 136.48,102.05 136.48,101.99 136.51,101.96 v4(136.51,101.94) 136.7,101.94 137.29,101.35 137.29,101.07 138.22,100.14 138.22,100.07 138.84,99.45 138.84,99.3 139.55,98.59
  IN2 w0.084: v3(215.49,110.68) 214.99,111.17 214.19,111.17 212.44,112.92 209.79,112.92 209.05,112.19 203.75,112.19 203.02,111.45 200.18,111.45 193.96,105.23 193.96,104.94 188.96,99.94 188.96,99.47 187.73,98.23 187.73,96.46 182.21,90.95 176.83,90.95 175.01,92.77 163.06,92.77 162.62,93.21 158.73,93.21 158.66,93.13 157.66,93.13 156.98,93.81 155.2,93.81 155.14,93.87 150.12,93.87 148.97,95.02 148.32,95.02 147.22,96.12 146.3,96.12 146.13,96.29 145.82,96.29 145.75,96.35 145.42,96.35 145.08,96.69 145.08,97.15 144.68,97.55 142.29,97.55 141.98,97.86 141.43,97.86 140.79,98.5 139.63,98.5 139.55,98.59
  IN3 w0.084: v4(136.51,101.94) 136.72,101.72 v6(136.84,101.72)
  BOTTOM w0.119: RH97.1 137.04,101.51 136.84,101.71 v6(136.84,101.72)
SML1ALERT#: length 15.3
  TOP w0.119: v2(145.37,112.81) 145.41,112.85 RH181.1
  IN1 w0.06: v1(134.16,109.62) 134.37,109.62 134.58,109.84 135.21,109.84 135.55,109.5 136.36,109.5 v3(136.38,109.48)
  IN2 w0.06: v3(136.38,109.48) 136.4,109.51 137.01,109.51 v4(137.04,109.53) 137.09,109.53 137.34,109.28 138.34,109.28 138.4,109.33 138.64,109.33 139.29,109.99 139.29,110.92 140.43,112.05 140.7,112.05
  IN2 w0.084: v2(145.37,112.81) 144.65,112.81 144.22,112.38 143.99,112.38 143.48,111.87 142.41,111.87 142.07,112.21 141.37,112.21 141.21,112.05 140.7,112.05
  IN3 w0.084: v6(137.48,109.09) 137.48,109.11 137.06,109.53 v4(137.04,109.53)
SOC_SATALED#: length 7.9
  IN1 w0.06: 137.54,96.9 137.38,97.06 136.59,97.06 136.4,97.25 135.81,97.25 134.85,98.2 134.5,98.2 134.35,98.36 134.35,98.51 134.22,98.64 134.02,98.64 133.92,98.74 133.92,99.07 v1(133.67,99.31)
  IN1 w0.089: v1(139.68,95.54) 139.22,95.99 138.93,95.99 138.56,96.36 138.08,96.36 137.54,96.9
SOC_SVID_ALERT#: length 7.7
  TOP w0.06: 117.71,96.22 117.71,96.36 117.61,96.45 117.47,96.45 117.35,96.56 117.35,96.79 117.7,97.14 117.83,97.14 117.95,97.26 118.01,97.26 118.07,97.21 118.14,97.21 118.32,97.39 118.41,97.39 118.45,97.43 118.45,97.67 118.5,97.72 118.5,97.85 118.41,97.93 UC1.B58
  TOP w0.152: 117.71,96.22 117.61,96.12 117.41,96.12 117.12,95.84 116.97,95.84 116.85,95.72 116.85,95.44 117.1,95.18 117.1,95.05 116.83,94.79 116.66,94.79 116.57,94.88 116.57,95.16 116.47,95.26 116.2,95.26 116.14,95.2 116.14,94.9 115.96,94.72 115.96,94.47 116.21,94.22 RC143.1
SOC_SVID_ALERT#_R: length 78.2
  TOP w0.152: v2(116.57,93.3) 116.63,93.3 117.01,92.92 117.33,92.92 117.56,92.69 RC142.2
  IN2 w0.084: v2(116.57,93.3) 116.57,93.28 116.41,93.12 115.92,93.12 115.7,92.9 115.66,92.9 115.14,92.39 114.05,92.39 114.03,92.41 113.11,92.41 112.43,91.73 112.07,91.73 112.05,91.71 112.05,91.71 111.65,91.31 111.02,91.31 110.98,91.26 110.39,91.26 109.5,92.15 109.5,92.59 106.4,95.69 106.12,95.69 105.99,95.82 105.99,96.19 105.88,96.3 105.72,96.3 105.61,96.19 105.61,95.82 105.48,95.69 105.27,95.69 105.15,95.82 105.15,96.21 105.03,96.33 104.86,96.33 104.74,96.21 104.74,95.75 104.61,95.63 103.93,95.63 103.35,96.21 101.85,96.21 100.96,97.09 100.38,97.09 99.49,97.98 98.87,97.98 97.35,99.49 97.35,100.05 96.73,100.66 96.73,102.03 96.65,102.11 96.02,102.11 95.94,102.19 95.94,102.49 96.02,102.57 96.65,102.57 96.73,102.65 96.73,102.95 96.65,103.03 96.02,103.03 95.94,103.12 95.94,103.42 96.02,103.5 96.65,103.5 96.73,103.58 96.73,103.89 95.13,105.49 95.13,110.17 90.42,114.87 88.95,114.87 87.91,115.91 87.05,115.91 86.21,116.75 83.35,116.75 82.84,116.24 74.38,116.24 74.08,115.94 72.61,115.94 72.04,115.37 72.04,114.82 71.48,114.26 69.57,114.26 68.49,115.34 67.37,115.34 66.78,114.75 66.78,114.12 67.15,113.76 67.15,113.17 67.76,112.56 67.77,112.55 67.77,112.12 v2(68.1,111.79)
SOC_SVID_CLK: length 7.7
  TOP w0.06: UC1.A56 118.7,97.4 118.55,97.25 118.36,97.25 118.32,97.21 118.32,97.06 118.27,97.01 118.27,96.96 118.22,96.91 118.12,96.91 118.07,96.96 118.07,97.03 118.01,97.09 117.95,97.09 117.86,97 117.86,96.88 117.81,96.83 117.58,96.83 117.51,96.76 117.51,96.65 117.58,96.58 117.84,96.58 117.96,96.71 118.12,96.71 118.18,96.64 118.18,96.52 117.94,96.28 117.94,96.17 118.02,96.09 118.13,96.09 118.19,96.15 118.32,96.15
  TOP w0.152: 118.32,96.15 118.47,95.99 118.47,95.77 118.32,95.61 118.12,95.61 117.85,95.88 117.59,95.88 117.43,95.71 117.43,95.54 117.76,95.21 117.76,94.89 117.65,94.78 117.47,94.78 117.2,94.51 117.2,94.37 117.3,94.27 RC145.1
SOC_SVID_CLK_R: length 81.1
  TOP w0.152: PR803.2 68.99,112.68 v2(68.1,113.57) ; RC145.2 117.38,93.35 v2(117.32,93.42)
  IN2 w0.084: v2(117.32,93.42) 117.27,93.42 116.36,92.51 115.82,92.51 115.37,92.07 115.37,92.07 115.23,91.93 114.74,91.93 114.7,91.88 114.59,91.88 114.34,91.63 113.88,91.63 113.88,91.63 113.73,91.63 113.42,91.32 112.21,91.32 111.75,90.86 110.18,90.86 109.8,91.24 108.97,91.24 108.49,91.73 108.49,93.05 106.26,95.28 104.87,95.28 104.82,95.23 103.74,95.23 103.15,95.82 101.6,95.82 100.72,96.71 99.59,96.71 96.96,99.33 96.96,99.89 96.25,100.6 95.69,100.6 95.54,100.76 95.54,101.1 95.62,101.18 96.24,101.18 96.32,101.26 96.32,101.56 96.24,101.64 95.62,101.64 95.54,101.72 95.54,102.7 95.45,102.78 95.27,102.78 95.14,102.65 95.14,102.19 95.02,102.07 94.85,102.07 94.72,102.19 94.72,102.65 94.6,102.78 94.32,102.78 94.24,102.86 94.24,103.16 94.32,103.24 95.45,103.24 95.54,103.32 95.54,103.62 95.45,103.7 94.32,103.7 94.24,103.78 94.24,104.08 94.32,104.17 95.46,104.17 95.59,104.29 95.59,104.47 95.46,104.6 94.8,104.6 94.67,104.73 94.67,110.02 90.2,114.49 88.79,114.49 87.93,115.34 87.55,115.34 87.03,114.82 86.57,114.82 85.52,115.87 85.52,116.26 85.42,116.36 85.28,116.36 85.18,116.26 85.18,115.87 85.1,115.78 84.93,115.78 84.85,115.87 84.85,116.02 84.77,116.1 84.6,116.1 84.51,116.02 84.51,115.87 84.43,115.78 76.37,115.78 76.24,115.65 76.24,114.99 76.12,114.87 75.72,114.87 75.6,114.99 75.6,115.65 75.47,115.78 74.57,115.78 73.6,114.81 72.88,114.81 71.49,113.42 70.56,113.42 70.44,113.29 70.44,113.01 70.31,112.88 70.15,112.88 70.02,113.01 70.02,113.44 69.9,113.57 v2(68.1,113.57)
SOC_SVID_DAT: length 9.7
  TOP w0.06: UC1.A58 118.08,97.57 117.77,97.26 117.65,97.26 117.07,96.68 117.07,96.6 117.29,96.39 117.29,96.26 117.19,96.16 117.06,96.16 116.88,96.34 116.83,96.34 116.69,96.2 116.69,96.12 116.8,96.02 116.8,95.97 116.69,95.87
  TOP w0.152: 116.69,95.87 116.54,95.72 116.3,95.72 116.12,95.89 115.69,95.89 115.56,95.77 115.56,95.63 115.68,95.51 115.68,95.17 115.61,95.11 115.5,95.11 115.28,95.32 115.11,95.32 114.74,94.95 114.74,94.88 114.81,94.8 115.4,94.8 115.49,94.71 115.49,94.38 RC146.1 115.4,94.29 116,93.7 116,92.87 115.77,92.64 RC144.1
SOC_SVID_DAT_R: length 80.3
  TOP w0.152: v2(68.03,110.98) PR836.1 68.1,110.93 PR802.2 ; v2(114.99,92.79) 115.27,92.79 115.4,92.92 RC146.2
  IN2 w0.084: v2(114.99,92.79) 114.82,92.96 114.59,92.96 114.48,92.85 114.26,92.85 114.14,92.96 113.92,92.96 113.8,92.85 113.59,92.85 113.47,92.96 112.9,92.96 112.58,92.64 111.64,92.64 111.16,92.16 111.16,91.97 110.89,91.69 110.5,91.69 109.89,92.31 109.89,92.75 109.8,92.84 109.8,92.95 109.97,93.12 109.97,93.24 109.85,93.36 109.74,93.36 109.57,93.19 109.45,93.19 109.33,93.31 109.33,93.43 109.5,93.6 109.5,93.72 109.38,93.83 109.26,93.83 109.09,93.67 108.97,93.67 106.66,95.98 106.66,96.97 106.32,97.32 104.37,97.32 103.71,96.66 102.84,96.66 102.71,96.78 102.71,97.35 102.58,97.48 102.42,97.48 102.3,97.35 102.3,96.75 102.18,96.63 102.01,96.63 101.89,96.75 101.89,97.35 101.76,97.48 101.13,97.48 101.12,97.48 100.54,97.48 99.65,98.37 99.02,98.37 97.74,99.66 97.74,100.21 97.14,100.81 97.14,104.05 95.56,105.62 95.56,110.4 90.69,115.26 89.11,115.26 88.03,116.34 87.17,116.34 86.37,117.14 83.19,117.14 82.68,116.63 74.57,116.63 74.4,116.8 72.45,116.8 70.82,115.17 69.48,115.17 68.92,115.73 68.67,115.73 68.59,115.81 68.59,116.21 68.5,116.29 68.34,116.29 68.25,116.21 68.25,115.81 68.17,115.73 68,115.73 67.92,115.81 67.92,116.21 67.83,116.29 67.67,116.29 67.58,116.21 67.58,115.81 67.5,115.73 67.18,115.73 66.36,114.92 66.36,113.57 66.11,113.32 66.11,112.94 66.44,112.61 66.44,112.38 67.05,111.77 67.49,111.77 68.03,111.23 v2(68.03,110.98)
SP7_SDWP: length 5.6
  TOP w0.152: QR1.1 28.57,72.93 28.26,73.24 28.26,75.9 27.98,76.19 UR1.29
SPDIF_IN: length 2.4
  TOP w0.119: UA2.9 203.58,124.94 202.29,126.23 TC19.1
SPI1_CLK: length 24.2
  TOP w0.119: RC73.1 150.39,94.6 150.39,95.06 150.57,95.24 150.57,95.9 151.1,96.43 151.1,96.78 v2(151.14,96.81)
  IN2 w0.084: v4(163.28,96.25) 163.68,96.66 163.68,96.99 163.54,97.13 162.74,97.13 162.09,97.78 157.89,97.78 157.28,97.17 151.44,97.17 151.02,97.58 150.87,97.58 150.77,97.48 150.77,97.33 151.14,96.96 v2(151.14,96.81)
  GND4 w0.119: v9(163.28,95.79) v4(163.28,96.25)
  BOTTOM w0.119: v9(163.28,95.79) 163.48,95.59 v14(163.48,95.31) 163.48,93.28 163.19,92.99 163.19,92.29 163.91,91.58 JITOUCH.2
SPI1_CS#: length 17
  TOP w0.119: v10(160.31,92.26) 161.93,92.26 162.54,91.65 RC89.1
  GND1 w0.119: v10(160.31,92.26) 160.17,92.4 v4(160.17,92.63)
  GND4 w0.119: v4(160.17,92.63) 160.17,92.62 160.38,92.4 v9(160.38,92.26)
  BOTTOM w0.119: JITOUCH.8 160.91,93.08 160.79,93.2 160.5,93.2 160.38,93.32 160.38,93.5 160.5,93.62 160.79,93.62 160.91,93.74 160.91,93.93 160.79,94.05 160.5,94.05 160.38,94.17 160.38,94.35 160.5,94.47 160.79,94.47 160.91,94.59 160.91,94.93 160.69,95.16 160.27,95.16 v14(159.78,94.67) 158.23,93.12 158.23,92.94 158.46,92.71 158.64,92.71 159.66,93.73 159.85,93.73 159.97,93.61 159.97,92.46 160.08,92.34 160.31,92.34 v9(160.38,92.26)
SPI1_INT#: length 33.5
  IN1 w0.06: v3(137.17,98.41) 136.96,98.61 136.4,98.61 135.25,99.75 134.56,99.75 134.36,99.96 134.36,100.05 134.33,100.08 134.32,100.08 134.21,100.2 134.21,100.2 134.12,100.28 v1(133.91,100.28)
  IN2 w0.06: 138.51,97.54 138.36,97.7 138.13,97.7 137.73,98.1 137.47,98.1 v3(137.17,98.41)
  IN2 w0.084: 138.51,97.54 138.66,97.39 v4(138.66,96.9) 138.72,96.9 139.15,96.46 139.15,96.17 139.66,95.66 140.21,95.66 140.57,95.31 142.18,95.31 142.57,94.92 142.57,94.57 142.86,94.28 143.8,94.28 144.56,93.52 146.23,93.52 146.49,93.27 146.66,93.27 146.87,93.06 149.22,93.06 149.66,93.5 154.98,93.5 155.05,93.44 156.8,93.44 157.48,92.76 159.45,92.76 v4(159.57,92.64)
  GND4 w0.119: v9(159.68,92.27) 159.59,92.36 159.59,92.62 v4(159.57,92.64) ; v9(138.22,96.58) 138.54,96.9 v4(138.66,96.9)
  BOTTOM w0.119: v13(159.59,92.92) 159.59,92.36 v9(159.68,92.27) 159.73,92.27 160.41,91.6 JITOUCH.9 ; v9(138.22,96.58) 138.22,96.15 RC50.2
SPI1_IO2: length 23.4
  TOP w0.119: RC77.1 150.41,96.39 150.41,96.64 v2(150.43,96.66)
  IN2 w0.084: v4(161.22,96.13) 161.22,96.02 161.09,95.89 160.71,95.89 160.59,96.02 160.59,96.48 160.71,96.6 161.55,96.6 161.68,96.73 161.68,97 161.55,97.13 160.03,97.13 159.87,96.97 159.87,96.63 159.54,96.3 157.79,96.3 157.58,96.52 152.69,96.52 152.44,96.27 150.74,96.27 150.43,96.58 v2(150.43,96.66)
  GND4 w0.119: v9(161.52,95.77) 161.22,96.07 v4(161.22,96.13)
  BOTTOM w0.119: v9(161.52,95.77) 161.37,95.62 161.37,94.63 161.49,94.51 v14(161.7,94.51) 161.91,94.51 162.03,94.39 162.03,94.21 161.91,94.09 161.49,94.09 161.37,93.97 161.37,93.79 161.49,93.67 161.91,93.67 162.03,93.55 162.03,93.36 161.91,93.24 161.49,93.24 161.37,93.12 161.37,92.29 161.91,91.75 JITOUCH.6
SPI1_IO3: length 15.1
  TOP w0.119: v10(162.42,97.57) 159.05,97.57 158.93,97.45 156.37,97.45 RC80.1
  GND1 w0.119: v10(162.42,97.57) 162.8,97.57 v4(162.83,97.54)
  GND4 w0.119: v9(162.34,97.44) 162.43,97.53 162.83,97.53 v4(162.83,97.54)
  BOTTOM w0.119: JITOUCH.7 161.41,91.75 161.15,92.01 161.15,96.13 161.5,96.48 162.01,96.48 v14(162.34,96.81) v9(162.34,97.44)
SPI1_MISO: length 23.2
  TOP w0.119: RC75.1 150.04,95.03 150.35,95.33 150.35,96.02 150.77,96.44 150.77,96.64 v2(150.78,96.66)
  IN2 w0.084: v2(150.78,96.66) 150.98,96.45 152.36,96.45 152.61,96.7 157.47,96.7 158.09,97.31 158.4,97.31 158.48,97.23 158.48,96.66 158.56,96.58 159.56,96.58 159.67,96.69 159.67,96.85 159.56,96.96 158.87,96.96 158.82,97.01 158.82,97.23 158.9,97.31 161.9,97.31 162.74,96.46 v4(162.74,96.27)
  GND4 w0.119: v4(162.74,96.27) v9(162.74,95.84)
  BOTTOM w0.119: v9(162.74,95.84) 162.74,95.51 162.91,95.35 v13(162.91,93.52) 162.69,93.3 162.69,91.78 162.91,91.56 JITOUCH.4
SPI1_MOSI: length 19.6
  TOP w0.119: RC76.1 v2(149.93,96.66)
  IN2 w0.084: v4(162.13,96.15) 161.83,96.15 161.37,95.69 160.56,95.69 160.14,96.11 157.71,96.11 157.5,96.33 152.76,96.33 152.51,96.08 150.5,96.08 v2(149.93,96.66)
  GND4 w0.119: v4(162.13,96.15) v9(162.13,95.69)
  BOTTOM w0.119: JITOUCH.5 162.41,92.36 162.29,92.48 v13(162.08,92.48) 161.85,92.48 161.73,92.6 161.73,92.78 161.85,92.9 162.29,92.9 162.41,93.02 162.41,94.27 162.69,94.55 162.69,95.24 162.24,95.69 v9(162.13,95.69)
SPI_CLK_ROM1: length 6.1
  TOP w0.305: RH89.1 213.18,128.54 213.95,129.32 215.14,129.32 215.5,129.68 215.5,130.95 215.25,131.2 U18.6
SPI_IO2_ROM1: length 2.4
  TOP w0.305: U18.3 206.38,131.2 205.9,130.72 RH106.1
SPI_IO3_ROM1: length 5.2
  TOP w0.305: U18.7 215.12,132.47 215.47,132.82 215.47,134.02 214.48,135.01 RH108.1
SPI_PCH_CLK: length 21.3
  TOP w0.152: v7(214.15,128.56) 213.56,127.96 RH89.2 ; RC55.2 211.22,139.34 v7(211.22,139.76)
  IN3 w0.084: v7(211.22,139.76) 211.27,139.76 212.19,138.83 212.19,138.42 211.76,137.99 211.76,137.81 211.91,137.66 212.09,137.66 212.5,138.07 212.67,138.07 212.85,137.89 212.85,137.76 212.34,137.26 212.34,137.08 212.49,136.93 212.67,136.93 213.18,137.44 213.3,137.44 213.47,137.27 213.47,136.54 213.36,136.43 212.02,136.43 211.89,136.3 211.89,136.09 212.02,135.96 212.86,135.96 212.99,135.84 212.99,134.91 213.43,134.47 213.43,133.65 214.13,132.95 214.13,128.58 v7(214.15,128.56)
  BOTTOM w0.152: JSPI1.7 211.28,139.82 v7(211.22,139.76)
SPI_PCH_CS0#: length 19.4
  TOP w0.152: v7(209.94,139.71) 209.94,139.07 RC56.2 ; v7(207.65,134.88) 207.8,134.73 U18.1
  IN3 w0.084: v7(209.94,139.71) 209.94,139.68 209.55,139.29 209.08,139.29 209,139.2 209,138.91 209.08,138.82 209.55,138.82 209.63,138.74 209.63,138.44 209.55,138.36 208.39,138.36 208.26,138.23 208.26,138.02 208.39,137.89 209.55,137.89 209.63,137.81 209.63,137.3 209.27,136.94 209.27,136.82 209.59,136.51 209.59,136.39 209.38,136.18 209.26,136.18 208.94,136.5 208.83,136.5 208.61,136.28 208.61,136.17 209.18,135.6 209.18,135.42 209.03,135.27 209.03,134.74 207.78,133.49 207.6,133.49 207.39,133.7 207.39,133.88 208.36,134.86 208.36,135.54 208.29,135.62 207.95,135.62 207.65,135.32 v7(207.65,134.88)
  BOTTOM w0.152: v7(209.94,139.71) 210.28,140.05 JSPI1.9
SPI_PCH_IO2: length 33.5
  TOP w0.152: RH106.2 v7(204.3,130.72) ; v7(209.12,139.7) 208.79,139.37 208.79,138.95 RC57.2 ; RH90.2 210.17,135.59 209.76,136 v7(209.73,136)
  IN3 w0.084: v7(204.3,130.72) 204.3,130.82 204.07,131.05 204.07,134.22 204.34,134.49 204.34,135.4 204.59,135.65 204.7,135.65 204.94,135.42 205.12,135.42 205.27,135.57 205.27,135.75 204.86,136.15 204.86,136.33 205.09,136.56 205.27,136.56 205.81,136.02 205.93,136.02 206.14,136.23 206.14,136.35 205.61,136.88 205.61,137.06 205.76,137.21 205.94,137.21 206.47,136.68 206.59,136.68 206.8,136.89 206.8,137.01 206.28,137.52 206.28,137.7 206.43,137.85 206.61,137.85 207.13,137.34 207.24,137.34 207.45,137.55 207.45,137.67 206.97,138.16 206.97,138.34 207.14,138.51 207.32,138.51 207.64,138.2 207.82,138.2 207.96,138.34 207.96,138.52 207.77,138.72 207.77,138.84 207.98,139.05 208.1,139.05 208.33,138.82 208.51,138.82 208.66,138.96 208.66,139.14 208.48,139.33 208.48,139.42 208.76,139.7 v7(209.12,139.7)
  BOTTOM w0.152: v7(209.73,136) 211.39,134.35 212.11,134.35 212.24,134.48 212.24,135.6 212.11,135.73 211.07,135.73 210.12,136.69 209.2,136.69 208.74,137.14 208.74,137.7 209.12,138.08 v7(209.12,139.7) 209.12,139.9 209.28,140.06 JSPI1.11
SPI_PCH_IO3: length 31.8
  TOP w0.152: RH183.2 207.69,135.89 207.82,135.76 208.11,135.76 208.24,135.89 208.24,136.3 208.36,136.43 209.06,136.43 209.19,136.56 209.19,136.81 209.06,136.94 206.56,136.94 206.43,137.07 206.43,137.68 206.56,137.8 207.09,137.8 207.22,137.93 207.22,138.29 207.09,138.41 206.62,138.41 206.5,138.54 206.5,139.24 206.37,139.37 205.62,139.37 205.49,139.49 205.49,139.76 205.62,139.89 206.95,139.89 207.08,139.76 207.08,139.05 207.21,138.92 RC58.2 208.31,139.48 v7(208.31,139.78) ; RH108.2 212.77,135.44 212.77,135.68 212.5,135.95 211.55,135.95 RH91.2 211.05,135.71 211.05,135.92 210.88,136.1 v10(210.7,136.1)
  GND1 w0.089: v10(210.7,136.1) v4(210.29,136.1)
  IN3 w0.084: v7(208.31,139.78) 208.3,139.77 207.64,139.77 207.45,139.96 207.45,141.26 207.58,141.38 207.85,141.38 207.98,141.26 207.98,140.39 208.11,140.27 208.4,140.27 208.51,140.39 208.51,141.23 208.64,141.36 208.9,141.36 209.02,141.23 209.02,140.64 209.18,140.48 209.96,140.48 210.32,140.13 210.32,139.47 210.01,139.16 210.01,137.02 210.29,136.74 v4(210.29,136.1)
  BOTTOM w0.152: JSPI1.13 208.28,139.82 v7(208.31,139.78)
SPI_PCH_SI: length 19.5
  TOP w0.152: RC54.2 213.04,139.67 v7(212.98,139.73) ; RH107.2 212.48,127.72 212.91,127.29 213.37,127.29 v10(214.31,126.35)
  GND1 w0.089: v4(214.81,126.58) 214.59,126.35 v10(214.31,126.35)
  IN3 w0.084: v7(212.98,139.73) 212.98,138.45 213.98,137.45 213.98,135.29 214.97,134.3 214.97,129.53 215.32,129.18 215.32,127.31 214.81,126.8 v4(214.81,126.58)
  BOTTOM w0.152: v7(212.98,139.73) 213.28,140.04 JSPI1.3
SPI_PCH_SO: length 24.4
  TOP w0.152: v1(206.1,133.31) 206.1,134.07 207.22,135.19 RC53.2 207.44,135.52 207.58,135.37 208.43,135.37 209.62,136.56 210.79,136.56 211.41,137.18 211.41,138.46 212.04,139.09 v7(212.04,139.8)
  IN1 w0.089: v1(206.1,133.31) 206.1,133.06 206.69,132.48 206.69,132.33 206.59,132.23 206.45,132.23 205.73,132.95 205.58,132.95 205.48,132.85 205.48,132.7 206.11,132.07 206.11,131.88 206,131.78 205.86,131.78 204.78,132.85 204.21,132.85 204.11,132.75 204.11,132.63 204.21,132.53 204.78,132.53 204.88,132.43 204.88,132.34 204.78,132.24 204.21,132.24 204.11,132.14 204.11,132.01 204.21,131.91 205.35,131.91 205.45,131.81 205.45,131.69 205.35,131.59 204.21,131.59 204.11,131.49 204.11,131.24 204.23,131.11 204.86,131.11 204.98,131.24 v1(204.98,131.29)
  BOTTOM w0.152: JSPI1.5 212.28,140.04 v7(212.04,139.8)
SPI_SI_ROM1: length 2.2
  TOP w0.305: U18.5 213.14,129.93 212.83,129.62 212.83,129.22 212.48,128.86 RH107.1
SPI_SO_ROM1: length 2.8
  TOP w0.305: RH105.1 205.57,131.43 206.61,132.47 U18.2
SPK_L+: length 14.9
  IN1 w0.762: 20.51,92.84 20.01,92.34 14.46,92.34 13.37,93.43 11.16,93.43 10.83,93.76 10.83,94.88 11.82,95.87 11.82,96.78
  GND1 w0.119: v4(10.99,96.52) 11.14,96.67 v10(11.14,96.88)
  GND4 w0.119: v15(11.56,96.57) 11.04,96.57 v4(10.99,96.52)
  vias: v1(10.44,96.89) v1(10.8,96.89) v1(21.1,93.65) v1(21.1,93.29) v1(21.46,93.65) v1(21.46,93.29)
SPK_L+_L: length 512.2
  TOP w0.203: UA2.23 200.57,119.77 v10(199.57,118.78)
  GND1 w0.254: v10(199.57,118.78) v4(199.57,119.39)
  GND3 w0.254: v4(199.57,119.39) 200.21,119.39 201.23,120.4 201.23,121.15 200.89,121.48 199.94,121.48 198.28,123.15 195.87,123.15 191.83,127.19 191.83,136.56 188.03,140.36 v4(187.99,140.36)
  GND3 w0.762: 203.96,115.34 198.53,115.34 188.89,124.98 188.89,134.26 186.67,136.48 183.57,136.48 183.18,136.09 180.66,136.09 179.1,134.53 172.22,134.53 170.1,136.65 161.99,136.65 161.87,136.77 159.02,136.77 158.54,137.26 155.29,137.26 153.89,135.86 151.73,135.86 150.63,136.96 149.58,136.96 149.13,136.52 144.91,136.52 139.83,131.44 131.28,131.44 130.05,132.66 130.05,134.63 128.15,136.53 123.89,136.53 123.37,137.06 96.79,137.06 96.67,136.94 78.45,136.94 77.01,138.39 77.01,143.45 72.33,148.13 68.29,148.13 67.6,147.43 66.9,147.43 66.2,148.13 56.98,148.13 51.21,142.36 47.1,142.36 44.3,139.57 44.3,124.28 43.41,123.39 43.41,111.03 44.61,109.84 44.61,108.1 44.18,107.67 44.18,106.6 43.26,105.68 42.06,105.68 41.68,105.3
  IN3 w0.254: v6(150.15,138.13) 148.76,138.13 148.41,138.49 144.05,138.49 143.61,138.04 141.92,138.04 140.48,136.61 140.48,133.54 139.49,132.55 131.88,132.55 131.2,133.22 131.2,133.81 128.91,136.1 123.36,136.1 121.28,138.18 80.31,138.18 79.87,138.63 71.49,138.63 70.97,138.12 v6(70.97,137.9) ; v6(55.39,134.64) 54.77,134.02 52.01,134.02 47.42,129.43 47.42,128.13 48.03,127.52 48.03,125.09 44.84,121.9 44.84,120.16 46.31,118.69 46.31,110.18 44.2,108.07 44.2,106.85 43.81,106.46 42.21,106.46 v6(41.26,105.51) ; v6(187.56,140.1) 187.81,140.36 v4(187.99,140.36)
  BOTTOM w0.254: v7(26.63,93.8) 27.11,93.8 27.79,94.48 29.84,94.48 32.19,96.83 36.42,96.83 37.43,95.82 37.43,93.78 38.06,93.15 41.4,93.15 42.84,94.59 42.84,101.73 41.45,103.13 41.45,104.99 41.26,105.18 v6(41.26,105.51) ; v6(187.56,140.1) 187.56,138.64 186.64,137.71 179.48,137.71 179.2,137.99 174.38,137.99 174.29,137.9 154.15,137.9 154.12,137.93 150.35,137.93 v6(150.15,138.13) ; v6(55.39,134.64) 55.39,134.96 59.68,139.25 66.2,139.25 68.53,136.93 70.35,136.93 70.97,137.55 v6(70.97,137.9)
  BOTTOM w0.762: 25.9,93.73 25.9,94.33 26.66,95.09 29.58,95.09 31.96,97.47 36.77,97.47 38.12,96.12 38.12,94.27 38.56,93.82 40.96,93.82 42.21,95.07 42.21,101.44 40.84,102.82 40.84,103.59
  vias: v7(26.63,93.21) v7(40.81,104.87) v7(40.95,104.31) v7(204.84,115.68) v7(204.84,115.1)
SPK_L-: length 14.6
  IN1 w0.762: 20.68,91.75 20.4,91.47 14.1,91.47 13.14,92.44 10.9,92.44 9.91,93.43 9.91,95.46
  GND1 w0.119: v10(11.16,96.1) 11.16,95.84 11.04,95.73 v4(11.04,95.72)
  GND4 w0.119: v15(11.08,95.3) 11.08,95.68 v4(11.04,95.72)
  vias: v1(10.45,96.1) v1(10.8,96.09) v1(21.11,92.58) v1(21.11,92.22) v1(21.47,92.58) v1(21.47,92.22)
SPK_L-_L: length 244.8
  TOP w0.203: v10(200.59,120.11) 200.65,120.17 UA2.22
  GND1 w0.254: v10(200.59,120.11) v4(200.26,120.44)
  GND3 w0.254: v4(200.26,120.44) 200.26,120.62 198.09,122.79 195.72,122.79 191.47,127.04 191.47,136.41 188.16,139.72 v4(188.06,139.72)
  IN3 w0.254: v6(101.28,137.83) 80.16,137.83 79.72,138.27 71.63,138.27 71.37,138 v6(71.37,137.93) ; v6(141.15,135.36) 141.92,136.13 142.2,136.13 144.2,138.13 148.26,138.13 148.65,137.74 150.58,137.74 151.25,138.41 158.96,138.41 159.53,137.85 162.05,137.85 162.15,137.95 174.93,137.95 175.03,138.04 179.89,138.04 180.04,137.9 186.04,137.9 187.86,139.72 v4(188.06,139.72) ; v6(41.64,105.3) 42.42,106.09 43.94,106.09 44.25,106.4 47.17,106.4 47.56,106.78 47.56,107.44 46.8,108.19 46.8,118.7 45.19,120.31 45.19,121.7 48.38,124.88 48.38,127.67 47.77,128.28 47.77,129.28 52.15,133.66 55.09,133.66 v6(55.86,134.44)
  BOTTOM w0.254: v6(141.15,135.36) 140.95,135.16 140.95,133.66 139.57,132.28 131,132.28 129.91,133.37 129.91,135.93 128.02,137.83 v6(101.28,137.83) ; v6(55.86,134.44) 55.86,134.88 59.23,138.25 66.66,138.25 68.36,136.55 70.47,136.55 71.37,137.44 71.37,137.93 v6(71.37,137.93) ; v7(28,94.01) 29.88,94.01 32.29,96.43 36.32,96.43 37.06,95.68 37.06,93.65 37.92,92.79 41.55,92.79 43.2,94.45 43.2,101.88 41.8,103.28 41.8,105.14 v6(41.64,105.3)
SPK_R+:
  vias: v1(243.49,137.02) v1(243.49,136.67) v1(247.31,135.24) v1(247.31,134.91) v14(249.47,134.96)
SPK_R+_L: length 89.8
  TOP w0.203: UA2.26 202.78,117.22 CA116.1
  TOP w0.254: v7(201.95,116.67) 202.23,116.67 CA116.1
  BOTTOM w0.254: v7(241.81,137.8) 243.06,136.56 243.06,135.92 242.5,135.36 239.6,135.36 238.88,134.64 235.71,134.64 235.08,135.27 233.09,135.27 232.19,136.18 230.69,136.18 229.91,135.4 226.74,135.4 225.16,133.82 223.72,133.82 217.07,127.17 217.07,125.07 216.5,124.49 213.32,124.49 212.83,124.01 212.83,123.37 212.25,122.79 211.61,122.79 206.92,118.09 204.59,118.09 203.17,116.67 v7(201.95,116.67)
  BOTTOM w0.762: 240.35,137.74 236.1,137.74 235.5,137.14 230.25,137.14 229.54,136.43 226.37,136.43 224.72,134.78 223.29,134.78 213.96,125.46 212.92,125.46 212.6,125.14
  vias: v7(211.93,124.38) v7(211.94,123.82) v7(241.26,137.8)
SPK_R-:
  vias: v1(243.52,135.68) v1(243.52,135.35) v1(247.36,133.85) v1(247.36,133.55) v14(249.88,133.24)
SPK_R-_L: length 52
  TOP w0.203: UA2.25 202.38,117.68 v7(202.01,117.31)
  BOTTOM w0.254: v7(202.01,117.31) 203.26,117.31 204.4,118.45 206.7,118.45 211.39,123.14 212.1,123.14 212.48,123.52 212.48,124.15 213.17,124.85 216.35,124.85 216.72,125.22 216.72,127.32 223.57,134.17 225.01,134.17 226.6,135.76 229.76,135.76 230.54,136.53 235.76,136.53 236.35,137.13 241.38,137.13 v7(242.37,136.14)
SPKR: length 263.1
  IN1 w0.06: v3(137.9,108.4) 137.86,108.45 135.58,108.45 135.38,108.65 v1(134.9,108.65)
  IN1 w0.089: v3(11.49,80.77) 11.74,81.02 11.74,87.78 14.53,90.56 23.54,90.56 23.74,90.76 25.65,90.76 28.05,93.16 28.05,93.24 28.89,94.08 28.89,94.68 29.73,95.53 31.27,95.53 32.4,96.67 32.67,96.67 32.82,96.52 33.47,96.52 33.99,95.99 34.88,95.99 35.73,96.84 39.72,96.84 41.54,98.66 44.45,98.66 45.41,99.62 47.78,99.62 50.02,101.86 58.79,101.86 59.79,102.86 59.79,110.47 61.8,112.49 61.8,117 65.19,120.39 65.61,120.39 67.41,122.18 67.41,123.01 67.9,123.5 68.57,123.5 69.53,124.47 70.29,124.47 70.72,124.89 71.72,124.89 72.66,125.83 75.61,125.83 77.92,128.14 78.83,129.05 79.32,129.05 79.81,129.54 79.81,130.09 80.45,130.72 83.45,130.72 83.9,131.18 85.19,131.18 86.14,132.12 89.32,132.12 93.44,136.24 99.9,136.24 100.48,135.66 101.67,135.66 102.12,135.21 106.8,135.21 107.16,134.85 108.34,134.85 108.95,134.24 109.62,134.24 110.4,135.02 113,135.02 114.81,133.2 v3(114.81,132.98)
  IN2 w0.06: v3(137.9,108.4) 138.22,108.4 v4(138.31,108.49)
  IN2 w0.084: v3(11.49,80.77) 11.34,80.77 10.05,79.47 10.05,76.08 4.83,70.86 4.83,59.75 5.61,58.96 5.61,47.45 11.28,41.78 11.28,36.96 12.16,36.08 12.16,31.48 12.69,30.95 12.69,29.32 16.02,26 16.02,23.94 18.37,21.59 19.32,21.59 20.1,20.81 v2(20.1,20.23) ; v3(114.81,132.98) 114.81,132.72 115.68,131.86 v4(115.68,131.24)
  GND3 w0.119: v4(138.59,125.21) 138.45,125.36 137.36,125.36 136.66,124.66 127.29,124.66 122.48,129.47 120.94,129.47 119.59,130.82 116.6,130.82 116.44,130.98 116.2,130.98 115.94,131.24 v4(115.68,131.24)
  IN3 w0.084: v4(138.59,125.21) 138.59,123.92 138.93,123.58 139.6,123.58 139.95,123.24 139.95,121.93 139.27,121.26 139.27,119.19 138.92,118.83 138.92,118.08 138.97,118.02 138.97,116.49 137.9,115.43 137.9,112.83 139.15,111.59 139.15,109.74 138.99,109.58 138.99,108.54 v6(138.74,108.29)
  GND4 w0.119: v4(138.31,108.49) 138.51,108.29 v6(138.74,108.29)
SSD_PWR_EN: length 69.6
  TOP w0.119: R136.1 191.95,99.47 R223.2 191.28,99.33 191.08,99.14 189.53,99.14 v1(189.53,99.13)
  IN1 w0.06: v2(133.42,104.79) 133.49,104.86 133.7,104.86 133.94,105.1 133.94,105.19 134.07,105.32 134.24,105.32 134.37,105.19 134.45,105.19 134.57,105.31 134.73,105.31 134.81,105.24 134.81,105.24 134.82,105.23 135.91,105.23 136.15,104.99 137.61,104.99 137.7,105.09 138.16,105.09 138.46,104.78 138.46,104.25 139.05,103.67 139.45,103.67 139.64,103.85 139.91,103.85 140.02,103.74 140.06,103.74
  IN1 w0.089: v1(189.53,99.13) 189.29,99.13 188.56,98.4 186.75,98.4 186.19,97.83 176.63,97.83 176.34,98.12 164.44,98.12 163.57,97.25 162.15,97.25 161.84,97.56 156.53,97.56 155.92,98.17 152.76,98.17 152.16,98.76 151.19,98.76 150.93,98.51 150.25,98.51 150.15,98.61 149.65,98.61 149.17,99.09 149.17,99.87 148.19,100.85 148.19,101.33 147.68,101.84 147.25,101.84 145.82,103.26 145.82,105.14 144.33,106.64 144.18,106.64 143.99,106.83 142.59,106.83 142.51,106.75 142.06,106.75 140.96,105.66 140.96,105.33 140.82,105.19 140.82,104.02 140.54,103.74 140.06,103.74
SSD_RST#: length 79.7
  TOP w0.119: U712.2 195.31,104.91 195.69,105.29 195.69,108.57 194.14,110.12 v7(194.14,110.55)
  IN2 w0.06: v2(132.68,105.11) 132.89,105.11 133.09,105.31 133.1,105.31 133.1,105.31 133.26,105.31 133.34,105.23 133.79,105.23 134.12,105.56 134.94,105.56 135.1,105.72 136.52,105.72 136.57,105.67 138.07,105.67 138.17,105.77 138.79,105.77 138.84,105.72 139.32,105.72 139.48,105.89 139.52,105.89 139.81,106.17
  IN2 w0.084: v7(194.14,110.55) 193.73,110.55 190.71,107.54 190.71,105.17 189.23,103.69 183.27,103.69 182.74,103.16 177.85,103.16 176.85,104.16 173.25,104.16 172.53,103.44 168.82,103.44 168.5,103.12 166.21,103.12 164.88,101.79 v2(163.57,101.79) 163.4,101.79 162.74,101.13 156.72,101.13 156.44,100.85 156.44,100.8 156.01,100.36 153.57,100.36 152.49,101.45 151.94,101.45 151.69,101.69 148.88,101.69 146.21,104.36 146.21,105.52 144.28,107.45 141.91,107.45 140.63,106.17 139.81,106.17
SSD_RST#_Q: length 12
  TOP w0.076: JNGFF2.50 200.93,95.98
  TOP w0.14: U712.4 194.66,102.16 195.35,101.47 R1032.1 195.46,101.38 v7(195.84,101) ; v10(200.49,98.06) 200.49,96.29 200.8,95.98 200.93,95.98
  GND1 w0.084: v4(200.49,98.48) v10(200.49,98.06)
  GND4 w0.084: v9(200.49,98.86) v4(200.49,98.48)
  BOTTOM w0.14: v7(195.84,101) v14(196.65,100.19) 197.19,99.65 198.87,99.65 199.65,98.86 v9(200.49,98.86)
STROBE_IN: length 2.7
  IN2 w0.084: v2(197.11,144.08) 196.73,143.7 195.99,143.7 195.66,143.37 195.66,142.79 v2(195.37,142.5)
SUS_PWR_DN: length 11.2
  TOP w0.119: RH114.2 143.21,112.9 RH59.2 143.03,112.38 RH62.1 142.35,112.34 v1(141.66,111.65)
  IN1 w0.06: 139.81,111.56 139.62,111.56 139.12,111.07 137.67,111.07 137.49,111.25 136.93,111.25 136.62,110.94 135.88,110.94 135.41,111.42 134.83,111.42 134.67,111.57 134.35,111.57 134.13,111.79 v1(134.13,111.79)
  IN1 w0.089: 139.81,111.56 141.46,111.56 141.54,111.65 v1(141.66,111.65)
SUSACK#: length 126.1
  TOP w0.119: RH60.1 144.63,111.54 T30.1 144.76,111.9 v1(144.58,112.07)
  IN1 w0.089: v1(230.81,126.75) 229.81,126.75 228.05,128.51 228.05,130.21 227.39,130.87 227.39,133.42 226.37,134.44 223.74,134.44 223.58,134.27 v5(214.94,134.27) ; v5(215.69,123.46) 215.69,123.34 214.8,122.45 213.58,122.45 212.63,121.5 211.77,121.5 210.98,120.72 208.92,120.72 205.96,117.76 204.6,117.76 203.09,116.25 203.09,116.18 201.04,114.13 198.24,114.13 196.22,112.1 196.22,110.65 193.66,108.09 193.66,106.72 192.73,105.79 192.73,104.9 192.21,104.37 192.21,103.87 191.32,102.99 191.32,102.73 191.01,102.42 190.52,102.42 189.52,101.42 188.48,101.42 188.27,101.2 185.48,101.2 185.01,100.74 183.82,100.74 183.52,100.44 181.35,100.44 180.91,100.88 179.89,100.88 179.45,101.32 167.43,101.32 167.15,101.05 164.04,101.05 163.84,100.85 159.17,100.85 158.82,101.2 157.05,101.2 156.81,100.96 155.36,100.96 154.9,101.42 153.84,101.42 151.36,103.9 151.19,103.9 149.75,105.34 149.75,107.85 149.44,108.16 149.44,108.79 146.66,111.56 146,111.56 145.49,112.07 v1(144.58,112.07)
  GND1 w0.119: v5(214.94,134.27) 214.86,134.2 v4(214.48,134.2) ; v5(215.69,123.46) 215.68,123.48 v4(215.68,124.14)
  IN3 w0.084: v4(215.68,124.14) 215.7,124.16 215.7,125.59 215.35,125.94 214.79,125.94 214.36,126.37 214.36,126.65 215.11,127.41 215.11,129.09 214.64,129.57 214.64,134.04 v4(214.48,134.2)
SUSACK#_R: length 10.6
  TOP w0.119: RH60.2 142.42,111.54 RH62.2 141.98,111.1 v1(141.87,111.1)
  IN1 w0.06: v1(133.42,110.59) 133.5,110.67 133.72,110.67 134.09,111.04 134.82,111.04 134.9,111.13 135.36,111.13 135.78,110.7 137.27,110.7 137.37,110.81 140.41,110.81
  IN1 w0.089: v1(141.87,111.1) 141.78,111.18 140.82,111.18 140.45,110.81 140.41,110.81
SUSCLK: length 332.9
  TOP w0.119: v2(243.48,122.45) 243.48,122.73 243.05,123.16 C74.1 R40.2 ; v1(144.34,119.54) 144.34,118.87 MC1.2 RH76.2 ; v10(193.69,109.49) 194.05,109.49 195.19,108.36 195.19,106.63 C200.1 195.19,106.54 195.19,105.74 R59.2 ; v2(15.37,100.12) 15.34,100.16 R64.2 14.71,99.86 C171.1
  IN1 w0.089: v3(145.19,128.53) 145.14,128.48 145.14,123.96 145.52,123.58 145.52,121.32 144.62,120.42 144.62,120.06 144.34,119.78 v1(144.34,119.54) 144.52,119.54 144.89,119.91 145.61,119.91 145.93,119.59 147.73,119.59 149.64,117.68 151.02,117.68 152.08,116.62 152.08,116.01 154.08,114 162.92,114 163.1,114.18 164.27,114.18 166.25,112.2 166.77,112.2 169.56,109.41 170.16,109.41 171.58,107.98 173.01,107.98 173.48,107.52 175.39,107.52 175.65,107.25 177.75,107.25 178.89,108.39 185.33,108.39 187.5,110.55 187.5,114.89 190.77,118.16 v5(190.77,119.26) 191.32,119.26 192.44,120.38 192.44,121.05 192.71,121.32 192.71,122.41 195.51,125.2 197.62,125.2 198.38,125.97 202.44,125.97 203.75,127.27 204.68,127.27 205.42,128.02 205.42,128.58 206.5,129.66 207.06,129.66 210.32,132.91 210.63,132.91 213.5,135.78 217.94,135.78 218.52,135.2 228.09,135.2 230.23,133.06 230.23,132.38 230.82,131.79 230.82,130.26 231.02,130.06 233.18,130.06 234.93,131.81 v7(235.67,131.81)
  GND1 w0.119: v10(193.69,109.49) 193.63,109.56 193.25,109.56 v4(193.22,109.53) ; v4(190.07,119.31) 190.72,119.31 v5(190.77,119.26)
  IN2 w0.084: v3(145.19,128.53) 144.85,128.53 144.56,128.24 142.21,128.24 140.97,129.48 139.44,129.48 139,129.04 138.01,129.04 136.4,130.65 132.17,130.65 128.92,133.9 125.01,133.9 124.87,134.04 120.29,134.04 119.73,133.48 119.73,129.76 119.3,129.33 118.18,129.33 116.07,127.22 109.44,127.22 108.28,126.06 104.16,126.06 103.22,125.11 100.89,125.11 100.47,125.52 99,125.52 95.76,128.76 87.64,128.76 87.08,129.32 83.92,129.32 82.54,127.94 79.49,127.94 74.61,123.05 74.14,123.05 73.05,121.96 71.09,121.96 70.73,121.6 69.77,121.6 63.61,115.44 63.61,111.41 60.15,107.96 60.15,107.07 60.66,106.56 60.66,106.45 61.6,105.51 61.6,102.25 61.3,101.95 52.72,101.95 52.51,102.15 48.21,102.15 46.47,103.89 45.84,103.89 45.1,103.15 43.91,103.15 41.28,100.52 40.66,100.52 40.2,100.05 36.81,100.05 35.77,101.1 32.21,101.1 31.91,100.8 30.3,100.8 30.12,100.97 28.12,100.97 27.11,99.96 24.99,99.96 24.61,100.34 24.36,100.34 23.78,100.92 23.78,101.29 23.34,101.74 22.33,101.74 22.03,101.43 22.03,100.86 20.43,99.26 17.93,99.26 17.41,99.79 17.41,100.15 16.9,100.66 16.12,100.66 15.75,100.29 15.54,100.29 v2(15.37,100.12) ; v4(244.88,125.33) 244.88,123.85 v2(243.48,122.45)
  IN3 w0.076: v4(190.07,119.31) 190.07,116.87 191.14,115.81 191.14,112.25 193.22,110.17 v4(193.22,109.53)
  IN3 w0.084: v7(235.67,131.81) 235.86,131.62 239.58,131.62 240.53,130.67 241.57,130.67 244.36,127.87 244.36,125.85 v4(244.88,125.33)
SUSCLK_L: length 5.4
  TOP w0.119: JNGFF1.60 15.5,103.87 14.64,103.87 13.98,103.21 13.98,101.43 14.66,100.74 R64.1
SW4: length 8.9
  TOP w0.254: v7(164.57,122.72) 164.65,122.79 165.58,122.79 PU500.K1
  TOP w0.508: v7(164.12,119.26) 164.12,117.97 PC506.2 163.88,117.91 162.93,116.97 162.93,116.91 ; PQ500.9 162.93,116.78
  IN3 w0.508: v7(164.12,119.26) 164.12,119.21 164.01,119.31 164.01,121.78 164.57,122.34 v7(164.57,122.72)
SW5: length 14.5
  IN2 w0.254: v4(170.64,127.8) 170.52,127.92 168.81,127.92 168.29,127.4 168.29,127.04 168.03,126.78 168.03,126.44 v2(167.99,126.4)
  IN3 w0.508: v7(180.83,129.19) 180.3,128.66 176.92,128.66 176.18,127.92 170.77,127.92 v4(170.64,127.8)
SW6: length 14.9
  TOP w0.254: PU500.K14 170.81,122.82 172.01,122.82 v10(172.21,123.01)
  GND1 w0.254: v4(172.6,123.05) 172.57,123.01 v10(172.21,123.01)
  IN3 w0.508: v6(176.26,116.21) 176.26,117.17 173.77,119.66 173.77,121.88 v4(172.6,123.05)
  BOTTOM w0.508: v6(176.26,116.21) 179.18,116.21 179.51,115.88 v7(180.75,115.88)
SW7: length 8.1
  TOP w0.254: PU500.D13 PU500.D14 171.07,125.2 v10(171.44,125.57)
  GND1 w0.254: v10(171.44,125.57) 171.72,125.57 v4(171.86,125.71)
  GND4 w0.508: v4(171.86,125.71) v9(172.4,125.71)
  BOTTOM w0.762: v9(172.4,125.71) 176.69,125.71 v7(177.78,124.62)
SW8: length 10.1
  TOP w0.254: PU500.B4 PU500.A4 166.79,126.47 166.35,126.91 165.81,126.91 165.51,127.21
  TOP w0.508: 165.51,127.21 164.88,127.21 v7(164.55,127.54) 164.55,127.82 PC524.2
  IN3 w0.508: v7(164.55,127.54) 164.55,128.15
  IN3 w0.762: v7(164.73,133.56) 164.73,130.36 164.55,130.18 164.55,128.15
