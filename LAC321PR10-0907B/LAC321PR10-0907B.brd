# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPP_F0: length 3.6
  IN2 w0.06: v4(135.59,108.59) 135.5,108.59 134.85,107.94 134.65,107.94 134.59,107.89 133.59,107.89 133.51,107.81 133.13,107.81 v2(132.93,108.01)
  IN3 w0.084: v4(135.59,108.59) 135.79,108.8 v6(136,108.8)
GPP_F1: length 4.3
  IN2 w0.06: v2(132.44,108.02) 132.64,108.02 132.96,107.69 133.56,107.69 133.64,107.77 134.64,107.77 134.7,107.83 134.9,107.83 135.27,108.2 v4(135.92,108.2)
  IN3 w0.084: v4(135.92,108.2) 136.09,108.36 v6(136.33,108.36)
GPP_F2: length 3.6
  IN2 w0.06: v2(132.93,107.37) 133.13,107.57 134.61,107.57 134.75,107.71 135.97,107.71 v4(136,107.68)
  GND4 w0.119: v9(135.59,107.63) 135.64,107.68 v4(136,107.68)
GPP_F3: length 13.2
  IN1 w0.06: 142.09,108.38 141.45,108.38 141.11,108.03 139.97,108.03 139.84,107.91 139.41,107.91 138.96,107.45 136.93,107.45 136.87,107.39 136.42,107.39 136.28,107.53 135.47,107.53 135.19,107.81 134.61,107.81 v1(134.41,108.01)
  IN1 w0.089: 142.09,108.38 144.76,108.38 145.88,107.26 v1(146.48,107.26)
GPP_F23: length 7.8
  TOP w0.119: v2(140.06,106.79) 140.35,107.08 TC163.1
  IN2 w0.06: v2(133.67,105.76) 134.07,106.15 134.25,106.15 134.45,106.36 135.32,106.36 135.78,105.9 136.21,105.9 136.58,106.27 137.47,106.27 137.67,106.07 139.29,106.07 140.01,106.79
  IN2 w0.084: v2(140.06,106.79) 140.01,106.79
GTDRVL1_1: length 6.6
  TOP w0.508: PR901.2 85.71,117.84 v7(85.35,118.19) ; PQ900.8 v7(82.29,121.94)
  IN2 w0.508: v7(82.29,121.94) 82.29,121.25 v7(85.35,118.19)
GTSW1: length 13.6
  TOP w0.254: PL902.1 88.75,120.05 89.21,120.51 89.21,121.87 90.18,122.84 PR903.1 ; PU901.7 83.79,118.14 83.98,118.32 v7(84.16,118.32)
  TOP w0.508: PC901.2 82.28,117.13 v7(82.15,117.25)
  IN2 w0.508: v7(82.15,117.25) 83.17,118.28 84.11,118.28 v7(84.16,118.32)
  IN3 w0.508: v7(84.16,118.32) 84.13,118.35 84.13,118.78 85.6,120.25 v7(85.6,120.99)
GYRO_DRDY: length 8.2
  TOP w0.119: R112.1 229.61,110.52 229.61,107.41 228.96,106.76 U20.13
GYRO_I2C_ADD_SEL: length 5.3
  TOP w0.119: U20.5 218.39,107.44 218.08,107.75 R109.1 R103.2
GYRO_INT: length 8.2
  TOP w0.119: U20.10 224.39,106.13 224.69,105.83 228.96,105.83 230.73,107.59 DH6.1
H_CATERR: length 2
  IN2 w0.06: v4(121.04,97.98) 120.99,98.03 120.99,99.29 v2(120.95,99.32)
  GND4 w0.119: v9(121.19,97.47) 121.19,97.82 v4(121.04,97.98)
H_CPUPWRGD_R: length 4.2
  TOP w0.06: UC1.A62 117.25,97.42 116.72,96.88 116.36,96.88
  TOP w0.112: 116.36,96.88 116.29,96.88 116.24,96.83 115.27,96.83 v2(114.97,96.53)
  IN2 w0.06: v4(115.25,96.17) 115.25,96.21 114.97,96.49 v2(114.97,96.53)
  IN3 w0.076: v6(115.08,96.53) 115.08,96.34 v4(115.25,96.17)
  BOTTOM w0.112: RH54.2 115.26,96.71 v6(115.08,96.53)
H_PECI: length 229.5
  TOP w0.119: R172.2 237.84,120.8 237.32,121.32 v2(236.9,121.32)
  IN1 w0.06: v1(120.95,98.83) 120.95,98.78 120.86,98.69 120.86,98.52 120.66,98.33 120.59,98.33 120.43,98.17 120.43,98.01 120.51,97.92 120.51,97.75 120.12,97.36 119.72,97.36 119.38,97.02 119.38,96.93 118.95,96.5 118.62,96.5 118.21,96.1 117.25,96.1 116.9,96.45 116.47,96.45
  IN1 w0.089: v5(107.98,101.99) 107.55,101.99 107.29,101.72 107.29,101.38 106.33,100.43 106.33,99.35 106.8,98.88 107.62,98.88 107.91,98.59 110.04,98.59 110.42,98.2 113.54,98.2 113.87,97.87 113.87,97.44 114.08,97.24 115.03,97.24 115.54,96.74 116.18,96.74 116.47,96.45
  GND1 w0.119: v5(107.98,101.99) 108.03,102.04 v4(108.03,102.4)
  IN2 w0.084: v4(110.39,125.99) 110.41,126.01 116.6,126.01 120.11,129.53 120.11,130.68 v4(121.61,132.18) ; v2(236.9,121.32) 236.95,121.37 236.95,123.49 238.87,125.41 240.42,125.41 240.9,125.88 240.9,130.27 239.13,132.04 237.99,132.04 236.65,133.37 235.14,133.37 234.09,134.42 233.17,134.42 232.39,135.2 232.39,140.35 231.6,141.14 v4(231.49,141.14)
  IN3 w0.084: v4(110.39,125.99) 110.34,125.99 109.84,125.48 105.31,125.48 104.22,124.39 102.71,124.39 101.07,122.75 101.07,118.52 100.76,118.21 100.76,110.56 104.74,106.57 106.69,106.57 107.78,105.48 107.78,102.66 v4(108.03,102.4) ; v4(121.61,132.18) 121.95,132.18 124.65,129.48 137.04,129.48 137.88,130.32 140.14,130.32 142.44,132.62 142.44,132.94 144.88,135.39 149.11,135.39 149.24,135.52 150.27,135.52 150.68,135.94 154.38,135.94 155.43,136.99 158.33,136.99 159.16,136.17 159.21,136.17 159.7,135.67 160.69,135.67 161.22,136.2 163.68,136.2 164,136.52 172.29,136.52 173.98,134.83 176.13,134.83 176.36,135.06 177.81,135.06 180.09,137.34 187.08,137.34 189.24,139.5 189.24,141.45 191.17,143.38 191.17,144.59 191.75,145.18 191.75,145.83 193.45,147.53 198.96,147.53 199.88,148.45 226.22,148.45 227.81,146.86 228.15,146.86 229.18,145.83 229.18,143.45 v4(231.49,141.14)
H_PROCHOT#: length 389
  TOP w0.112: RC8.1 RC13.2 120.12,92.69 v2(119.69,93.12) ; v10(186.77,119.67) 186.42,119.31 PR715.2 ; PR800.2 PR837.2 65.51,111.79 64.65,110.93 64.65,110.14 v2(64.88,109.91) ; v7(216.55,121.5) 217.14,120.91 223.81,120.91 225.8,118.92 225.8,116.12 226.45,115.48 R1217.2
  GND1 w0.076: v10(186.77,119.67) 186.77,119.92 v4(186.98,120.12)
  IN2 w0.066: v4(68.33,105.93) 68.43,106.03 69.17,106.03 69.53,105.67 69.53,105.29 70.39,104.43 72.35,104.43 73.39,103.39 79.25,103.39 80.04,102.6 91.13,102.6 95.47,98.26 96.15,98.26 97.68,96.73 99.02,96.73 99.44,96.31 100.57,96.31 102.04,94.84 104.23,94.84 104.96,94.84 105.03,94.9 106.1,94.9 108.11,92.89 108.11,91.57 108.81,90.87 108.82,90.86 109.63,90.86 110.06,90.43 112.85,90.43 113.15,90.13 113.68,90.13 114.26,90.72 114.72,90.72 114.96,90.97 115.56,90.97 115.75,91.15 116.36,91.15 118.08,92.87 118.7,92.87 118.98,93.15 119.67,93.15 v2(119.69,93.12) ; v4(64.86,109.5) 64.88,109.52 v2(64.88,109.91) 63.29,109.91 61.17,107.79 61.17,106.62 62.09,105.71 62.09,102.05 61.5,101.47 52.32,101.47 52.14,101.65 47.02,101.65 46.67,102 46.67,102.57 v4(46.82,102.73) ; v2(50.2,127.92) 50.96,128.68 v4(51.39,128.68) ; v4(150.13,135.96) 150.13,135.61 150.48,135.26 154.93,135.26 156.3,136.64 157.04,136.64 157.71,135.97 157.71,135.23 157.93,135.01 158.76,135.01 158.87,135.13 160.54,135.13 161.27,135.86 161.78,135.86 162.05,136.13 163.25,136.13 163.36,136.02 172.94,136.02 173.58,135.38 179.54,135.38 180.21,136.05 182.88,136.05 183.56,136.72 188.3,136.72 189,137.42 189,138.56 188.67,138.89 188.67,142.17 192.3,145.8 v4(196.09,145.8) 196.26,145.64 200.59,145.64 200.73,145.78 204.5,145.78 205.29,144.99 v4(209.56,144.99)
  IN3 w0.076: v4(68.33,105.93) 67.85,105.44 65.64,105.44 65.13,105.95 65.13,109.23 v4(64.86,109.5) ; v4(46.82,102.73) 46.98,102.56 51.24,102.56 51.75,103.07 51.75,113.47 52.85,114.57 52.85,118.73 55.2,121.08 55.2,122.4 54.73,122.87 52.81,122.87 51.12,124.55 51.12,128.42 v4(51.39,128.68) 51.39,128.81 53.34,130.76 57.11,130.76 58.64,132.3 75.4,132.3 77.37,134.27 85.46,134.27 85.96,134.77 89.09,134.77 89.85,135.52 95.25,135.52 95.44,135.33 97.39,135.33 97.96,135.9 102.56,135.9 103.36,136.7 110.93,136.7 113.05,134.58 114.74,134.58 115.75,133.56 117.57,133.56 118.26,132.87 120.77,132.87 121.1,132.53 122,132.53 124.77,129.76 136.92,129.76 137.77,130.61 140.03,130.61 142.14,132.73 142.14,133.05 144.76,135.67 148.99,135.67 149.26,135.94 150.12,135.94 v4(150.13,135.96) ; v4(196.09,145.8) 194.62,145.8 192.61,143.8 192.61,142.76 191.81,141.96 191.81,137.16 189.8,135.14 189.8,132.19 190.14,131.84 190.14,125 186.98,121.84 v4(186.98,120.12) ; v7(216.55,121.5) 216.49,121.56 216.49,124.47 217.03,125.01 217.03,125.72 216.53,126.22 216.53,130.75 215.46,131.82 215.46,136.74 213.58,138.62 213.58,139.88 209.56,143.9 v4(209.56,144.99)
H_PROCHOT#_R: length 7.7
  TOP w0.112: v1(119.94,96.87) 120.05,96.76 120.05,96.38 120.22,96.2 120.22,94.2 120.42,94.01 120.78,94.01 121.01,93.78 RC8.2
  IN1 w0.06: v1(121.28,99.57) 121.28,99.36 121.05,99.13 121.05,99.01 121.19,98.87 121.19,98.78 121.04,98.63 121.04,98.54 121.19,98.38 121.19,98.29 120.96,98.05 120.96,97.51 120.88,97.44 120.76,97.44 120.55,97.24 120.55,97.11 120.43,96.99 120.06,96.99 v1(119.94,96.87)
H_THERMTRIP#: length 4.9
  TOP w0.112: v2(120.38,96.5) 120.55,96.32 120.55,95.59 R90.2
  IN2 w0.06: v2(120.38,96.5) 120.33,96.5 120.43,96.6 120.71,96.6 121.47,97.37 121.47,98.56 121.4,98.63 121.4,98.91 121.6,99.11 v2(121.6,99.32)
H_VCCST_PWRGD: length 7.8
  TOP w0.119: RC79.2 113.14,95.54 T23.1 114.23,96.63 v1(114.23,97.51)
  IN1 w0.06: v1(117.63,98) 117.63,97.84 117.13,97.34 116.15,97.34 115.84,97.64 115.84,98.05 115.72,98.18 115.13,98.18 115.02,98.29 114.31,98.29 114.18,98.17 114.18,97.56 v1(114.23,97.51)
H_VCCST_PWRGD_R: length 179.2
  TOP w0.119: RC79.1 111.5,94.99 RH66.2 111.19,94.99 v2(110.75,94.55)
  IN1 w0.06: 168.46,119.92 168.46,120.33 167.79,121 167.79,122.6 v1(167.59,122.8)
  IN1 w0.089: v8(172.9,111.59) 172.9,112.15 171.33,113.72 169.27,113.72 168.69,114.31 168.69,119.41 168.46,119.64 168.46,119.92 ; v3(100.34,98.43) 99.92,98.01 98.22,98.01 96.42,96.22 96.42,92.15 96.53,92.05 96.53,88.92 98.44,87 98.88,87 99.68,86.2 102.75,86.2 102.95,86.41 104.15,86.41 104.92,85.64 105.68,85.64 107.91,83.41 120.31,83.41 121.34,82.38 121.34,82.08 121.88,81.54 123.35,81.54 125.15,83.35 126.28,83.35 126.73,82.9 127.44,82.9 128.18,82.16 134.29,82.16 136.44,84.31 136.44,85.65 142.31,91.52 147.71,91.52 147.99,91.8 150.73,91.8 150.82,91.71 154.64,91.71 154.87,91.48 158.87,91.48 159.16,91.19 161.07,91.19 161.96,90.31 163.15,90.31 163.87,89.58 164.3,89.58 165.46,88.42 165.46,88.29 165.69,88.06 166.49,88.06 v3(166.58,88.15)
  GND1 w0.119: v8(172.9,111.59) 173.18,111.31 173.18,111.26 v4(173.21,111.23)
  IN2 w0.084: v2(110.75,94.55) 110.45,94.24 109.45,94.24 107.48,96.22 107.48,96.9 107.48,97.26 106.69,98.05 106.61,98.05 106.6,98.06 104.03,98.06 103.85,98.24 100.53,98.24 v3(100.34,98.43) ; v3(166.58,88.15) 167.34,88.15 168.79,86.7 183.08,86.7 191.4,95.02 v4(191.4,96.49)
  IN3 w0.084: v4(173.21,111.23) 173.18,111.21 173.18,110.29 176.61,106.87 176.61,106.05 177.57,105.1 180.74,105.1 182.6,103.23 184.21,103.23 187.33,100.11 187.33,99.47 189.03,97.78 190.27,97.78 191.4,96.66 v4(191.4,96.49)
HDA_BIT_CLK: length 15.5
  TOP w0.152: RH109.2 138.66,121.74 138.66,121.81 138.56,121.92 v1(138.56,121.98)
  IN1 w0.06: v1(130.94,111.64) 130.94,112.02 131.14,112.22 131.14,112.32 131.48,112.66 131.51,112.66 133.54,114.69 135.8,114.69 137.99,116.89 137.99,117.28
  IN1 w0.089: 137.99,117.28 138.11,117.39 138.11,118.7 138.28,118.88 138.28,121.7 v1(138.56,121.98)
HDA_BIT_CLK_L: length 233.5
  TOP w0.152: UA1.13 27.31,22.9 v1(27.16,23.05) ; RH109.1 139.52,121.69 139.19,122.02 CH40.1 138.87,122.37 138.87,122.97 139.12,123.22 v10(139.15,123.22)
  IN1 w0.089: v5(113.88,130.23) 113.88,129.51 113.48,129.1 111.68,129.1 111.42,129.36 111.42,130.22 111.19,130.45 111.19,131.49 109.99,132.69 105.7,132.69 105.57,132.82 104.79,132.82 104.51,133.1 104.27,133.1 103.71,133.66 101.47,133.66 101.02,134.11 99.79,134.11 99.21,134.69 96.53,134.69 96.18,134.35 95.86,134.35 94.88,133.37 94.88,132.31 94.61,132.04 93.33,132.04 93.2,131.91 93.2,131.73 93.33,131.61 94.62,131.61 94.75,131.48 94.75,130.94 93.95,130.15 91.46,130.15 91.05,129.73 87.66,129.73 86.42,128.49 85.78,128.49 85.13,127.84 80.84,127.84 77.44,124.44 76.45,124.44 75.9,123.89 74.39,123.89 72.85,122.35 72.45,122.35 70.71,120.61 69.17,120.61 65.88,117.31 65.64,117.31 63.75,115.42 63.75,111.7 62.58,110.53 62.58,102.02 59.66,99.11 50.23,99.11 48.14,97.01 46.99,97.01 46.25,96.27 42.73,96.27 41.09,94.63 40.5,94.63 34.81,88.94 34.05,88.94 33.39,88.28 33.39,84.33 31.97,82.9 31.97,77.96 31.08,77.07 31.08,76.68 30.23,75.82 30.23,64.35 30.47,64.11 30.47,63.98 30.23,63.74 30.23,63.59 30.33,63.49 30.48,63.49 30.72,63.73 30.85,63.73 31.48,63.1 31.48,62.98 31.06,62.56 31.06,62.41 31.16,62.31 31.31,62.31 31.73,62.73 31.85,62.73 31.98,62.6 31.98,62.48 31.56,62.06 31.56,61.91 31.67,61.81 31.81,61.81 32.23,62.22 32.36,62.22 32.63,61.95 32.63,55.27 33.71,54.19 33.71,51.19 34.06,50.85 34.06,44.08 34.4,43.74 34.4,42.2 34.65,41.94 34.65,41.49 34.57,41.42 34.15,41.42 34.05,41.31 34.05,41.16 34.15,41.06 34.64,41.06 34.68,41.02 34.68,40.75 34.64,40.7 33.44,40.7 33.34,40.6 33.34,40.45 33.44,40.35 34.64,40.35 34.69,40.3 34.69,40.05 34.6,39.96 33,39.96 32.89,39.85 32.89,39.7 33,39.59 34.19,39.59 34.29,39.49 34.29,39.35 34.19,39.25 32.96,39.25 32.85,39.14 32.85,38.99 32.91,38.94 32.91,34.19 32.52,33.81 32.52,29.92 31.01,28.42 30.77,28.42 30.46,28.11 30.46,26.82 29.84,26.2 29.84,25.86 28.1,24.13 26.22,24.13 26.12,24.02 26.12,23.87 26.22,23.77 27.27,23.77 27.36,23.68 27.36,23.49 27.16,23.29 v1(27.16,23.05)
  GND1 w0.089: v4(114.23,130.54) 114.2,130.54 v5(113.88,130.23) ; v10(139.15,123.22) v4(139.15,123.93)
  GND3 w0.084: v4(114.23,130.54) 114.74,130.54 115.47,129.8 115.47,129.14 116.12,128.49 116.51,128.49 117.05,127.95 121.74,127.95 127,122.69 137.49,122.69 138.73,123.93 v4(139.15,123.93)
HDA_RST#: length 27
  TOP w0.152: RH110.2 139.01,129.17 139.26,128.91 139.26,128.35 138.91,128 138.91,126.63 v1(138.72,126.44)
  IN1 w0.06: v1(130.62,111.89) 130.86,112.13 131.01,112.28 131.01,112.35 131.44,112.78 131.47,112.78 133.49,114.81 135.74,114.81 137.46,116.54 137.46,117.42
  IN1 w0.084: 138.41,122.97 138,122.97 137.62,122.59 137.62,118.42 137.46,118.26 137.46,117.42
  IN1 w0.089: v1(138.72,126.44) 138.45,126.17 138.45,126.06 138.53,125.98 139.4,125.98 139.48,125.9 139.48,124.89 139.4,124.81 139.07,124.81 139,124.89 139,125.45 138.91,125.53 138.5,125.53 138.45,125.48 138.45,124.93 138.36,124.85 138.23,124.85 138.14,124.76 138.14,124.34 138.23,124.25 138.72,124.25 138.8,124.16 138.8,123.08 138.69,122.97 138.41,122.97
HDA_RST#_L: length 221.9
  TOP w0.152: v1(25.24,21.43) 25.24,22.33 24.42,23.15 23.6,23.15 23.44,23.31 RA77.1 ; RH110.1 CH39.1 138.25,128.29 138.37,128.16 v1(138.37,127.74)
  IN1 w0.089: v1(138.37,127.74) 138.3,127.67 138.07,127.67 138.06,127.65 136.27,127.65 134.4,129.52 133.04,129.52 132.58,129.98 132.55,129.98 v3(132.54,129.98) ; v3(120.2,132.71) 120.06,132.57 116.26,132.57 116.19,132.49 115.2,132.49 114.61,131.91 113.9,131.91 113.2,131.21 113.2,130.1 112.94,129.85 112.43,129.85 112.2,130.08 112.2,131.45 110.28,133.38 108.59,133.38 107.98,133.99 105.59,133.99 105.39,133.79 104.55,133.79 104,134.35 101.76,134.35 101.31,134.8 100.08,134.8 99.49,135.38 93.88,135.38 89.74,131.25 87.02,131.25 86.09,130.31 84.26,130.31 82.89,128.94 81.57,128.94 81.15,128.53 80.56,128.53 77.15,125.12 76.16,125.12 75.62,124.58 74.11,124.58 72.56,123.03 72.17,123.03 71.89,122.75 70.35,122.75 65.59,118 65.36,118 63.06,115.7 63.06,111.98 61.89,110.82 61.89,102.31 59.48,99.89 49.88,99.89 48.11,98.12 47.13,98.12 45.97,96.96 41.98,96.96 40.33,95.32 39.51,95.32 35.12,90.93 34.18,90.93 32.16,88.91 32.16,88.22 31.73,87.79 31.73,83.63 31.28,83.19 31.28,78.76 29.54,77.02 29.54,73.56 29.17,73.19 28.81,73.19 28.65,73.03 28.65,69.6 29.54,68.71 29.54,62.96 31.95,60.56 31.95,54.98 32.96,53.97 32.96,50.75 33.24,50.46 33.24,43.92 33.71,43.46 33.71,42.13 32.86,41.28 32.44,41.28 31.96,40.8 31.96,40.05 31.28,39.37 31.28,36.81 31.5,36.59 31.5,35.86 31.72,35.64 31.72,30.09 30.73,29.1 30.44,29.1 29.23,27.89 29.23,26.72 28.3,25.79 26.23,25.79 25.42,24.98 25.42,24.24 25.24,24.06 v1(25.24,21.43)
  IN2 w0.084: v3(132.54,129.98) 132.29,129.98 130.66,131.61 128.91,131.61 128.52,132 128.52,132.13 128.24,132.41 127.23,132.41 126.9,132.08 124.96,132.08 124.32,132.72 121.72,132.72 121.54,132.53 120.38,132.53 v3(120.2,132.71)
HDA_RST#_L_R: length 3.1
  TOP w0.119: UA1.15 25.96,21.99 24.42,23.53 RA77.2
HDA_SDI0: length 247.5
  IN1 w0.06: 139.59,117.47 139.59,117.04 138.92,116.37 138.38,116.37 136.22,114.21 133.74,114.21 131.99,112.46 131.99,111.98 v1(131.9,111.89)
  IN1 w0.089: v8(141.15,123.69) 141.15,123.88 141.7,124.43 143.19,124.43 143.63,123.98 143.63,122.81 142.85,122.02 142.36,122.02 141.48,121.15 139.76,121.15 139.59,120.98 139.59,117.47 ; v1(23.44,22.77) 23.44,23.11 24.44,24.11 24.44,25.36 25.3,26.22 28.12,26.22 28.45,26.55 28.45,28.77 29.28,29.59 30.35,29.59 30.86,30.1 30.86,30.61 30.95,30.7 30.95,31.97 31.23,32.25 31.23,35.52 31.07,35.68 31.07,36.41 30.85,36.63 30.85,39.59 31.52,40.25 31.52,41.2 33.28,42.96 33.28,43.28 32.81,43.74 32.81,50.29 32.53,50.57 32.53,53.79 31.08,55.23 31.08,59.36 28.14,62.3 28.14,73.13 28.4,73.39 28.4,75.3 29.11,76.01 29.11,77.2 30.01,78.1 30.01,79.7 30.85,80.54 30.85,83.37 31.29,83.81 31.29,87.97 31.69,88.36 31.69,89.05 34,91.37 34.94,91.37 37.39,93.81 37.39,94.72 38.72,96.05 40.14,96.05 41.7,97.61 44.24,97.61 45.44,98.81 47.88,98.81 49.7,100.63 59.26,100.63 61.23,102.6 61.23,111.07 62.41,112.25 62.41,116.64 64.81,119.05 65.3,119.05 65.68,119.42 65.68,119.61 69.47,123.4 71.07,123.4 72.1,124.43 72.74,124.43 73.88,125.57 75.66,125.57 78.91,128.83 79.41,128.83 80.65,130.08 83.11,130.08 83.99,130.96 85.82,130.96 86.76,131.91 89.44,131.91 93.56,136.03 99.81,136.03 100.39,135.45 101.58,135.45 102.03,135 105.51,135 105.88,134.63 108.25,134.63 108.86,134.02 109.71,134.02 110.49,134.8 112.91,134.8 114.43,133.28 v3(114.43,132.9)
  GND1 w0.089: v4(140.71,123.53) 140.87,123.69 v8(141.15,123.69)
  IN2 w0.084: v4(114.26,130.01) 113.82,130.44 113.82,132.65 114.08,132.9 v3(114.43,132.9)
  GND3 w0.084: v4(140.71,123.53) 140.43,123.25 139.01,123.25 137.77,122.01 126.72,122.01 121.55,127.19 115.55,127.19 114.73,128.01 114.73,128.27 114.46,128.53 114.46,129.8 v4(114.26,130.01)
HDA_SDIN0_AUDIO: length 3.2
  TOP w0.152: UA1.16 25.12,21.03 24.91,21.24 24.91,22.22 24.36,22.77 RA14.2
HDA_SDOUT: length 21
  TOP w0.152: v1(143.12,124.01) RH112.2
  IN1 w0.06: v1(131.58,111.64) 131.63,111.69 131.63,111.89 131.7,111.96 131.7,111.97 131.82,112.09 131.82,112.46 133.69,114.33 136.17,114.33 138.33,116.49 138.79,116.49 139.38,117.08 139.38,117.69
  IN1 w0.089: v1(143.12,124.01) 143.42,123.72 143.42,122.9 142.76,122.24 142.27,122.24 141.39,121.36 139.65,121.36 139.38,121.09 139.38,117.69
HDA_SDOUT_L: length 239.4
  TOP w0.152: UA1.17 25.09,20.63 24.63,21.09 24.63,21.99 v1(24.47,22.16) ; CH49.1 144.51,124.87 144.23,124.6 v1(143.71,124.6)
  IN1 w0.089: v8(140.7,124.32) 141.26,124.32 141.62,124.68 143.62,124.68 v1(143.71,124.6) ; v1(24.47,22.16) 24.47,23.82 25.18,24.53 25.18,25.04 26.14,26.01 28.21,26.01 28.67,26.46 28.67,28.68 29.37,29.38 30.67,29.38 31.5,30.2 31.5,35.55 31.29,35.77 31.29,36.5 31.07,36.72 31.07,39.47 31.73,40.14 31.73,41.11 33.5,42.87 33.5,43.37 33.03,43.83 33.03,50.38 32.75,50.66 32.75,53.88 31.73,54.89 31.73,60.36 31.58,60.52 31.45,60.52 30.92,59.98 30.77,59.98 30.66,60.08 30.66,60.23 31.2,60.77 31.2,60.89 31.07,61.02 30.95,61.02 30.41,60.48 30.27,60.48 30.16,60.59 30.16,60.73 30.7,61.27 30.7,61.4 30.57,61.52 30.45,61.52 29.91,60.99 29.76,60.99 29.66,61.09 29.66,61.24 30.2,61.77 30.2,61.9 30.07,62.03 29.94,62.03 29.41,61.49 29.26,61.49 29.16,61.59 29.16,61.74 29.69,62.28 29.69,62.4 29.57,62.53 29.44,62.53 28.9,61.99 28.76,61.99 28.65,62.1 28.65,62.24 29.19,62.78 29.19,62.91 29.06,63.03 28.94,63.03 28.69,62.78 28.54,62.78 28.44,62.88 28.44,63.03 28.69,63.28 28.69,63.41 28.36,63.74 28.36,73.04 28.62,73.3 28.62,75.21 29.33,75.92 29.33,77.11 30.23,78.01 30.23,79.61 31.07,80.45 31.07,83.28 31.51,83.72 31.51,87.88 31.9,88.27 31.9,88.96 34.09,91.15 35.03,91.15 37.6,93.72 37.6,94.63 38.81,95.83 40.23,95.83 41.8,97.39 44.33,97.39 45.49,98.55 47.93,98.55 49.74,100.36 59.32,100.36 61.45,102.5 61.45,110.98 62.63,112.16 62.63,116.56 64.9,118.83 65.39,118.83 65.94,119.38 65.94,119.57 69.56,123.19 71.16,123.19 72.19,124.21 72.83,124.21 73.97,125.36 75.79,125.36 75.98,125.55 76.5,125.55 79.18,128.23 79.65,128.23 80.89,129.47 82.8,129.47 84.08,130.75 85.91,130.75 86.85,131.69 89.55,131.69 93.67,135.81 99.72,135.81 100.3,135.23 101.49,135.23 101.94,134.78 105.42,134.78 105.79,134.42 108.16,134.42 108.77,133.81 109.8,133.81 110.58,134.58 112.79,134.58 114.02,133.36 114.02,132.91 v3(114.46,132.47)
  GND1 w0.089: v4(140.22,124.31) 140.69,124.31 v8(140.7,124.32)
  IN2 w0.084: v4(114.92,129.68) 114.87,129.73 114.87,131.3 114.46,131.71 v3(114.46,132.47)
  GND3 w0.084: v4(140.22,124.31) 140.22,123.99 139.69,123.46 138.92,123.46 137.68,122.22 126.81,122.22 121.57,127.47 115.57,127.47 114.94,128.1 114.94,128.39 114.69,128.64 114.69,129.24 114.87,129.42 114.87,129.62 v4(114.92,129.68)
HDA_SYNC: length 17.5
  TOP w0.152: RH111.2 140.56,121.48 v1(140.77,121.7)
  IN1 w0.06: v1(130.62,111.4) 130.65,111.36 130.95,111.36 131.16,111.57 131.16,111.71 131.06,111.81 131.06,111.97 131.26,112.17 131.26,112.27 131.53,112.53 131.55,112.53 133.59,114.57 135.93,114.57 138.72,117.36 138.72,118.02 138.88,118.18
  IN1 w0.089: 138.88,118.18 139,118.3 139,121.26 139.44,121.7 v1(140.77,121.7)
HDA_SYNC_L: length 234.9
  TOP w0.152: v1(26.48,22.38) UA1.14 ; RH111.1 140.37,122.27 CH50.1 139.87,123.63 v10(139.88,123.64)
  IN1 w0.089: v3(115.09,131.83) 114.84,131.83 114.66,131.66 113.95,131.66 113.41,131.12 113.41,130.01 113.03,129.63 112.34,129.63 111.99,129.99 111.99,131.36 110.19,133.16 105.9,133.16 105.77,133.29 104.98,133.29 104.7,133.57 104.47,133.57 103.91,134.13 101.67,134.13 101.22,134.58 99.99,134.58 99.41,135.16 93.97,135.16 89.83,131.03 87.11,131.03 86.17,130.1 84.35,130.1 82.56,128.31 80.65,128.31 77.24,124.91 76.25,124.91 75.71,124.36 74.2,124.36 72.65,122.82 72.26,122.82 71.98,122.54 70.44,122.54 65.68,117.78 65.45,117.78 63.28,115.61 63.28,111.89 62.11,110.73 62.11,102.22 59.57,99.68 50.03,99.68 48.26,97.91 47.22,97.91 46.06,96.74 42.18,96.74 40.54,95.1 39.6,95.1 35.21,90.72 34.27,90.72 32.37,88.82 32.37,88.13 31.94,87.7 31.94,83.54 31.5,83.1 31.5,78.15 30.61,77.27 30.61,76.87 29.76,76.02 29.76,73.08 29.64,72.96 28.93,72.96 28.87,72.9 28.87,72.72 28.96,72.63 29.67,72.63 29.76,72.54 29.76,72.36 29.67,72.27 28.96,72.27 28.87,72.19 28.87,72.01 28.96,71.92 29.67,71.92 29.76,71.83 29.76,71.65 29.67,71.56 28.96,71.56 28.87,71.47 28.87,71.3 28.96,71.21 29.67,71.21 29.76,71.12 29.76,70.94 29.67,70.85 28.96,70.85 28.87,70.76 28.87,70.59 28.96,70.5 29.67,70.5 29.76,70.41 29.76,63.05 32.16,60.65 32.16,55.07 33.18,54.06 33.18,50.84 33.46,50.55 33.46,44.01 33.93,43.55 33.93,41.85 32.78,40.71 32.47,40.71 32.34,40.57 32.34,39.37 32.23,39.26 31.59,39.26 31.5,39.17 31.5,38.99 31.59,38.91 32.23,38.91 32.32,38.82 32.32,38.64 32.23,38.55 31.59,38.55 31.5,38.46 31.5,38.28 31.59,38.19 32.23,38.19 32.32,38.11 32.32,37.93 32.23,37.84 31.59,37.84 31.52,37.77 31.52,36.88 31.72,36.68 31.72,35.95 31.93,35.73 31.93,30 30.82,28.89 30.53,28.89 29.99,28.35 29.99,27.02 29.47,26.49 29.31,26.49 28.66,25.84 28.66,25.57 28.29,25.2 25.95,25.2 25.65,24.9 25.65,23.43 25.77,23.3 26.56,23.3 26.69,23.17 26.69,22.96 26.56,22.83 25.77,22.83 25.65,22.7 25.65,21.73 25.77,21.6 26.35,21.6 26.48,21.73 v1(26.48,22.38)
  GND1 w0.089: v4(139.77,124.06) 139.77,123.89 139.88,123.78 v10(139.88,123.64)
  IN2 w0.084: v4(115.85,129.43) 115.09,130.18 v3(115.09,131.83)
  GND3 w0.084: v4(115.85,129.43) 116.19,129.09 119.39,129.09 120.02,128.46 122.2,128.46 127.51,123.15 136.49,123.15 137.37,124.02 138.17,124.02 138.77,124.62 139.22,124.62 v4(139.77,124.06)
HG4: length 11.7
  TOP w0.254: v10(163.85,122.86) 164.19,123.2 PU500.J1
  GND1 w0.508: v4(163.25,122.94) 163.76,122.94 v10(163.85,122.86)
  IN2 w0.508: v4(161.7,115.6) 161.45,115.6 v2(160.89,115.04)
  IN3 w0.508: v4(163.25,122.94) 162.29,121.99 162.29,120.12 161.77,119.6 161.77,117.56 161.93,117.4 161.93,115.8 161.7,115.57 v4(161.7,115.6)
HG5: length 18.8
  TOP w0.254: v7(167.83,127.33) 168.38,126.77 168.38,126.4 PU500.A8
  GND1 w0.508: v10(181.46,133.77) 180.86,134.37 v4(180.86,134.54)
  IN3 w0.508: v7(167.83,127.33) 167.83,127.58 171.1,130.84 176.51,130.84 176.92,131.25 176.92,132.04 177.41,132.53 178.86,132.53 180.86,134.54 v4(180.86,134.54)
HG6: length 12.9
  TOP w0.254: PU500.J14 v10(171.3,123.2)
  GND1 w0.254: v4(171.68,123.1) 171.58,123.2 v10(171.3,123.2)
  GND1 w0.508: v10(177.78,114.21) v4(177.78,114.64)
  IN3 w0.508: v6(176.38,115.6) 175.9,115.6 175.63,115.87 175.63,116.93 173.08,119.48 173.08,121.7 v4(171.68,123.1)
  GND4 w0.508: v4(177.78,114.64) 177.63,114.64 v9(177.35,114.92)
  BOTTOM w0.508: v6(176.38,115.6) 177.07,114.92 v9(177.35,114.92)
HG10: length 10
  TOP w0.254: PU500.F1 165.25,124.4 164.67,124.98 v7(164.38,124.98)
  GND1 w0.508: v4(158.22,125.38) 157.71,125.89 v10(156.95,125.89)
  GND4 w0.508: v4(158.22,125.38) 158.22,125.36 v9(158.63,124.95)
  BOTTOM w0.508: v9(158.63,124.95) 159.47,124.11 162.87,124.11 163.74,124.98 v7(164.38,124.98)
HG11: length 16.5
  TOP w0.254: v1(167.75,120.48) 167.99,120.72 PU500.P7
  TOP w0.508: v10(162.69,109.53) 162.37,109.21 PQ601.1
  IN1 w0.254: v1(167.75,120.48) 167.75,120.44 167.93,120.26 167.93,119.25 168.05,119.12
  IN1 w0.508: 168.05,119.12 168.05,116.61 v3(167.87,116.43)
  GND1 w0.508: v4(162.5,110.07) 162.69,109.87 v10(162.69,109.53)
  IN2 w0.508: v3(167.87,116.43) v4(167.37,116.43)
  IN3 w0.508: v6(163.3,113.11) 162.5,112.31 v4(162.5,110.07)
  GND4 w0.508: v4(167.37,116.43) v9(167.37,116.04)
  BOTTOM w0.508: v6(163.3,113.11) 163.3,114.03 165.31,116.04 v9(167.37,116.04)
HOME_KEY#: length 65.1
  TOP w0.119: v1(192.28,95.17) 192.25,95.21 192.25,96.63 192.12,96.76 D423.2 191.96,96.68 191.96,95.24 191.65,94.92 JLVDS1.3
  IN1 w0.089: v1(232.31,121.25) 232.31,120.73 232.05,120.47 231.36,120.47 231.2,120.31 231.2,119.15 v1(231.12,119.07) 231.33,118.86 231.33,118.04 231.08,117.8 229.41,117.8 228.83,117.22 225.86,117.22 225.07,118 223.18,118 222.33,118.85 217.33,118.85 216.71,118.23 216.28,118.23 215.1,117.05 213.12,117.05 210.2,114.13 210.01,114.13 208.15,112.27 207.86,112.27 204.12,108.53 202.24,108.53 198.62,104.91 198.62,98.81 198.01,98.2 198.01,95.09 196.88,93.96 194.05,93.96 192.84,95.17 v1(192.28,95.17)
HOST_DEBUG_TX: length 62
  TOP w0.119: JDEG1.8 208.23,144.99 v1(208.12,144.88)
  IN1 w0.089: v1(208.12,144.88) 208.78,144.22 212.05,144.22 212.25,144.42 213.87,144.42 215.73,146.29 224.65,146.29 225.18,146.81 226.22,146.81 227.34,145.69 227.34,144.93 227.92,144.35 227.92,143.7 228.21,143.41 228.94,143.41 229.45,142.9 229.75,142.9 231.13,141.52 233.53,141.52 v3(234.09,140.97) ; v3(239.94,123.77) 239.94,123.76 239.21,123.03 237.07,123.03 236.68,123.43 236.53,123.43 236.26,123.16 235.93,123.16 235.77,122.99 235.03,122.99 234.81,122.77 v10(234.81,122.75)
  IN2 w0.084: v3(234.09,140.97) 234.72,140.34 234.72,137.7 235.39,137.03 235.39,136.5 238.45,133.44 239.27,133.44 241.03,131.68 242.46,131.68 242.69,131.45 242.69,128.18 242.56,128.04 242.56,124.86 241.9,124.2 240.37,124.2 v3(239.94,123.77)
HOST_SD_WP#: length 167.2
  TOP w0.119: v1(32.79,73.36) 32.25,73.36 RH134.1 32.16,73.34 31.23,72.41 QR1.2
  IN1 w0.089: v5(97.57,125.18) 97.07,124.68 97.07,123.8 96.06,122.79 96.06,112.46 95.59,111.99 95.59,106.57 94.81,105.79 94.81,102.2 91.74,99.13 91.74,98.03 91.18,97.47 91.18,95.45 87.84,92.11 76.7,92.11 75.97,91.37 66.2,91.37 61.78,95.79 53.92,95.79 52.19,94.06 49.56,94.06 49.21,93.71 45.21,93.71 43.4,91.89 42.87,91.89 42.42,91.45 40.96,91.45 38.84,89.32 38.37,89.32 37.5,88.45 37.5,84.97 34.45,81.92 34.45,77.08 33.37,76 33.37,74.51 32.79,73.92 v1(32.79,73.36)
  GND1 w0.119: v5(97.57,125.18) 97.86,125.47 v4(98.01,125.47)
  IN2 w0.06: v2(132.68,103.18) 132.81,103.06 132.98,103.06 133.05,102.98 133.79,102.98 133.86,103.05 135.06,103.05 v4(135.13,102.98)
  GND3 w0.119: v4(98.01,125.47) 98.36,125.47 101.93,121.9 v4(104.4,121.9)
  IN3 w0.084: v4(104.4,121.9) 104.49,121.99 108.65,121.99 109.46,122.8 115.49,122.8 116.59,121.7 118.19,121.7 118.47,121.42 118.47,120.4 118.12,120.05 118.12,118.55 121.95,114.71 128.45,114.71 132.42,110.75 132.42,107.93 132.7,107.65 132.7,105.52 135.13,103.08 v4(135.13,102.98)
HP2_D_L: length 10.5
  TOP w0.203: UA1.32 28.11,14.55 27.9,14.33 v7(27.9,14.18)
  TOP w0.254: v7(29.11,10.98) 29.08,11.02 28.7,11.02 RA1.1
  IN2 w0.254: v7(29.11,10.98) 29.19,11.06 32.86,11.06 v2(33.39,11.59)
  IN3 w0.254: v7(27.9,14.18) 27.92,14.16 27.92,11.62 28.56,10.98 v7(29.11,10.98)
HP2_D_L_C: length 9.4
  TOP w0.254: JHP1.8 22.71,6.32 v7(23.3,6.91) ; L1.2 25.8,10.78 RA4.1 CA11.1 23.85,10.52 DA8.1 23.09,10.82 v7(23.35,11.08)
  IN3 w0.254: v7(23.3,6.91) 23.3,6.92 23.25,6.98 23.25,9.33 23.58,9.66 23.58,10.84 23.35,11.06 v7(23.35,11.08)
HP2_D_L_R: length 11.2
  TOP w0.254: v2(27.59,10.83) 26.85,10.83 L1.1
  IN2 w0.254: v2(27.59,10.83) 27.59,10.24 28.46,9.37 33.89,9.37 34.92,10.4 34.92,11.29 34.44,11.77 v2(34.4,11.77)
HP2_D_R: length 12
  TOP w0.203: v7(28.45,14.18) 28.51,14.24 UA1.33
  TOP w0.254: v7(29.11,11.59) 29.05,11.53 28.7,11.53 RA2.1
  IN2 w0.254: v2(33.39,10.32) 33.39,10.71 33.92,11.23 33.92,11.9 33.69,12.12 33.21,12.12 32.65,11.57 29.14,11.57 v7(29.11,11.59)
  IN3 w0.254: v7(29.11,11.59) 29.01,11.49 28.81,11.49 28.43,11.87 28.43,14.16 v7(28.45,14.18)
HP2_D_R_C: length 9.7
  TOP w0.254: JHP1.7 22.21,6.54 22.6,6.93 v7(22.66,6.93) ; v7(22.69,11.13) 23.09,11.54 DA1.1 23.98,11.9 CA10.1 RA3.1 25.82,11.77 L2.2
  IN3 w0.254: v7(22.66,6.93) 22.74,7.01 22.74,9.54 23.07,9.87 23.07,10.63 22.69,11.01 v7(22.69,11.13)
HP2_D_R_R: length 9.5
  TOP w0.254: L2.1 v2(27.59,11.72)
  IN2 w0.254: v2(27.59,11.72) 28.2,11.11 28.2,10.35 28.67,9.88 33.67,9.88 34.4,10.6 v2(34.4,10.9)
HP_PLUG#: length 29.3
  TOP w0.119: v7(23.91,6.51) 23.71,6.32 JHP1.10 ; RA24.1 23.22,23.96 22.74,23.48 v7(22.74,22.74)
  IN3 w0.084: v7(23.91,6.51) 23.42,6.02 19.09,6.02 17.66,7.45 17.66,14.35 18.26,14.94 21.69,14.94 22.18,15.44 22.18,22.06 22.74,22.61 v7(22.74,22.74)
HW_ACAV_IN: length 273.4
  TOP w0.119: PR737.1 177.26,108.24 v10(177.25,108.22) ; v2(235.49,129.8) 235.46,129.77 235.46,127.74 234.81,127.09 U27.C1 ; v7(53.03,134.95) 53.03,134.5 PR411.1
  GND1 w0.119: v10(177.25,108.22) 177.26,108.24 177.98,108.24 v4(178.01,108.21)
  IN2 w0.084: v4(159.49,134.63) 159.71,134.84 163.28,134.84 163.62,135.19 172.51,135.19 173.21,134.49 179.83,134.49 180.55,135.21 183.23,135.21 183.76,135.74 185.11,135.74 v4(185.31,135.54) 185.65,135.89 189.05,135.89 189.83,136.67 189.83,138.91 189.5,139.24 189.5,141.75 192.5,144.75 201.19,144.75 201.38,144.94 203.99,144.94 204.93,144 209.86,144 211.18,145.32 211.18,147.84 211.69,148.35 216.99,148.35 221.2,144.14 222.06,144.14 222.36,143.84 223.59,143.84 225.01,142.42 227.62,142.42 227.88,142.16 228.49,142.16 231.34,139.32 231.34,138.75 231.32,138.74 231.32,137.29 230.75,136.71 230.75,134.13 231.04,133.84 232.22,133.84 234.32,131.74 234.32,130.97 v2(235.49,129.8)
  GND3 w0.119: v4(159.49,134.63) 159.35,134.77 156.87,134.77 156.69,134.59 147.83,134.59 146.89,133.65 143.75,133.65 140.34,130.24 129.1,130.24 127.73,131.6 127.73,132.77 125.51,134.99 123.5,134.99 122.56,135.92 118.93,135.92 v4(118.73,135.72)
  IN3 w0.084: v4(178.01,108.21) 178.24,107.98 185.53,107.98 186.29,107.22 186.29,105.17 187.92,103.54 189.43,103.54 191.5,105.6 191.5,110.5 188.02,113.98 188.02,118.37 185.43,120.96 185.43,122.89 188.89,126.36 188.89,131.27 188.53,131.63 188.53,133.71 187.05,135.19 185.66,135.19 v4(185.31,135.54) ; v4(118.73,135.72) 118.46,135.98 116.06,135.98 115.92,135.84 115.42,135.84 114.09,137.17 103.13,137.17 102.33,136.37 97.76,136.37 97.19,135.8 95.63,135.8 95.44,135.99 90.27,135.99 89.63,136.63 80.67,136.63 80.31,136.26 79.66,136.26 79.21,136.71 59.2,136.71 58.19,135.69 53.78,135.69 v7(53.03,134.95)
I2C0_SCL_AMP: length 307.1
  TOP w0.119: v1(27.71,23.07) UA1.12 ; v7(203.56,128.3) 203.56,127.34 RA66.1
  IN1 w0.089: v7(203.82,141.33) 202.81,142.34 202.81,142.64 202.18,143.27 198.84,143.27 198.27,142.69 198.27,140.83 196.85,139.42 193.4,139.42 191.97,137.98 190.21,137.98 188.96,136.72 181.87,136.72 179.38,134.23 174.05,134.23 173.2,135.08 172.69,135.08 171.85,135.92 168.93,135.92 168.6,136.26 163.68,136.26 162.38,134.96 159.71,134.96 159.58,134.84 154.82,134.84 153.85,133.87 149.35,133.87 148.31,132.83 145.08,132.83 144.29,132.04 142.14,132.04 140.96,130.87 140.96,130.08 139.98,129.1 139.71,129.1 139.29,128.69 139.29,128.29 138.91,127.91 138.91,127.54 138.81,127.45 138.16,127.45 138.05,127.34 136.28,127.34 134.31,129.3 132.19,129.3 130.76,130.73 130.76,131.04 130.29,131.51 123.55,131.51 122.79,130.75 120.85,130.75 120.66,130.95 120.66,131.29 120.19,131.75 116.82,131.75 115.44,130.37 115.44,129.6 115.75,129.28 115.75,128.88 115.29,128.42 111.66,128.42 110.92,129.16 110.92,129.71 110.69,129.94 110.69,131.22 110.25,131.66 109.55,131.66 108.99,132.22 105.51,132.22 105.38,132.35 104.59,132.35 104.4,132.55 103.72,132.55 103.07,133.19 101.64,133.19 100.43,131.99 99.51,131.99 99.05,131.52 98.42,131.52 98.17,131.28 95.77,131.28 94.17,129.68 91.67,129.68 91.26,129.26 89.26,129.26 87.81,127.82 86.4,127.82 85.75,127.17 81.1,127.17 77.39,123.45 76.51,123.45 76.17,123.12 74.88,123.12 73.23,121.47 72.24,121.47 70.05,119.29 68.57,119.29 66.07,116.8 65.79,116.8 64.22,115.22 64.22,111.5 63.18,110.46 63.18,101.94 59.87,98.64 50.43,98.64 48.33,96.54 47.19,96.54 46.45,95.8 42.93,95.8 41.27,94.15 40.68,94.15 35,88.47 34.24,88.47 33.86,88.09 33.86,84.13 32.44,82.71 32.44,77.77 31.55,76.88 31.55,75.62 30.85,74.92 30.85,65.07 31.99,63.92 31.99,63.89 33.43,62.46 33.43,55.13 34.53,54.03 34.53,44.27 34.87,43.94 34.87,42.39 35.16,42.1 35.16,39.55 33.62,38.01 33.62,34.24 33.15,33.77 33.15,29.88 31.43,28.16 31.43,27.12 30.32,26.01 30.32,25.68 v1(27.71,23.07)
  IN3 w0.084: v7(203.82,141.33) 203.84,141.36 205.37,141.36 206.43,140.29 206.43,138.74 202.08,134.39 202.08,133.75 203.43,132.39 203.43,128.43 v7(203.56,128.3)
I2C0_SCL_AMP_R: length 10.1
  TOP w0.119: UA2.4 205.58,126.24 RA66.2 ; RA66.2 204.84,126.97 204.58,126.97 204.05,127.49 Q349.1 ; RA66.2 205.8,126.53 v1(205.85,126.57) ; v1(209.66,127.73) 209.95,127.44 RA71.1 209.71,127.05 RA79.1
  IN1 w0.089: v1(209.66,127.73) 209.44,127.52 206.96,127.52 206.01,126.57 v1(205.85,126.57)
I2C0_SCL_AUD: length 110.7
  TOP w0.152: v1(208.58,126.02) 210.1,126.02 210.61,126.53 RA79.2
  IN1 w0.06: 148.36,99.73 148.36,99.75 147.38,100.72 146.69,100.72 146.43,100.98 142.78,100.98 142.4,101.37 141.98,101.37 141.81,101.54 141.65,101.7 141.52,101.7 141.24,101.98 140.01,101.98 139.99,102 139.83,102 139.36,102.46 137.9,102.46 137.79,102.58 v8(137.67,102.58) 137.4,102.58 136.87,103.1 136.45,103.1 136.15,103.4 135,103.4 v1(134.9,103.5)
  IN1 w0.089: 148.36,99.73 148.36,98.61 148.69,98.27 149.33,98.27 149.71,97.89 152.06,97.89 152.63,97.32 155.81,97.32 156.04,97.09 161.65,97.09 161.95,96.78 164.66,96.78 168.57,92.87 176.72,92.87 179.27,95.42 186.76,95.42 188.66,97.32 189.46,97.32 190.64,98.49 191.78,98.49 194.04,100.74 194.04,101.76 194.99,102.71 194.99,104.72 198.02,107.75 198.02,108.8 200,110.78 201.21,110.78 203.86,113.43 205.66,113.43 206.99,114.76 206.99,115.6 208.44,117.05 v3(208.44,117.59) ; v1(208.58,126.02) 207.75,126.02 v3(207.75,126.02)
  GND1 w0.089: v8(137.67,102.58) 137.68,102.58 v4(138.08,102.58)
  IN2 w0.084: v4(208.64,125.07) 208.46,125.07 207.75,125.78 v3(207.75,126.02) ; v3(208.44,117.59) v4(207.71,117.59)
  IN3 w0.084: v4(208.64,125.07) 208.64,123.48 207.71,122.54 207.71,118.13 208.01,117.83 209.96,117.83 210.02,117.76 210.02,117.38 209.96,117.32 207.98,117.32 v4(207.71,117.59)
  GND4 w0.06: v6(137.79,102.83) 137.8,102.83 138.04,102.58 v4(138.08,102.58)
I2C0_SDA_AMP: length 311.5
  TOP w0.119: RA65.1 207.53,127.84 208.18,127.84 208.45,128.11 v7(208.45,128.3) ; v1(28.11,23.07) UA1.11
  IN1 w0.089: v1(28.11,23.07) 28.16,23.12 28.16,23.25 30.52,25.61 30.52,25.94 31.71,27.13 31.71,27.28 33.2,28.77 33.2,29.35 33.34,29.49 33.34,33.69 33.81,34.16 33.81,37.93 35.35,39.47 35.35,42.18 35.06,42.47 35.06,44.02 34.72,44.35 34.72,54.11 33.62,55.21 33.62,62.53 32.18,63.97 32.18,64 31.04,65.14 31.04,74.84 31.74,75.54 31.74,76.8 32.63,77.69 32.63,82.63 34.41,84.41 34.41,86.38 35.31,87.27 35.31,87.81 35.82,88.32 35.82,89.02 40.76,93.96 41.35,93.96 43.01,95.61 46.53,95.61 47.26,96.35 48.43,96.35 50.51,98.43 59.94,98.43 63.38,101.87 63.38,110.4 64.41,111.43 64.41,114.53 65.4,115.52 65.4,115.7 68.77,119.07 70.11,119.07 72.32,121.28 74.49,121.28 75.24,122.03 76.24,122.03 81.18,126.98 85.83,126.98 86.47,127.62 87.89,127.62 89.33,129.06 93.82,129.06 95.85,131.09 98.25,131.09 98.49,131.33 99.12,131.33 99.58,131.79 100.5,131.79 101.71,133 102.99,133 103.64,132.35 104.32,132.35 104.51,132.16 105.3,132.16 105.43,132.03 108.8,132.03 109.47,131.36 110.27,131.36 110.5,131.14 110.5,129.86 110.72,129.63 110.72,129.08 111.59,128.21 115.35,128.21 115.99,128.85 115.99,130.65 116.9,131.56 120.11,131.56 120.47,131.21 120.47,130.87 120.77,130.56 122.87,130.56 123.63,131.32 130.21,131.32 130.57,130.96 130.57,130.65 132.11,129.11 134.23,129.11 136.2,127.15 138.13,127.15 138.24,127.26 138.89,127.26 139.1,127.47 139.1,127.83 139.48,128.21 139.48,128.61 139.77,128.9 140.05,128.9 141.15,130 141.15,130.79 142.22,131.85 144.37,131.85 145.16,132.64 148.42,132.64 149.38,133.6 153.86,133.6 154.9,134.65 159.66,134.65 159.75,134.73 162.43,134.73 163.75,136.05 168.54,136.05 168.87,135.72 171.78,135.72 172.61,134.89 173.12,134.89 173.97,134.04 179.46,134.04 181.14,135.72 181.95,136.53 189.04,136.53 190.29,137.79 192.05,137.79 193.48,139.23 196.93,139.23 198.46,140.75 198.46,142.61 198.92,143.08 202.11,143.08 202.62,142.56 202.62,142.25 203.3,141.58 203.3,141.09 203.54,140.85 203.89,140.85 204.26,141.22 204.26,141.27 205.01,142.02 v5(205.53,142.02)
  GND1 w0.119: v4(205.94,142.02) v5(205.53,142.02)
  IN3 w0.084: v4(205.94,142.02) 206.47,142.55 209.71,142.55 210.74,141.52 210.74,139.5 211.28,138.96 211.28,137.27 211.16,137.14 211.16,136.61 211.41,136.36 211.41,134.63 208.26,131.48 208.26,128.49 v7(208.45,128.3)
I2C0_SDA_AMP_R: length 9
  TOP w0.119: UA2.3 205.98,125.13 207.05,126.21 RA65.2 ; 206.06,127.44 205.85,127.66 205.85,127.67 205.35,128.17 Q349.4 ; 206.06,127.44 RA65.2 ; 206.06,127.44 206.48,127.86 206.81,127.86 RA78.1 ; RA65.2 207.89,127.29 RA70.1
I2C0_SDA_AUD: length 123.9
  TOP w0.152: RA78.2 206.04,128.3 v2(205.78,128.56)
  IN1 w0.06: v3(139.24,104.24) 139.43,104.24 139.49,104.3 139.97,104.3 140.22,104.55 140.22,106.43 140.28,106.49
  IN1 w0.089: 140.28,106.49 141.64,107.84 144.54,107.84 147.52,104.87 147.52,104.37 149.22,102.67 149.22,102.15 150.03,101.33 150.93,100.44 150.93,99.84 151.57,99.2 152.21,99.2 152.9,98.51 156.06,98.51 156.67,97.9 163.74,97.9 164.3,98.46 179.49,98.46 179.78,98.17 185.68,98.17 186.28,98.77 186.88,98.77 187.15,99.04 188.72,99.04 189.15,99.47 190.22,99.47 190.49,99.75 192.38,99.75 193.57,100.94 193.57,101.96 194.52,102.91 194.52,104.91 197.55,107.94 197.55,108.99 199.84,111.29 200.99,111.29 203.62,113.91 205.33,113.91 206.45,115.03 206.45,115.78 v3(207.74,117.07) ; v3(202.04,126.72) 201.56,126.72 201.17,127.11 198.97,127.11 v3(198.66,126.79)
  IN2 w0.06: v3(139.24,104.24) 139.24,103.97 v4(139.11,103.84) 139.03,103.92 137.94,103.92 136.8,105.05 136.11,105.05 136.07,105.09 135.46,105.09 135.39,105.03 135.39,105.03 135.04,104.68 133.8,104.68 133.59,104.47 133.25,104.47 v2(132.93,104.15)
  IN2 w0.084: v3(202.04,126.72) 202.17,126.59 205.97,126.59 206.26,126.3 206.57,126.3 207.93,124.94 v4(208.07,124.94) ; v2(205.78,128.56) 205.6,128.56 205.47,128.69 202.61,128.69 202.42,128.5 201.09,128.5 200.49,127.9 199.76,127.9 v3(198.66,126.79) ; v3(207.74,117.07) 207.55,117.07 207.12,117.51 v4(207.12,117.7)
  IN3 w0.084: v4(207.12,117.7) 207.24,117.82 207.24,122.73 208.07,123.57 v4(208.07,124.94)
  GND4 w0.089: v9(139.3,103.31) 139.3,103.65 v4(139.11,103.84)
  BOTTOM w0.152: v9(139.3,103.31) 139.81,102.8 RH74.1
I2S_DATA_OUT: length 297.4
  TOP w0.119: UA2.10 203.18,125.03 201.97,126.23 201.97,128.49 v1(201.82,128.64) ; RA60.1 32.34,26.78 v1(32.32,26.81)
  IN1 w0.089: v5(146.77,123.71) 146.77,122.37 147.29,121.85 149.36,121.85 149.74,121.48 149.74,121.21 150.87,120.07 158.96,120.07 159.98,121.09 159.98,121.47 160.64,122.13 161.95,122.13 162.26,121.83 162.63,121.83 163.09,121.37 163.42,121.37 164.12,120.67 164.34,120.67 165.62,119.39 165.62,117.94 166.03,117.53 166.03,116.88 165.82,116.67 165.82,116.37 166.06,116.12 166.06,115.48 166.58,114.96 166.58,114.3 166.94,113.95 167.75,113.95 168.96,112.74 170.59,112.74 170.91,112.42 171.3,112.42 171.57,112.14 171.57,111.43 172.09,110.9 172.24,110.9 172.68,110.46 173.5,110.46 174.51,109.45 175.82,109.45 176.99,110.62 176.99,112.54 176.37,113.16 176.37,117.47 178.03,119.13 183.81,119.13 183.99,119.31 184.76,119.31 186.49,121.04 186.49,122.7 188.49,124.71 189.7,124.71 191.71,126.72 193.08,126.72 193.38,127.01 193.38,127.55 193.59,127.76 193.99,127.76 194.38,128.14 194.38,128.49 194.5,128.61 198.48,128.61 199.17,129.31 200.39,129.31 200.57,129.12 201.34,129.12 v1(201.82,128.64) ; v3(113.43,127.69) 113.1,128.02 111.51,128.02 110.51,129.03 110.51,129.58 110.31,129.78 110.31,130.19 108.66,131.84 105.35,131.84 105.22,131.97 104.43,131.97 104.24,132.16 103.56,132.16 102.91,132.81 101.79,132.81 100.57,131.59 99.65,131.59 96.17,128.11 95.52,128.11 95.26,128.38 95.26,128.65 94.85,129.06 94.4,129.06 94.21,128.87 89.42,128.87 87.97,127.41 86.53,127.41 85.9,126.79 81.26,126.79 75.56,121.09 72.4,121.09 70.17,118.87 68.84,118.87 65.59,115.62 65.59,115.44 64.6,114.45 64.6,111.35 63.58,110.33 63.58,101.8 60.02,98.24 50.59,98.24 48.49,96.13 47.32,96.13 46.61,95.42 43.09,95.42 41.43,93.77 40.84,93.77 36.01,88.94 36.01,88.24 35.5,87.73 35.5,87.2 34.6,86.3 34.6,84.29 32.82,82.52 32.82,77.61 31.93,76.72 31.93,75.46 31.23,74.76 31.23,65.22 32.37,64.08 32.37,64.05 33.81,62.61 33.81,55.29 34.91,54.19 34.91,44.43 35.25,44.09 35.25,42.55 35.54,42.26 35.54,39.37 34,37.83 34,34.08 33.53,33.61 33.53,29.41 33.39,29.27 33.39,28.68 32.32,27.61 v1(32.32,26.81)
  GND1 w0.119: v5(146.77,123.71) 146.77,124.06 v4(146.74,124.09)
  IN2 w0.084: v4(114.1,128) 113.73,128 v3(113.43,127.69)
  GND3 w0.119: v4(146.74,124.09) 146.53,123.87 145.24,123.87 143.82,122.45 140.16,122.45 139.27,121.56 126.5,121.56 121.38,126.68 115.42,126.68 v4(114.1,128)
I2S_DATA_OUT_R: length 7.1
  TOP w0.119: UA1.5 30.51,23.17 v2(30.6,23.26) ; v2(33.39,23.54) 33.31,23.63 33.31,26.68 RA60.2
  IN2 w0.084: v2(30.6,23.26) 33.12,23.26 v2(33.39,23.54)
I2S_LRCK: length 292.8
  TOP w0.119: RA56.1 31.85,25.6 v7(32.35,26.1) ; v1(202.48,130.34) 202.48,127.08 202.91,126.65 202.91,126.35 204.03,125.23 204.24,125.23 204.38,125.09 UA2.7
  IN1 w0.089: v3(102.24,132.09) 102.19,132.04 101.85,132.04 100.82,131.01 99.88,131.01 96.39,127.52 95.31,127.52 94.9,127.92 94.57,127.92 94.2,128.3 89.67,128.3 88.19,126.82 86.75,126.82 86.14,126.21 81.5,126.21 75.79,120.51 72.67,120.51 70.34,118.18 68.96,118.18 67.56,116.78 67.56,116.05 65.57,114.06 65.57,111.51 64.19,110.13 64.19,101.61 60.26,97.67 51.67,97.67 50.83,96.83 50.83,96.32 50.06,95.56 47.55,95.56 46.84,94.85 43.32,94.85 41.64,93.16 41.04,93.16 36.58,88.7 36.58,87.47 35.17,86.06 35.17,84.06 33.5,82.39 33.5,77.48 32.52,76.49 32.52,75.16 31.82,74.46 31.82,65.92 34.38,63.35 34.38,55.53 35.49,54.43 35.49,53.87 35.57,53.78 35.96,53.78 36.05,53.69 36.05,53.51 35.96,53.42 35.57,53.42 35.49,53.34 35.49,53.16 35.57,53.07 35.96,53.07 36.05,52.98 36.05,50.22 35.49,49.65 35.49,44.67 35.82,44.33 35.82,42.81 36.11,42.52 36.11,39.11 35.18,38.18 35.18,32.69 35.29,32.58 35.29,29.27 35.08,29.06 35.08,27.82 34.21,26.96 33.95,26.96 33.48,26.49 32.74,26.49 v7(32.35,26.1) ; v5(149.71,125.53) 149.94,125.76 149.94,126.51 149.66,126.79 149.66,128.83 150.29,129.46 159.87,129.46 159.96,129.36 161.49,129.36 162.13,128.72 166.74,128.72 167.39,128.07 167.77,128.07 167.9,128.2 168.61,128.2 169.01,128.6 171.4,128.6 172.43,127.56 172.43,127 172.76,126.67 173.92,126.67 174.3,126.28 174.3,125.57 176.08,123.79 176.08,123.02 176.56,122.53 176.56,122.28 177.04,121.8 177.85,121.8 178.45,121.2 183.69,121.2 184.07,121.58 184.8,121.58 185.15,121.93 185.15,122.79 187.63,125.27 187.89,125.53 187.89,126.96 188.51,127.57 190.3,127.57 191.8,129.07 191.8,129.96 192.52,130.68 194.21,130.68 194.63,130.26 200.79,130.26 200.97,130.08 202.21,130.08 v1(202.48,130.34)
  GND1 w0.119: v4(149.59,125.13) 149.59,125.41 v5(149.71,125.53)
  IN2 w0.084: v4(103.92,132.27) 103.59,131.94 102.39,131.94 v3(102.24,132.09)
  GND3 w0.119: v4(149.59,125.13) 149.21,124.75 149.21,124.21 147.94,122.94 145.08,122.94 144.12,121.99 140.32,121.99 139.45,121.12 126.22,121.12 121.12,126.22 114.91,126.22 111.1,130.03 107.5,130.03 105.26,132.27 v4(103.92,132.27)
  BOTTOM w0.119: CA46.1 32.35,25.58 v7(32.35,26.1)
I2S_LRCK_R: length 2.1
  TOP w0.119: RA56.2 32.11,24.09 UA1.1
I2S_OUT: length 294.4
  TOP w0.119: RA57.1 30.54,26.06 v7(31.17,26.06) ; v1(202.1,130.35) 202.1,130.12 202.23,130 202.23,127.02 202.69,126.56 202.69,126.26 203.98,124.97 UA2.8
  IN1 w0.089: v1(202.1,130.35) 202.05,130.29 201.02,130.29 200.85,130.46 194.7,130.46 194.29,130.87 192.44,130.87 191.61,130.04 191.61,129.15 190.22,127.76 188.43,127.76 187.7,127.04 187.7,125.61 184.96,122.87 184.96,122.01 184.72,121.78 183.99,121.78 183.61,121.39 178.53,121.39 177.92,122 177.11,122 176.81,122.31 176.81,123.35 174.58,125.58 174.58,126.77 173.86,127.49 172.77,127.49 171.48,128.79 168.93,128.79 168.67,128.53 167.9,128.53 167.75,128.68 167.05,128.68 166.82,128.91 162.21,128.91 161.18,129.95 160.13,129.95 159.83,129.65 150.21,129.65 149.46,128.9 149.46,126.58 v5(149.66,126.37) ; v3(102.67,132.34) 102.65,132.37 101.91,132.37 100.74,131.2 99.8,131.2 96.32,127.72 95.37,127.72 94.98,128.11 94.65,128.11 94.27,128.49 89.59,128.49 88.11,127.01 86.67,127.01 86.06,126.4 81.42,126.4 75.71,120.7 72.59,120.7 70.26,118.37 68.88,118.37 67.37,116.86 67.37,116.14 64.98,113.75 64.98,111.19 63.99,110.2 63.99,101.67 60.18,97.86 50.75,97.86 48.64,95.75 47.48,95.75 46.76,95.04 43.25,95.04 41.56,93.35 40.96,93.35 36.39,88.78 36.39,87.55 34.98,86.14 34.98,84.14 33.2,82.36 33.2,77.45 32.33,76.57 32.33,75.23 31.63,74.54 31.63,65.84 34.19,63.27 34.19,55.45 35.29,54.35 35.29,52.79 35.38,52.7 35.73,52.7 35.82,52.62 35.82,52.44 35.73,52.35 35.38,52.35 35.29,52.26 35.29,52.08 35.38,51.99 35.73,51.99 35.82,51.9 35.82,51.73 35.73,51.64 35.38,51.64 35.29,51.55 35.29,44.59 35.63,44.25 35.63,42.73 35.92,42.44 35.92,39.21 34.38,37.67 34.38,33.92 33.91,33.46 33.91,31.98 34.39,31.51 34.39,29.73 33.79,29.13 33.79,27.44 33.03,26.68 32.61,26.68 32.41,26.48 31.59,26.48 v7(31.17,26.06)
  GND1 w0.119: v5(149.66,126.37) 149.69,126.35 v4(149.69,125.97)
  IN2 w0.084: v4(103.05,132.34) v3(102.67,132.34)
  GND3 w0.119: v4(103.05,132.34) 103.35,132.63 105.25,132.63 107.25,130.64 108.47,130.64 108.77,130.93 110.51,130.93 114.99,126.45 121.25,126.45 126.36,121.34 139.36,121.34 140.26,122.23 143.91,122.23 145.31,123.63 148.31,123.63 148.95,124.27 148.95,124.87 149.22,125.14 149.22,125.5 v4(149.69,125.97)
  BOTTOM w0.119: CA47.1 30.33,25.71 30.68,26.06 v7(31.17,26.06)
I2S_OUT_R: length 3
  TOP w0.119: UA1.3 31.31,23.38 30.78,23.91 30.29,23.91 29.87,24.33 RA57.2
I_ADP: length 229.7
  TOP w0.119: PR412.1 50.08,134.79 v7(50.1,134.81)
  IN1 w0.089: v1(230.31,126.25) 230.03,126.25 228.57,127.71 v10(227.7,127.71) ; v5(221.79,138.95) 221.42,139.31 216.08,139.31 215.64,139.75 214.04,139.75 213.65,139.36 210.39,139.36 209.77,138.74 208.59,138.74 208.42,138.58 207.61,138.58 203.75,134.72 203.75,134.53 202.95,133.72 196.32,133.72 195.87,133.26 195.37,133.26 194.87,132.76 193.11,132.76 192.79,132.44 191.95,132.44 189.35,129.84 188.13,129.84 186.18,127.89 186.18,126.24 185.05,125.11 179.93,125.11 179.48,125.56 179.48,127.93 178.01,129.4 176.21,129.4 175.72,128.91 173.89,128.91 173.37,129.43 172.72,129.43 170.85,131.3 165.27,131.3 165.13,131.16 163.5,131.16 163.09,131.58 163.09,131.75 162.65,132.19 160.12,132.19 159.64,131.71 159.59,131.71 v5(159.32,131.44)
  GND1 w0.119: v5(221.79,138.95) 222.13,138.6 v4(222.13,138.45) ; v4(227.68,127.07) 227.68,127.29 227.7,127.31 v10(227.7,127.71) ; v4(160,130.63) 159.32,131.31 v5(159.32,131.44)
  IN2 w0.084: v4(63.15,146.63) 64.23,147.71 66.86,147.71 69.07,145.5 71.92,145.5 76.12,141.29 76.12,140.49 79.81,136.8 90.95,136.8 91.38,136.37 92.54,136.37 92.72,136.19 98.91,136.19 v4(99.99,135.11)
  GND3 w0.119: v4(160,130.63) 159.79,130.42 155.81,130.42 154.16,132.08 150.45,132.08 149.16,130.78 149.16,130.06 145.7,126.6 142.57,126.6 141.99,126.02 141.31,126.02 140.65,126.68 139.06,126.68 138.27,127.47 134.55,127.47 133.83,126.75 128.2,126.75 122.59,132.36 122.59,133.15 122.1,133.65 120.42,133.65 120.06,133.29 110.56,133.29 110.36,133.08 106.95,133.08 106.41,133.62 101.8,133.62 101.25,134.17 100.94,134.17 v4(99.99,135.11)
  IN3 w0.084: v4(222.13,138.45) 222.8,138.45 222.82,138.43 224.15,138.43 224.89,137.7 225.28,137.7 228.49,134.48 228.49,131.9 228.64,131.75 228.64,128.03 v4(227.68,127.07) ; v7(50.1,134.81) 50.1,134.88 51.15,135.94 51.15,139.87 58.07,146.79 62.99,146.79 v4(63.15,146.63)
I_BATT: length 231.3
  TOP w0.254: v1(49.61,131.88) 50.02,131.48 PR415.1
  IN1 w0.254: v3(124.02,137.47) 106.61,137.47 106.03,136.89 105.31,136.89 104.86,136.44 102.63,136.44 102.18,136.89 100.99,136.89 100.4,137.47 91.03,137.47 90.65,137.85 81.64,137.85 81.08,137.3 79.28,137.3 78.14,138.43 78.14,142.16 77.85,142.45 68.22,142.45 65.56,139.8 64.12,139.8 63.54,139.23 60.62,139.23 60.37,139.48 60.37,139.81 59.81,140.37 57.94,140.37 57.33,139.76 57.33,138.04 57.63,137.75 57.63,137.35 57.18,136.9 56.78,136.9 55.77,137.9 52.01,137.9 50.73,136.62 50.73,134.68 49.61,133.56 v1(49.61,131.88) ; v10(227.7,125.94) 227.91,125.94 228.26,125.59 229.24,125.59 229.58,125.25 v1(230.31,125.25) ; v3(130.61,135.36) 130.61,133.22 131.97,131.87 134.08,131.87 136.71,129.23 137.63,129.23 139.33,130.94 140.38,130.94 142.34,132.9 142.34,135.06 142.46,135.19 143.82,135.19 144.32,135.68 146.22,135.68 146.59,135.31 148.96,135.31 149.69,134.58 153.79,134.58 154.86,135.66 156.04,135.66 156.15,135.77 159.29,135.77 159.63,136.1 160.45,136.1 160.47,136.08 162.69,136.08 163.4,136.79 168.76,136.79 169.14,136.41 172.02,136.41 172.88,135.54 173.39,135.54 174.25,134.69 179.19,134.69 181.68,137.19 188.7,137.19 190.2,138.69 191.19,138.69 192.69,140.19 196.14,140.19 197.99,142.04 197.99,142.81 198.73,143.54 201.85,143.54 v7(202.67,144.37)
  GND1 w0.254: v4(228.26,126.37) 227.83,125.94 v10(227.7,125.94)
  IN2 w0.254: v4(130.85,136.44) 130.61,136.2 v3(130.61,135.36) ; v4(124.39,137.24) 124.17,137.47 v3(124.02,137.47)
  IN3 w0.254: v4(130.85,136.44) 130.7,136.44 129.9,137.24 v4(124.39,137.24) ; v4(228.26,126.37) 229.28,127.39 229.28,132.09 229.17,132.19 229.17,134.71 225.54,138.34 225.15,138.34 224.07,139.42 224.07,139.7 223.39,140.37 v6(223.39,141.52)
  BOTTOM w0.254: v7(202.67,144.37) 203.14,144.83 207.35,144.83 208.34,145.82 219.71,145.82 223.39,142.14 v6(223.39,141.52)
ILEDA: length 9.7
  TOP w0.119: R5712.1 202.01,145.54 201.5,145.03 v2(201.5,144.29)
  IN2 w0.084: v2(201.5,144.29) 201.42,144.38 197.87,144.38 196.95,143.46 196.12,143.46 195.87,143.21 195.87,142.38 195.37,141.88 v2(195.37,141.7)
