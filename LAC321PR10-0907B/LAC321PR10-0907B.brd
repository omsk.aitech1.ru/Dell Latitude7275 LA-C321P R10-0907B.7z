# Allegro board LAC321PR10-0907B.brd (continued)
## Nets (continued)
KEYSSA_USB_PWR_EN: R389.2 U27.M5 U33.3
LAN_WAKE#: RH77.1 U27.C12
LCD_VDD_AND_TST_EN: D1.3 JLVDS1.29 R162.2 U27.B12
LDO2-CAP: CA28.1 CA29.1 RA6.2 UA1.22
LG4: PR502.2 PU500.L1
LG4-1: PQ500.8 PR502.1
LG5: PR512.2 PU500.A6
LG5-1: PQ501.8 PR512.1
LG6: PR517.2 PU500.L14
LG6-1: PQ502.8 PR517.1
LG10: PR606.2 PU500.H1
LG10-1: PQ600.8 PR606.1
LG11: PR610.2 PU500.P5
LG11-1: PQ601.8 PR610.1
LID_CL_SIO#: C162.1 R130.2 U24.6 U27.J1
LINE1_L: CA51.1 RA61.2
LINE1_L_C: CA50.2 RA31.1
LINE1_R: CA50.1 RA63.2
LINE1_R_C: CA51.2 RA30.1
LINE1_VREFO: D8.1 UA1.40
LINE_L: RA61.1 UA1.35
LINE_R: RA63.1 UA1.34
LPC_AD0: JLPDE1.3 U27.K6 UC1.BK11
LPC_AD1: JLPDE1.4 U27.L6 UC1.BJ8
LPC_AD2: JLPDE1.5 U27.M6 UC1.BG10
LPC_AD3: JLPDE1.6 U27.K7 UC1.BP5
LPC_FRAME#: JLPDE1.7 U27.K5 UC1.BP7
M_A_CA_0_0: U3.L2 UC1.AW59
M_A_CA_0_1: U3.L3 UC1.AW55
M_A_CA_0_2: U3.L4 UC1.BF62
M_A_CA_0_3: U3.K2 UC1.AV56
M_A_CA_0_4: U3.K3 UC1.AW57
M_A_CA_0_5: U3.G3 UC1.AV58
M_A_CA_0_6: U3.G4 UC1.BA56
M_A_CA_0_7: U3.F2 UC1.BD59
M_A_CA_0_8: U3.F3 UC1.BD61
M_A_CA_0_9: U3.F4 UC1.BG61
M_A_CA_1_0: U3.B5 UC1.BK59
M_A_CA_1_1: U3.C5 UC1.BL62
M_A_CA_1_2: U3.D5 UC1.BJ61
M_A_CA_1_3: U3.B6 UC1.AV60
M_A_CA_1_4: U3.C6 UC1.BN62
M_A_CA_1_5: U3.C9 UC1.BB61
M_A_CA_1_6: U3.D9 UC1.BL61
M_A_CA_1_7: U3.B10 UC1.BM59
M_A_CA_1_8: U3.C10 UC1.BN58
M_A_CA_1_9: U3.D10 UC1.AV62
M_A_CK_DDR0_DN: U3.C8 UC1.BC62
M_A_CK_DDR0_DP: U3.B8 UC1.BC60
M_A_CK_DDR1_DN: U3.H2 UC1.BA60
M_A_CK_DDR1_DP: U3.H3 UC1.BA62
M_A_CKE0: U3.C7 UC1.BB57
M_A_CKE1: U3.D7 UC1.BC58
M_A_CKE2: U3.J3 UC1.BE57
M_A_CKE3: U3.J4 UC1.AW61
M_A_CS0_N: U3.D6 U3.K4 UC1.AW63
M_A_CS1_N: U3.B7 U3.J2 UC1.BJ57
M_A_DQ_0: U3.L16 UC1.AG61
M_A_DQ_1: U3.K15 UC1.AH60
M_A_DQ_2: U3.J16 UC1.AK62
M_A_DQ_3: U3.J15 UC1.AK60
M_A_DQ_4: U3.K16 UC1.AH62
M_A_DQ_5: U3.L15 UC1.AG63
M_A_DQ_6: U3.K13 UC1.AL61
M_A_DQ_7: U3.K14 UC1.AL63
M_A_DQ_8: U3.C16 UC1.AM60
M_A_DQ_9: U3.B16 UC1.AM62
M_A_DQ_10: U3.C13 UC1.AT60
M_A_DQ_11: U3.C14 UC1.AR61
M_A_DQ_12: U3.C15 UC1.AN61
M_A_DQ_13: U3.B15 UC1.AN63
M_A_DQ_14: U3.B14 UC1.AR63
M_A_DQ_15: U3.B13 UC1.AT62
M_A_DQ_16: U3.F14 UC1.AT56
M_A_DQ_17: U3.D13 UC1.AR55
M_A_DQ_18: U3.E13 UC1.AN57
M_A_DQ_19: U3.E14 UC1.AN55
M_A_DQ_20: U3.F15 UC1.AR57
M_A_DQ_21: U3.F16 UC1.AT58
M_A_DQ_22: U3.E15 UC1.AM58
M_A_DQ_23: U3.E16 UC1.AM56
M_A_DQ_24: U3.M13 UC1.AL55
M_A_DQ_25: U3.L13 UC1.AL57
M_A_DQ_26: U3.N16 UC1.AH58
M_A_DQ_27: U3.N15 UC1.AH56
M_A_DQ_28: U3.M14 UC1.AK58
M_A_DQ_29: U3.N14 UC1.AK56
M_A_DQ_30: U3.P15 UC1.AG55
M_A_DQ_31: U3.P16 UC1.AG57
M_A_DQ_32: U3.R5 UC1.BE55
M_A_DQ_33: U3.N4 UC1.BC55
M_A_DQ_34: U3.T6 UC1.BG53
M_A_DQ_35: U3.R6 UC1.BE53
M_A_DQ_36: U3.N5 UC1.BC53
M_A_DQ_37: U3.T5 UC1.BG55
M_A_DQ_38: U3.P5 UC1.BD52
M_A_DQ_39: U3.P6 UC1.BF52
M_A_DQ_40: U3.N11 UC1.BC51
M_A_DQ_41: U3.N12 UC1.BE51
M_A_DQ_42: U3.R13 UC1.BC49
M_A_DQ_43: U3.P13 UC1.BE49
M_A_DQ_44: U3.P12 UC1.BG51
M_A_DQ_45: U3.T13 UC1.BG49
M_A_DQ_46: U3.T14 UC1.BF48
M_A_DQ_47: U3.R14 UC1.BD48
M_A_DQ_48: U3.N2 UC1.BJ55
M_A_DQ_49: U3.P2 UC1.BL55
M_A_DQ_50: U3.P3 UC1.BJ53
M_A_DQ_51: U3.R2 UC1.BL53
M_A_DQ_52: U3.R3 UC1.BN55
M_A_DQ_53: U3.T3 UC1.BN53
M_A_DQ_54: U3.N3 UC1.BM52
M_A_DQ_55: U3.T2 UC1.BK52
M_A_DQ_56: U3.T10 UC1.BL51
M_A_DQ_57: U3.T9 UC1.BJ51
M_A_DQ_58: U3.T11 UC1.BL49
M_A_DQ_59: U3.R9 UC1.BJ49
M_A_DQ_60: U3.R11 UC1.BN49
M_A_DQ_61: U3.R10 UC1.BN51
M_A_DQ_62: U3.N10 UC1.BK48
M_A_DQ_63: U3.P10 UC1.BM48
M_A_DQS_DN_0: U3.J13 UC1.AJ61
M_A_DQS_DN_1: U3.D15 UC1.AP62
M_A_DQS_DN_2: U3.G13 UC1.AP56
M_A_DQS_DN_3: U3.M15 UC1.AJ57
M_A_DQS_DN_4: U3.N7 UC1.BD54
M_A_DQS_DN_5: U3.R12 UC1.BF50
M_A_DQS_DN_6: U3.R4 UC1.BM54
M_A_DQS_DN_7: U3.N9 UC1.BK50
M_A_DQS_DP_0: U3.J14 UC1.AJ63
M_A_DQS_DP_1: U3.D16 UC1.AP60
M_A_DQS_DP_2: U3.G14 UC1.AP58
M_A_DQS_DP_3: U3.M16 UC1.AJ55
M_A_DQS_DP_4: U3.P7 UC1.BF54
M_A_DQS_DP_5: U3.T12 UC1.BD50
M_A_DQS_DP_6: U3.T4 UC1.BK54
M_A_DQS_DP_7: U3.P9 UC1.BM50
M_A_ODT0: U3.H13 U3.N8 UC1.BN61
M_B_CA_0_0: U4.B5 UC1.BK30
M_B_CA_0_1: U4.C5 UC1.BN31
M_B_CA_0_2: U4.D5 UC1.BM32
M_B_CA_0_3: U4.B6 UC1.BL37
M_B_CA_0_4: U4.C6 UC1.BG31
M_B_CA_0_5: U4.C9 UC1.BN37
M_B_CA_0_6: U4.D9 UC1.BJ37
M_B_CA_0_7: U4.B10 UC1.BJ35
M_B_CA_0_8: U4.C10 UC1.BM34
M_B_CA_0_9: U4.D10 UC1.BN35
M_B_CA_1_0: U4.L2 UC1.BG37
M_B_CA_1_1: U4.L3 UC1.BE37
M_B_CA_1_2: U4.L4 UC1.BC37
M_B_CA_1_3: U4.K2 UC1.BF34
M_B_CA_1_4: U4.K3 UC1.BC33
M_B_CA_1_5: U4.G3 UC1.BF30
M_B_CA_1_6: U4.G4 UC1.BD36
M_B_CA_1_7: U4.F2 UC1.BG35
M_B_CA_1_8: U4.F3 UC1.BC31
M_B_CA_1_9: U4.F4 UC1.BF36
M_B_CK_DDR0_DN: U4.H2 UC1.BK36
M_B_CK_DDR0_DP: U4.H3 UC1.BM36
M_B_CK_DDR1_DN: U4.C8 UC1.BD32
M_B_CK_DDR1_DP: U4.B8 UC1.BF32
M_B_CKE0: U4.J3 UC1.BN33
M_B_CKE1: U4.J4 UC1.BK32
M_B_CKE2: U4.C7 UC1.BG33
M_B_CKE3: U4.D7 UC1.BH30
M_B_CS0_N: U4.D6 U4.K4 UC1.BM30
M_B_CS1_N: U4.B7 U4.J2 UC1.BJ33
M_B_DQ_0: U4.D13 UC1.BC41
M_B_DQ_1: U4.E13 UC1.BC39
M_B_DQ_2: U4.E15 UC1.BG41
M_B_DQ_3: U4.E14 UC1.BE39
M_B_DQ_4: U4.F15 UC1.BF42
M_B_DQ_5: U4.F16 UC1.BD42
M_B_DQ_6: U4.F14 UC1.BG39
M_B_DQ_7: U4.E16 UC1.BE41
M_B_DQ_8: U4.N15 UC1.BC43
M_B_DQ_9: U4.M14 UC1.BD46
M_B_DQ_10: U4.M13 UC1.BG43
M_B_DQ_11: U4.N16 UC1.BG45
M_B_DQ_12: U4.N14 UC1.BC45
M_B_DQ_13: U4.L13 UC1.BE43
M_B_DQ_14: U4.P15 UC1.BE45
M_B_DQ_15: U4.P16 UC1.BF46
M_B_DQ_16: U4.N4 UC1.BM28
M_B_DQ_17: U4.P5 UC1.BN27
M_B_DQ_18: U4.N5 UC1.BK28
M_B_DQ_19: U4.R6 UC1.BL25
M_B_DQ_20: U4.T5 UC1.BN25
M_B_DQ_21: U4.P6 UC1.BL27
M_B_DQ_22: U4.T6 UC1.BJ25
M_B_DQ_23: U4.R5 UC1.BJ27
M_B_DQ_24: U4.N11 UC1.BM24
M_B_DQ_25: U4.R13 UC1.BK24
M_B_DQ_26: U4.P13 UC1.BN21
M_B_DQ_27: U4.R14 UC1.BJ23
M_B_DQ_28: U4.P12 UC1.BL23
M_B_DQ_29: U4.N12 UC1.BN23
M_B_DQ_30: U4.T14 UC1.BJ21
M_B_DQ_31: U4.T13 UC1.BL21
M_B_DQ_32: U4.K15 UC1.BN45
M_B_DQ_33: U4.K14 UC1.BM46
M_B_DQ_34: U4.K13 UC1.BL43
M_B_DQ_35: U4.L15 UC1.BK46
M_B_DQ_36: U4.J15 UC1.BN43
M_B_DQ_37: U4.K16 UC1.BL45
M_B_DQ_38: U4.L16 UC1.BJ45
M_B_DQ_39: U4.J16 UC1.BJ43
M_B_DQ_40: U4.C16 UC1.BM42
M_B_DQ_41: U4.C15 UC1.BN41
M_B_DQ_42: U4.C13 UC1.BJ41
M_B_DQ_43: U4.C14 UC1.BN39
M_B_DQ_44: U4.B16 UC1.BK42
M_B_DQ_45: U4.B15 UC1.BL41
M_B_DQ_46: U4.B14 UC1.BL39
M_B_DQ_47: U4.B13 UC1.BJ39
M_B_DQ_48: U4.P3 UC1.BF28
M_B_DQ_49: U4.N3 UC1.BD28
M_B_DQ_50: U4.T2 UC1.BG25
M_B_DQ_51: U4.N2 UC1.BC27
M_B_DQ_52: U4.R3 UC1.BG27
M_B_DQ_53: U4.P2 UC1.BE27
M_B_DQ_54: U4.R2 UC1.BE25
M_B_DQ_55: U4.T3 UC1.BC25
M_B_DQ_56: U4.P10 UC1.BF24
M_B_DQ_57: U4.T9 UC1.BD24
M_B_DQ_58: U4.T10 UC1.BG21
M_B_DQ_59: U4.R11 UC1.BC23
M_B_DQ_60: U4.R10 UC1.BE23
M_B_DQ_61: U4.R9 UC1.BG23
M_B_DQ_62: U4.T11 UC1.BC21
M_B_DQ_63: U4.N10 UC1.BE21
M_B_DQS_DN_0: U4.G13 UC1.BD40
M_B_DQS_DN_1: U4.M15 UC1.BD44
M_B_DQS_DN_2: U4.N7 UC1.BK26
M_B_DQS_DN_3: U4.R12 UC1.BM22
M_B_DQS_DN_4: U4.J13 UC1.BK44
M_B_DQS_DN_5: U4.D15 UC1.BM40
M_B_DQS_DN_6: U4.R4 UC1.BD26
M_B_DQS_DN_7: U4.N9 UC1.BF22
M_B_DQS_DP_0: U4.G14 UC1.BF40
M_B_DQS_DP_1: U4.M16 UC1.BF44
M_B_DQS_DP_2: U4.P7 UC1.BM26
M_B_DQS_DP_3: U4.T12 UC1.BK22
M_B_DQS_DP_4: U4.J14 UC1.BM44
M_B_DQS_DP_5: U4.D16 UC1.BK40
M_B_DQS_DP_6: U4.T4 UC1.BF26
M_B_DQS_DP_7: U4.P9 UC1.BD22
M_B_ODT0: U4.H13 U4.N8 UC1.BC35
MAG_DRDY: QT18.2 U20.9
MAG_I2C_ADD_SEL: R104.2 R110.1 U20.6
ME_FWP#: Q10.5 R171.2 R174.1 U27.J13
ME_SUS_PWR_ACK: RH59.1 T28.1(TP-1) U27.H2
MEC_XTAL1: C194.1 U27.A1 Y3.1
MEC_XTAL2: C195.1 U27.B1 Y3.2
MEM_CONFIG0: RH139.2 RH150.1 UC1.AN12
MEM_CONFIG1: RH145.2 RH149.1 UC1.AP9
MEM_CONFIG2: RH129.2 RH144.1 UC1.AN10
MEM_CONFIG3: RH184.1 RH185.2 UC1.AJ10
MIC1-VREFO_L: RA7.1 UA1.38
MIC1-VREFO_R: RA5.1 UA1.39
MIC1_L: L4.1 RA7.2 UA1.36
MIC1_R: L3.1 RA5.2 UA1.37
MONO_IN: CA20.2 UA1.23
MOTOR_N1: JVB1.2 R924.1
MOTOR_P1: DH5.1 JVB1.1 Q330.1
MUTI_ACIN_TAB: PR148.1 U27.N11
NB_MUTE#: DA7.2 U27.C6
NGFF1_CONFIG_0: JNGFF1.13 R1040.2 U27.G13
NGFF1_CONFIG_1: JNGFF1.61 R1045.2 U27.N13
NGFF1_CONFIG_2: JNGFF1.67 R1046.2 U27.G10
NGFF1_CONFIG_3: JNGFF1.1 R1047.2 U27.L9
NGFF_COEX1: JNGFF1.56 JNGFF3.40
NGFF_COEX2: JNGFF1.54 JNGFF3.38
NGFF_COEX3: JNGFF1.52 JNGFF3.36
NGFF_WWAN_PWREN: D11.2 UC1.BN4
NTC_REF: PC718.1 PR741.1 PU500.J10
OSC_IN: C113.1 R65.1 U16.B1 Y1.1
OSC_OUT: C114.1 R65.2 U16.A1 Y1.3
OUT1_CA_DET: R67.1 U23.43
OUT2_CA_DET: R106.1 U23.33
P_AGND: PC633.2 PC700.2 PC701.2 PC702.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC709.2 PC710.2 PC711.2 PC714.1 PC717.1 PC718.2 PR506.2 PR515.2 PR518.1 PR520.2 PR608.2 PR613.2 PR718.2 PR738.1 PU500.C4 PU500.C7 PU500.C8 PU500.D8 PU500.E5 PU500.E6 PU500.E7 PU500.E8 PU500.E10 PU500.E11 PU500.E12 PU500.F5 PU500.F11 PU500.G5 PU500.G12 PU500.G13 PU500.H5 PU500.J3 PU500.J9 PU500.J11 PU500.N3 PU500.N12 PU500.P3 PU500.P12
P_AGND_1: PC800.2 PC801.2 PC808.2 PC812.2 PC813.2 PC907.2 PC909.2 PC1008.2 PC1009.2 PC1010.2 PH1001.2 PH1002.2 PH1003.2 PR818.1 PR819.2 PR820.2 PR825.1 PR828.2 PR831.2 PR915.2 PR918.2 PR1012.2 PR1014.2 PR1015.2 PR1019.2 PR1025.2 PR1026.2 PR1027.2 PR1029.1 PU800.C8 PU800.D8 PU800.F1 PU800.F5 PU800.J6 PU800.K6 PU800.K7
P_SYS: C267.1 PR417.1 PR815.1 U27.M1
PA_USB2_RBIAS: R1392.2 UT1.H19
PANEL_BKEN_EC: D2.3 U27.F2
PB_USB2_RBIAS: R1393.2 UT1.F19
PBAT_PRES#: PR120.1 PR123.2 PR423.1
PBAT_SMBCLK: PR121.2 R1044.1 U27.C7
PBAT_SMBDAT: PR122.2 R1037.1 U27.D7
PBTN_OUT#_R: RH57.1 RH68.2 UC1.BF14
PC10: R185.2 R186.2 U23.56
PC11: R189.2 R190.2 U23.55
PC20: R187.2 R188.2 U23.54
PC21: R191.2 R194.2 U23.53
PCH_DDI1_AUXN: C133.1 UC1.H41
PCH_DDI1_AUXN_R: C133.2 U23.25
PCH_DDI1_AUXP: C112.1 UC1.F41
PCH_DDI1_AUXP_R: C112.2 U23.24
PCH_DDI1_CLK: RC6.2 UC1.L6
PCH_DDI1_DAT: RC16.2 UC1.H6
PCH_DDI1_HPD: RH1.2 U23.3 UC1.C11
PCH_DDI1_N0: C88.1 UC1.A46
PCH_DDI1_N0_R: C88.2 U23.7
PCH_DDI1_N1: C142.1 UC1.C48
PCH_DDI1_N1_R: C142.2 U23.10
PCH_DDI1_N2: C144.1 UC1.B45
PCH_DDI1_N2_R: C144.2 U23.13
PCH_DDI1_N3: C146.1 UC1.B47
PCH_DDI1_N3_R: C146.2 U23.16
PCH_DDI1_P0: C87.1 UC1.C46
PCH_DDI1_P0_R: C87.2 U23.6
PCH_DDI1_P1: C109.1 UC1.A48
PCH_DDI1_P1_R: C109.2 U23.9
PCH_DDI1_P2: C143.1 UC1.D45
PCH_DDI1_P2_R: C143.2 U23.12
PCH_DDI1_P3: C145.1 UC1.D47
PCH_DDI1_P3_R: C145.2 U23.15
PCH_DDI2_CLK: RC32.2 UC1.H4
PCH_DDI2_DAT: RC33.2 UC1.F4
PCH_DPWROK: RH56.1 RH67.2 T31.1(TP-1) U27.A5
PCH_DPWROK_R: C1.2 RH50.2 RH56.2 UC1.BN15
PCH_ENVDD: D1.2 UC1.D3
PCH_GPIOA7: RC90.1 TC106.1(TP-1) UC1.BF3
PCH_GPP_D11: RH120.1 UC1.T5
PCH_INV_PWM: D3.3 UC1.B6
PCH_JTAG_TCK: RC22.1 RC35.1 UC1.B53
PCH_JTAG_TDI: RC34.1 RC51.1 UC1.C50
PCH_JTAG_TDO: RC38.1 RC49.1 UC1.B51
PCH_JTAG_TMS: RC37.1 RC52.1 UC1.A52
PCH_JTAG_TRST#: RC62.1 UC1.C52
PCH_JTAGX: RC41.1 RC63.1 UC1.B49
PCH_MUTE#: DA7.3 UC1.AA8
PCH_OPIRCOMP: RC15.1 UC1.BP16
PCH_PLTRST#: RH40.2 RH41.1 RH47.2 U16.H2 UC1.BB8 UH1.1 UH1.2
PCH_PWR_EN: PR736.1 PR739.1 PR740.1 PU500.D6 U27.H13
PCH_RSMRST#: RC29.1 RH49.2 RH53.1 RH67.1 T27.1(TP-1) U27.N12
PCH_RSMRST#_R: RH53.2 UC1.BJ12
PCH_RTCX1: CH7.1 RH48.1 UC1.BN19 YH2.1
PCH_RTCX2: CH8.1 RH48.2 UC1.BP18 YH2.2
PCH_RTD3_CIO_PWR_EN: RT10.2 UC1.U8
PCH_RTD3_USB_PWR_EN: RT6.2 UC1.V5
PCH_SPI1_CLK: RC73.2 UC1.P9
PCH_SPI1_CS#: RC89.2 UC1.N6
PCH_SPI1_IO2: RC77.2 UC1.W12
PCH_SPI1_IO3: RC80.2 UC1.V7
PCH_SPI1_MISO: RC75.2 UC1.N8
PCH_SPI1_MOSI: RC76.2 UC1.P3
PCH_SPI_CLK: C135.1 CH43.1 JSPI1.8 R1035.1 RC55.1 RC72.1
PCH_SPI_CLK_R: RC72.2 UC1.AU10
PCH_SPI_CS0#: JSPI1.10 RC56.1 UC1.AU4
PCH_SPI_CS2#: R1036.1 R5714.1 R5739.1 UC1.AU8
PCH_SPI_CS2#_R: R1036.2 U15.20
PCH_SPI_IO2: JSPI1.12 RC26.1 RC57.1 UC1.AV11
PCH_SPI_IO3: JSPI1.14 RC58.1 UC1.AV13
PCH_SPI_SCLK: R1035.2 U15.19
PCH_SPI_SI: JSPI1.4 R1034.1 RC54.1 RC71.1 RC235.1
PCH_SPI_SI_MOSI: R1034.2 U15.21
PCH_SPI_SI_R: RC71.2 UC1.AT3
PCH_SPI_SO: JSPI1.6 R1033.1 RC53.1 UC1.AU12
PCH_SPI_SO_R: R1033.2 U15.24
PCH_SRTCRST#: CH6.1 RH45.2 T34.1(TP-1) UC1.BH18
PCH_STROBE_OUT: R63.1 RH27.1 UC1.N4
PCH_TBT_FORCE_PWR: RT7.2 UC1.V11
PCH_WWAN_WAKE#: R49.1 RH182.1 UC1.AJ12
PCIE_PRX_DTX_N5: JNGFF1.33 UC1.C24
PCIE_PRX_DTX_N7: JNGFF2.43 RH179.1
PCIE_PRX_DTX_N7_R: RH179.2 UC1.C26
PCIE_PRX_DTX_N8: JNGFF2.29 UC1.B25
PCIE_PRX_DTX_N9: JNGFF3.35 UC1.C28
PCIE_PRX_DTX_N10: C141.1 UC1.B27
PCIE_PRX_DTX_N10_C: C141.2 UR1.8
PCIE_PRX_DTX_P5: JNGFF1.35 UC1.A24
PCIE_PRX_DTX_P7: JNGFF2.41 RH180.1
PCIE_PRX_DTX_P7_R: RH180.2 UC1.A26
PCIE_PRX_DTX_P8: JNGFF2.31 UC1.D25
PCIE_PRX_DTX_P9: JNGFF3.33 UC1.A28
PCIE_PRX_DTX_P10: C138.1 UC1.D27
PCIE_PRX_DTX_P10_C: C138.2 UR1.7
PCIE_PTX_DRX_N5: CH35.1 JNGFF1.39
PCIE_PTX_DRX_N5_C: CH35.2 UC1.G24
PCIE_PTX_DRX_N7: CH23.1 JNGFF2.47
PCIE_PTX_DRX_N7_C: CH23.2 UC1.G26
PCIE_PTX_DRX_N8: CH25.1 JNGFF2.35
PCIE_PTX_DRX_N8_C: CH25.2 UC1.F25
PCIE_PTX_DRX_N9: CH27.1 JNGFF3.29
PCIE_PTX_DRX_N9_C: CH27.2 UC1.G28
PCIE_PTX_DRX_N10: CH21.1 UR1.4
PCIE_PTX_DRX_N10_C: CH21.2 UC1.F27
PCIE_PTX_DRX_P5: CH36.1 JNGFF1.41
PCIE_PTX_DRX_P5_C: CH36.2 UC1.J24
PCIE_PTX_DRX_P7: CH24.1 JNGFF2.49
PCIE_PTX_DRX_P7_C: CH24.2 UC1.J26
PCIE_PTX_DRX_P8: CH26.1 JNGFF2.37
PCIE_PTX_DRX_P8_C: CH26.2 UC1.H25
PCIE_PTX_DRX_P9: CH28.1 JNGFF3.27
PCIE_PTX_DRX_P9_C: CH28.2 UC1.J28
PCIE_PTX_DRX_P10: CH22.1 UR1.3
PCIE_PTX_DRX_P10_C: CH22.2 UC1.H27
PCIE_RBIAS: RT2.1 UT1.N16
PCIE_RCOMPN: RC88.2 UC1.A9
PCIE_RCOMPP: RC88.1 UC1.B10
PCIE_WAKE_I#: JNGFF1.46 JNGFF3.47 R107.2 R1055.1 U27.G11
PCIE_WAKE_O#: R1138.1 RH63.1 RT4.2 T32.1(TP-1) U27.G12
PD_EE_CLK: R5706.2 U717.A3 U718.6
PD_EE_CS#: R210.2 R5709.2 U717.B3 U718.1
PD_EE_DI: R5707.2 U717.B4 U718.5
PD_EE_DO: R213.2 R5708.2 U717.A4 U718.2
PD_EE_HOLD#: R215.2 U718.7
PD_EE_WP#: R214.2 U718.3
PD_MRESET_A: R1445.1 R5734.1 U717.E11
PD_MRESET_B: R1468.1 R5736.1 U719.E11
PDLDO: PC133.1 PD105.1 PD106.1 PD107.1 PD108.1 PR155.2 PU102.1
PECI_EC: R172.1 U27.A12
PEDET: JNGFF2.69 R1136.1 RH186.2 UC1.G11
PEQ: R196.2 R197.2 U23.8
PET0_N: C1255.2 UT1.V22
PET0_P: C1254.2 UT1.V23
PET1_N: C1252.2 UT1.P22
PET1_P: C1251.2 UT1.P23
PET2_N: C1257.2 UT1.K22
PET2_P: C1256.2 UT1.K23
PET3_N: C1258.2 UT1.F22
PET3_P: C1253.2 UT1.F23
PEWAKE#: JNGFF2.54 R107.1 R1377.1
PI0: R198.2 U23.60
PI1: R199.2 R203.2 U23.1
PLL_COMP1: C115.1 R69.1 U16.A3
PLL_COMP2: C117.2 R74.1 U16.A4
PLL_VDD: C107.1 U16.A5
PLT_RST#: JLPDE1.8 JNGFF1.42 R54.1 RC28.1 RH40.1 RH46.1 RT1.2 T24.1(TP-1) U13.1 U15.17 U27.K3 U712.1 UH1.4 UR1.1
PM_SYS_RESET#: JAPS2.13 RC36.1 RH52.1 T25.1(TP-1)
PMIC_INT#: PU500.D10 R167.1 U27.L3
PROXIMITY_OUT#: C1392.1 R83.2 U21.13 U27.D4
PS_SMBCLK: C1393.1 Q345.4 R84.2 U21.14
PS_SMBDAT: C1394.1 Q345.1 R85.2 U21.15
PWR1_ON: PC128.1 PR111.1 PR125.2 PR233.1
PWR2_ON: PC127.1 PR105.1 PR124.2 PR234.1
PWR_BTN_DOCK1#: QT19.1 R1434.2 R1462.2
PWR_BTN_DOCK2#: QT19.4 R1439.2 R1461.2
PWR_LED#: Q342.2 R22.2 U27.B3
PWR_LED#_R: C1428.1 JPB1.6 R1107.2
PWR_ON: R133.2 R134.2 U33.5 U41.3 U41.5
PWR_SW_IN#: C190.1 PR307.1 R175.2 R177.2 R1061.2 U27.C2
PWR_TB_DOCK#: R177.1 R1440.2
PWRBTN#: D23.1 JPB1.1 R175.1 SW1.1 SW1.3
PWRBTN#_HW: D23.2 U715.4
PWRGD_XDP: JXDP2.39 RC29.2
PWRPATH _DD: PQ212.3 PR250.2 R1063.2 U27.N2
PWRPATH_S1#: PR247.2 PR248.2 PU201.1 U27.D6
PWRPATH_S3#: PR237.2 PU203.2 U27.D5
PWRPATH_S6: PQ205.2 PR244.1 PR246.1 PU205.2 U27.K9
REG5: PC500.1 PC505.1 PC604.1 PC607.1 PC617.1 PC634.1 PC708.1 PU500.C9 PU500.C12 PU500.F13 PU500.G2 PU500.L2 PU500.M8 PU500.N6
REG33: PC702.1 PC703.1 PC704.1 PC705.1 PC706.1 PC707.1 PC710.1 PC711.1 PR711.2 PR734.1 PR735.1 PU500.C3 PU500.D3 PU500.G14 PU500.J12 PU500.K11 PU500.L11 PU500.M3 PU500.M12
REM_DIODE1_N: C191.2 C204.2 C209.1 Q27.3 Q30.1 Q30.2 U27.E13
REM_DIODE1_P: C191.1 C204.1 C209.2 Q27.1 Q27.2 Q30.3 U27.F13
REM_DIODE2_N: C192.2 R5761.2 U27.D13
REM_DIODE2_N_R: C220.1 Q28.1 Q28.2 R5761.1
REM_DIODE2_P: C192.1 R5762.2 U27.C13
REM_DIODE2_P_R: C220.2 Q28.3 R5762.1
REM_DIODE3_N: C193.2 C208.2 C221.1 Q29.3 Q31.1 Q31.2 U27.A13
REM_DIODE3_P: C193.1 C208.1 C221.2 Q29.1 Q29.2 Q31.3 U27.B13
RESET_OUT#: PU500.L4 RH44.2 T29.1(TP-1) UC1.BP14
REXT: R1101.1 U23.20
RING2: CA16.1 DA3.1 JHP1.4 JHP1.5 JHP1.6 L4.2 Q68.1
RREF: RR6.2 UR1.9
RTC_RST#: CH5.2 CLRP3.2 JAPS2.9 R5669.1 RH42.2 T33.1(TP-1) UC1.BN12
RTCRST_ON: Q340.2 R5719.1 U27.E2
RTD3_CIO_PWR_EN: R1411.1 RT10.1 UT1.F1
RTD3_USB_PWR_EN: R1412.1 RT6.1 UT1.D4
RUN_ON: R133.1 R135.1 R217.2 R1064.2 U27.D1
RUNPWROK: R176.2 U27.F1
S2_GATE-1: PU204.2 PU205.4
S_VSYNC: C1398.1 C1429.1 JCAM2.8 R79.1 R80.2
S_VSYNC_J1: JP1.15 R80.1
S_VSYNC_R: R79.2 U16.C1
SABTS: PR1000.1 PU800.H10
SAHGS: PQ1000.1 PU800.G10
SALGS: PR1004.1 PU800.D10
SALGS_1: PQ1000.8 PR1004.2
SAR_DPR: JNGFF1.17 Q43.1 U27.C5
SAR_DPR_R: Q43.3 R47.2
SASWS: PC1000.2 PL1001.1 PQ1000.9 PR1001.1 PR1002.1 PU800.F10
SC_ALERT#: JPOGO.70 MD6.1 MD6.9 Q347.6 R5750.2
SC_SMBCLK: JPOGO.18 MD6.2 MD6.8 Q348.3 R5751.2
SC_SMBDAT: JPOGO.16 MD6.4 MD6.7 Q348.6 R5752.2
SCLK: PR835.2 PU800.K3
SD_CD#: JCR1.9 UR1.30
SD_CLK: CR8.1 JCR1.5 RR12.2
SD_CLK_L: RR12.1 UR1.17
SD_CMD: CR21.1 JCR1.3 RR13.2
SD_CMD_L: RR13.1 UR1.19
SD_D2: CR19.1 JCR1.1 RR15.2
SD_D2_L: RR15.1 UR1.21
SD_D3: CR20.1 JCR1.2 RR14.2
SD_D3_L: RR14.1 UR1.20
SD_LN0_M: JCR1.17 UR1.25
SD_LN0_P: JCR1.16 UR1.26
SD_LN1_M: JCR1.19 UR1.23
SD_LN1_P: JCR1.20 UR1.22
SD_PWR_EN: R225.2 R5754.2 U32.3 UC1.BL4
SD_RCLK_M: CR23.1 JCR1.8 RR10.2
SD_RCLK_M_L: RR10.1 UR1.15
SD_RCLK_P: CR22.1 JCR1.7 RR11.2
SD_RCLK_P_L: RR11.1 UR1.16
SD_REG2: CR16.2 UR1.24
SDAT: PR836.2 PU800.K5
SDIO_RCOMP: RC60.2 UC1.BF1
SENSOR_I2C_CLK: C1417.2 JP1.5 RH78.2 U16.F6
SENSOR_I2C_DATA: C1418.2 JP1.7 RH79.2 U16.D6
SIO_EXT_SCI#: RC7.2 U27.C4 UC1.AW12
SIO_EXT_SMI#: R164.1 RH148.1 UC1.E11
SIO_EXT_SMI#_R: R164.2 U27.N5
SIO_EXT_WAKE#: RC202.2 U27.L7 UC1.AD3
SIO_PWRBTN#: JAPS2.11 RC66.1 RH57.2 T36.1(TP-1) U27.M13
SIO_RCIN#: RH14.1 U27.D11 UC1.BL10
SIO_SLP_A#: JAPS2.6 T9.1(TP-1) U27.N1 UC1.BE17
SIO_SLP_EN#: R1028.1 R1030.1 UH2.4
SIO_SLP_S0#: JAPS2.15 PU500.F7 R165.1 R1039.1 R5715.1 RH51.2
SIO_SLP_S0#_R: RH51.1 UC1.BC9
SIO_SLP_S3#: JAPS2.2 PU500.G6 R134.1 R1038.1 RT9.2 T8.1(TP-1) U27.L2 UC1.AY14
SIO_SLP_S4#: JAPS2.5 PU500.D9 PU500.F6 R1025.1 U27.A4 UC1.BF16
SIO_SLP_S5#: JAPS2.4 T6.1(TP-1) UC1.BH14
SIO_SLP_SUS#: PU500.B7 RH55.2 U27.M3
SIO_SLP_SUS#_L: RH55.1 UC1.BN10
SIO_SLP_WLAN#: T10.1(TP-1) U27.A8 UC1.BH16
SKTOCC#: RC11.1 UC1.B62
SKYCAM_CSI0_D: L30.4 R1121.1 UC1.F29
SKYCAM_CSI0_D#: L30.1 R1118.1 UC1.H29
SKYCAM_CSI0_D#_L: JP1.10 L30.2 R1118.2
SKYCAM_CSI0_D_L: JP1.12 L30.3 R1121.2
SKYCAM_CSI1_D: L31.4 R1128.1 UC1.H33
SKYCAM_CSI1_D#: L31.1 R1127.1 UC1.F33
SKYCAM_CSI1_D#_L: JP1.4 L31.2 R1127.2
SKYCAM_CSI1_D_L: JP1.6 L31.3 R1128.2
SKYCAM_CSI2_D: L32.4 R1133.1 UC1.G30
SKYCAM_CSI2_D#: L32.1 R1132.1 UC1.J30
SKYCAM_CSI2_D#_L: JP1.22 L32.2 R1132.2
SKYCAM_CSI2_D_L: JP1.24 L32.3 R1133.2
SKYCAM_CSI3_D: L33.4 R1135.1 UC1.G32
SKYCAM_CSI3_D#: L33.1 R1134.1 UC1.J32
SKYCAM_CSI3_D#_L: JP1.28 L33.2 R1134.2
SKYCAM_CSI3_D_L: JP1.30 L33.3 R1135.2
SKYCAM_CSI_CLK_D: L24.4 R1094.1 UC1.F31
SKYCAM_CSI_CLK_D#: L24.1 R1093.1 UC1.H31
SKYCAM_CSI_CLK_D#_L: JP1.16 L24.2 R1093.2
SKYCAM_CSI_CLK_D_L: JP1.18 L24.3 R1094.2
SKYCAM_I2C_CLK: RH73.2 U16.G5 UC1.AP7
SKYCAM_I2C_DATA: RH72.2 U16.F5 UC1.AP3
SKYCAM_USER_CSI0_D: L29.4 R1116.1 UC1.B35
SKYCAM_USER_CSI0_D#: L29.1 R1115.1 UC1.D35
SKYCAM_USER_CSI0_D#_L: J3.8 L29.2 R1115.2
SKYCAM_USER_CSI0_D_L: J3.6 L29.3 R1116.2
SKYCAM_USER_CSI1_D: L28.4 R1109.1 UC1.A36
SKYCAM_USER_CSI1_D#: L28.1 R1106.1 UC1.C36
SKYCAM_USER_CSI1_D#_L: J3.20 L28.2 R1106.2
SKYCAM_USER_CSI1_D_L: J3.18 L28.3 R1109.2
SKYCAM_USER_CSI_CLK_D: L23.4 R1092.1 UC1.A34
SKYCAM_USER_CSI_CLK_D#: L23.1 R1091.1 UC1.C34
SKYCAM_USER_CSI_CLK_D#_L: J3.14 L23.2 R1091.2
SKYCAM_USER_CSI_CLK_D_L: J3.12 L23.3 R1092.2
SLEEVE: CA17.1 DA4.1 JHP1.1 JHP1.2 JHP1.3 L3.2 QA1.3
SM_INTRUDER#: RH64.2 UC1.BG19
SMBALERT#: RH101.1 UC1.W8
SMBCLK: JXDP2.53 RH94.1 UC1.AC12
SMBDATA: JXDP2.51 RH95.1 UC1.W6
SML0ALERT#: RH98.1 UC1.AA6
SML0CLK: RH99.1 UC1.W4
SML0DATA: RH100.1 UC1.AC10
SML1_SMBCLK: RH96.1 U27.D3 UC1.AA4
SML1_SMBDAT: RH97.1 U27.A7 UC1.W10
SML1ALERT#: RH102.1 RH181.1 UC1.BB6
SOC_SATALED#: TC167.1(TP-1) UC1.H8
SOC_SVID_ALERT#: RC143.1 UC1.B58
SOC_SVID_ALERT#_R: PR838.2 RC142.2 RC143.2
SOC_SVID_CLK: RC145.1 UC1.A56
SOC_SVID_CLK_R: PR803.2 PR835.1 RC145.2
SOC_SVID_DAT: RC144.1 RC146.1 UC1.A58
SOC_SVID_DAT_R: PR802.2 PR836.1 RC146.2
SP7_SDWP: QR1.1 UR1.29
SPDIF_IN: TC19.1(TP-1) UA2.9
SPI1_CLK: JITOUCH.2 RC73.1
SPI1_CS#: JITOUCH.8 RC89.1
SPI1_INT#: JITOUCH.9 RC50.2 UC1.M7
SPI1_IO2: JITOUCH.6 RC77.1
SPI1_IO3: JITOUCH.7 RC80.1
SPI1_MISO: JITOUCH.4 RC75.1
SPI1_MOSI: JITOUCH.5 RC76.1
SPI_CLK_ROM1: RH89.1 U18.6
SPI_IO2_ROM1: RH106.1 U18.3
SPI_IO3_ROM1: RH108.1 U18.7
SPI_PCH_CLK: JSPI1.7 RC55.2 RH89.2
SPI_PCH_CS0#: JSPI1.9 RC56.2 U18.1
SPI_PCH_IO2: JSPI1.11 RC57.2 RH90.2 RH106.2
SPI_PCH_IO3: JSPI1.13 RC58.2 RH91.2 RH108.2 RH183.2
SPI_PCH_SI: JSPI1.3 RC54.2 RH107.2
SPI_PCH_SO: JSPI1.5 RC53.2 RH105.2
SPI_SI_ROM1: RH107.1 U18.5
SPI_SO_ROM1: RH105.1 U18.2
SPK_L+: CA45.1 DA6.2 JSPK2.1 RA75.2
SPK_L+_L: CA117.1 LA23.2 RA75.1 UA2.23
SPK_L-: CA52.1 DA6.3 JSPK2.2 RA76.2
SPK_L-_L: RA69.2 RA76.1 UA2.22
SPK_R+: CA42.1 DA5.3 JSPK1.2 RA74.2
SPK_R+_L: CA116.1 LA21.2 RA74.1 UA2.26
SPK_R-: CA41.1 DA5.2 JSPK1.1 RA73.2
SPK_R-_L: RA68.2 RA73.1 UA2.25
SPKR: RA21.1 RC83.2 UC1.AV3
SSD_PWR_EN: R136.1 R223.2 UC1.AF9
SSD_RST#: RH29.1 U712.2 UC1.AG12
SSD_RST#_Q: JNGFF2.50 R1032.1 U712.4
STROBE_IN: R63.2 U16.D2
SUS_PWR_DN: RH59.2 RH62.1 RH114.2 UC1.BL6
SUSACK#: RH60.1 T30.1(TP-1) U27.L1
SUSACK#_R: RH60.2 RH62.2 UC1.BF9
SUSCLK: C74.1 C171.1 C200.1 CH46.1 MC1.2 R40.2 R59.2 R64.2 RH76.2
SUSCLK_L: JNGFF1.60 R64.1
SW4: PC506.2 PL502.2 PQ500.9 PR503.1 PU500.K1
SW5: PC523.2 PL506.2 PQ501.9 PR514.1 PU500.A7
SW6: PC542.2 PL509.2 PQ502.9 PR519.1 PU500.K14
SW7: PC507.2 PL503.1 PR504.1 PU500.D13 PU500.D14
SW8: PC524.2 PL507.1 PR513.1 PU500.A4 PU500.B4
SW9: PC608.1 PL602.2 PR602.1 PU500.A11 PU500.B11
SW10: PC620.2 PL605.2 PQ600.9 PR607.1 PU500.G1
SW11: PC637.2 PL607.2 PQ601.9 PR611.1 PU500.P6
SW12: PC605.2 PL603.1 PR603.1 PU500.N9 PU500.P9
SYS_PRE#: JBAT100.7 PR305.2 PR306.1
SYS_PWROK: PU500.H6 RC67.1 RH113.2 T26.1(TP-1) UC1.J1
SYS_PWROK_XDP: JXDP2.47 RC9.2 RC67.2 RC235.2
SYS_RESET#: RH52.2 RH132.2 UC1.H2
SYSTHERM0: PR741.2 PR745.1 PU500.F10
TBT_BATLOW#: RT8.2 UC1.U12
TBT_BATLOW_N: R1402.1 RT8.1 UT1.F2
TBT_CIO_PLUG_EVENT#: RT5.2 UC1.V3
TBT_CIO_PLUG_EVENT_N: R1400.1 RT5.1 UT1.W2
TBT_CLKREQ_N: R1388.1 RH28.2 UC1.AV9 UT1.AC5
TBT_EE_CLK: R5706.1 U716.6 UT1.AB4
TBT_EE_CS_N: R1385.2 R5709.1 U716.1 UT1.AC3
TBT_EE_DI: R5707.1 U716.5 UT1.AB3
TBT_EE_DO: R1384.2 R5708.1 U716.2 UT1.AC4
TBT_EE_WP_N: R1383.2 U716.3 UT1.V1
TBT_FORCE_PWR: R1409.1 RT7.1 UT1.H4
TBT_HDMI_DDC_CLK: R1389.1 UT1.Y2
TBT_HDMI_DDC_DATA: R1390.1 UT1.Y1
TBT_HOLD_N: R1386.2 U716.7
TBT_I2C_SCL: R1398.1 U717.D2 U719.D2 UT1.U2
TBT_I2C_SDA: R1397.1 U717.D1 U719.D1 UT1.U1
TBT_PCIE_RX0_N: CH16.1 UT1.Y22
TBT_PCIE_RX0_N_C: CH16.2 UC1.G20
TBT_PCIE_RX0_P: CH17.1 UT1.Y23
TBT_PCIE_RX0_P_C: CH17.2 UC1.J20
TBT_PCIE_RX1_N: CH11.1 UT1.T22
TBT_PCIE_RX1_N_C: CH11.2 UC1.F19
TBT_PCIE_RX1_P: CH12.1 UT1.T23
TBT_PCIE_RX1_P_C: CH12.2 UC1.H19
TBT_PCIE_RX2_N: CH13.1 UT1.M22
TBT_PCIE_RX2_N_C: CH13.2 UC1.G22
TBT_PCIE_RX2_P: CH14.1 UT1.M23
TBT_PCIE_RX2_P_C: CH14.2 UC1.J22
TBT_PCIE_RX3_N: CH19.1 UT1.H22
TBT_PCIE_RX3_N_C: CH19.2 UC1.F21
TBT_PCIE_RX3_P: CH20.1 UT1.H23
TBT_PCIE_RX3_P_C: CH20.2 UC1.H21
TBT_PCIE_TX0_N: C1255.1 UC1.C20
TBT_PCIE_TX0_P: C1254.1 UC1.A20
TBT_PCIE_TX1_N: C1252.1 UC1.B19
TBT_PCIE_TX1_P: C1251.1 UC1.D19
TBT_PCIE_TX2_N: C1257.1 UC1.C22
TBT_PCIE_TX2_P: C1256.1 UC1.A22
TBT_PCIE_TX3_N: C1258.1 UC1.B21
TBT_PCIE_TX3_P: C1253.1 UC1.D21
TBT_PCIE_WAKE_N: R1399.1 RT4.1 UT1.W1
TBT_PERST_N: RT1.1 UT1.L4
TBT_RBIAS: R1387.2 UT1.H6
TBT_REFCLK_100_N: L62.3 R1417.1 UC1.H35
TBT_REFCLK_100_N_R: L62.4 R1417.2 UT1.T19
TBT_REFCLK_100_P: L62.2 R1410.1 UC1.F35
TBT_REFCLK_100_P_R: L62.1 R1410.2 UT1.V19
TBT_RESET_N: D100.2 D101.2 R1407.1 R5741.1 R5756.1 UT1.F4
TBT_RSENSE: R1387.1 UT1.J6
TBT_SLP_S3_N: R1401.1 RT9.1 UT1.D2
TBT_SNK0_AUX_N: C1396.2 UT1.W11
TBT_SNK0_AUX_N_L: C1396.1 R126.1 U23.29
TBT_SNK0_AUX_P: C1395.2 UT1.Y11
TBT_SNK0_AUX_P_L: C1395.1 R129.1 U23.28
TBT_SNK0_DDC_CLK: R1391.1 UT1.Y5
TBT_SNK0_DDC_DATA: R1394.1 UT1.R4
TBT_SNK0_HPD: R1413.1 R5675.2 U23.38 UT1.AA2
TBT_SNK0_ML0_N: C128.2 UT1.AC7
TBT_SNK0_ML0_N_L: C128.1 U23.39
TBT_SNK0_ML0_P: C134.2 UT1.AB7
TBT_SNK0_ML0_P_L: C134.1 U23.40
TBT_SNK0_ML1_N: C147.2 UT1.AC9
TBT_SNK0_ML1_N_L: C147.1 U23.36
TBT_SNK0_ML1_P: C136.2 UT1.AB9
TBT_SNK0_ML1_P_L: C136.1 U23.37
TBT_SNK0_ML2_N: C154.2 UT1.AC11
TBT_SNK0_ML2_N_L: C154.1 U23.34
TBT_SNK0_ML2_P: C152.2 UT1.AB11
TBT_SNK0_ML2_P_L: C152.1 U23.35
TBT_SNK0_ML3_N: C202.2 UT1.AC13
TBT_SNK0_ML3_N_L: C202.1 U23.31
TBT_SNK0_ML3_P: C155.2 UT1.AB13
TBT_SNK0_ML3_P_L: C155.1 U23.32
TBT_SNK1_AUX_N: C1270.2 UC1.J40
TBT_SNK1_AUX_P: C1269.2 UC1.G40
TBT_SNK1_DDC_CLK: R1395.1 UT1.Y8
TBT_SNK1_DDC_DATA: R1396.1 UT1.N4
TBT_SNK1_HPD: R1414.1 UC1.L10 UT1.Y6
TBT_SNK1_ML0_N: C1262.2 UC1.A42
TBT_SNK1_ML0_P: C1261.2 UC1.C42
TBT_SNK1_ML1_N: C1264.2 UC1.A44
TBT_SNK1_ML1_P: C1263.2 UC1.C44
TBT_SNK1_ML2_N: C1266.2 UC1.B41
TBT_SNK1_ML2_P: C1265.2 UC1.D41
TBT_SNK1_ML3_N: C1268.2 UC1.B43
TBT_SNK1_ML3_P: C1267.2 UC1.D43
TBT_SRC_CFG1: R1403.1 UT1.AA1
TBT_SRC_HPD: R1405.1 UT1.G1
TBT_SVR_IND: L63.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: JAR1.3 R1381.1 UT1.T4
TBT_TDI: JAR1.1 R1379.1 UT1.Y4
TBT_TDO: JAR1.4 R1382.1 UT1.W4
TBT_TEST_EN: RT11.2 UT1.E1
TBT_TEST_PWG: RT12.2 UT1.AB5
TBT_TMS: JAR1.2 R1380.1 UT1.V4
TBT_TMU_CLK_OUT: C1397.1 R1408.1 UT1.V2
TBT_XTAL_25_IN: C1260.1 UT1.D22 Y4.1
TBT_XTAL_25_OUT: C1259.1 UT1.D23 Y4.3
TBTA_AUX_N: C1282.2 UT1.W15
TBTA_AUX_P: C1280.2 UT1.Y15
TBTA_CA2HD_0_N: D81.1 JUSBC1.B10 UT1.A21
TBTA_CA2HD_0_P: D79.1 JUSBC1.B11 UT1.B21
TBTA_CA2HD_1_N: D82.2 JUSBC1.A10 UT1.B15
TBTA_CA2HD_1_P: D80.2 JUSBC1.A11 UT1.A15
TBTA_CC1: C289.1 D411.1 JUSBC1.A5 U717.K9 U717.L9
TBTA_CC2: C288.1 D414.2 JUSBC1.B5 U717.K10 U717.L10
TBTA_DBG_CTL1: R1449.2 U717.E4
TBTA_DBG_CTL2: R1459.2 U717.D5
TBTA_DC_SS: PQ100.5 PQ101.5 PR140.1
TBTA_DCIN: PC100.1 PC110.1 PC111.1 PC115.1 PC121.1 PL100.2 PQ100.1 PQ100.2 PQ100.3 PQ111.4 PR104.1 PR125.1
TBTA_DEBUG1: R1443.2 U717.L2
TBTA_DEBUG2: R1444.2 U717.K2
TBTA_DEG3_LSTX: R1482.2 R5722.2 U717.L3
TBTA_DEG4_LSRX: R1483.2 R5723.2 U717.K3
TBTA_DPSRC_AUX_N: C1282.1 R1480.2 U717.J2
TBTA_DPSRC_AUX_P: C1280.1 R1481.2 U717.J1
TBTA_HD2CA_0_N: C1278.1 D77.1 JUSBC1.A3
TBTA_HD2CA_0_P: C1276.1 D75.1 JUSBC1.A2
TBTA_HD2CA_1_N: C1274.1 D78.2 JUSBC1.B3
TBTA_HD2CA_1_P: C1272.1 D76.2 JUSBC1.B2
TBTA_HPD: R1416.1 R5674.2 U717.C10 UT1.M4
TBTA_HPD_EC: R5674.1 R5675.1 U27.B9
TBTA_I2C_ALERT#: R1404.1 U717.C1 UT1.J4
TBTA_I2C_D_N: D410.2 JUSBC1.B7 R5679.2
TBTA_I2C_D_N_R: R5679.1 U717.L7
TBTA_I2C_D_P: D409.1 JUSBC1.B6 R5678.2
TBTA_I2C_D_P_R: R5678.1 U717.K7
TBTA_LDO_BMC: C1328.1 U717.E1
TBTA_LSRX: R1418.1 R5689.1 R5721.1 R5723.1 UT1.A4
TBTA_LSRX_DEG4: R5721.2 U717.K4
TBTA_LSRX_R: R5689.2 R5691.1
TBTA_LSTX: R1421.1 R5670.1 R5688.1 R5720.1 R5722.1 UT1.A5
TBTA_LSTX_DEG3: R5720.2 U717.L4
TBTA_LSTX_R: R5688.2 R5690.1
TBTA_PD_SBU1: R1430.1 R5690.2 U717.K8
TBTA_PD_SBU2: R1431.1 R5691.2 U717.L8
TBTA_RESET_N: D100.1 U717.F11
TBTA_SBU1: D412.2 JUSBC1.A8 R1430.2
TBTA_SBU2: D413.1 JUSBC1.B8 R1431.2
TBTA_TX0_N: C1278.2 UT1.B19
TBTA_TX0_P: C1276.2 UT1.A19
TBTA_TX1_N: C1274.2 UT1.B17
TBTA_TX1_P: C1272.2 UT1.A17
TBTA_USB2_D_N: U717.K5 UT1.D20
TBTA_USB2_D_N_R: D408.2 ML6.1 R93.1 U717.L6
TBTA_USB2_D_P: U717.L5 UT1.E20
TBTA_USB2_D_P_R: D407.1 ML6.4 R94.1 U717.K6
TBTA_USB_OC0#: R1435.2 RH122.1 UC1.N12
TBTA_VBUS: C1337.1 C1359.2 C1362.2 C1365.2 C1366.2 C1423.1 CT1.1 D424.1 DI6.3 DI7.2 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 LT105.2 PC101.1 PC114.1 PD107.2 PL100.1
TBTA_VBUS_L: C1339.1 LT105.1 U717.A10 U717.B10 U717.H11 U717.J10 U717.J11 U717.K11
TBTB_AUX_N: C1283.2 UT1.W16
TBTB_AUX_P: C1281.2 UT1.Y16
TBTB_CA2HD_0_N: D89.1 JUSBC2.B10 UT1.B13
TBTB_CA2HD_0_P: D87.1 JUSBC2.B11 UT1.A13
TBTB_CA2HD_1_N: D90.2 JUSBC2.A10 UT1.A7
TBTB_CA2HD_1_P: D88.2 JUSBC2.A11 UT1.B7
TBTB_CC1: C291.1 D420.1 JUSBC2.A5 U719.K9 U719.L9
TBTB_CC2: C290.1 D421.2 JUSBC2.B5 U719.K10 U719.L10
TBTB_DBG_CTL1: R1454.2 U719.E4
TBTB_DBG_CTL2: R1460.2 U719.D5
TBTB_DC_SS: PD102.2 PQ107.5 PQ108.5 PR136.1
TBTB_DCIN: PC106.1 PC112.1 PC113.1 PC119.1 PC123.1 PL101.2 PQ107.1 PQ107.2 PQ107.3 PQ112.4 PR119.1 PR124.1
TBTB_DEBUG1: R1466.2 U719.L2
TBTB_DEBUG2: R1467.2 U719.K2
TBTB_DEG3_LSTX: R1485.2 R5726.2 U719.L3
TBTB_DEG4_LSRX: R1484.2 R5727.2 U719.K3
TBTB_DPSRC_AUX_N: C1283.1 R1478.2 U719.J2
TBTB_DPSRC_AUX_P: C1281.1 R1479.2 U719.J1
TBTB_EE_CLK: R1475.2 U719.A3
TBTB_EE_CS_N: R1477.2 U719.B3
TBTB_EE_DI: R1474.2 U719.B4
TBTB_EE_DO: R1476.2 U719.A4
TBTB_HD2CA_0_N: C1279.1 D85.1 JUSBC2.A3
TBTB_HD2CA_0_P: C1277.1 D83.1 JUSBC2.A2
TBTB_HD2CA_1_N: C1275.1 D86.2 JUSBC2.B3
TBTB_HD2CA_1_P: C1273.1 D84.2 JUSBC2.B2
TBTB_HPD: R1415.1 R1437.2 U27.F10 UT1.G2
TBTB_I2C_ALERT#: R1406.1 U719.C1 UT1.E2
TBTB_I2C_D_N: D418.2 JUSBC2.B7 R5680.2
TBTB_I2C_D_N_R: R5680.1 U719.L7
TBTB_I2C_D_P: D417.1 JUSBC2.B6 R5681.2
TBTB_I2C_D_P_R: R5681.1 U719.K7
TBTB_LDO_BMC: C1344.1 U719.E1
TBTB_LSRX: R1419.1 R5693.1 R5725.1 R5727.1 UT1.B5
TBTB_LSRX_DEG4: R5725.2 U719.K4
TBTB_LSRX_R: R5693.2 R5695.1
TBTB_LSTX: R1420.1 R5692.1 R5696.1 R5724.1 R5726.1 UT1.B4
TBTB_LSTX_DEG3: R5724.2 U719.L4
TBTB_LSTX_R: R5692.2 R5694.1
TBTB_PD_SBU1: R1457.1 R5694.2 U719.K8
TBTB_PD_SBU2: R1458.1 R5695.2 U719.L8
TBTB_RESET_N: D101.1 U719.F11
TBTB_SBU1: D419.2 JUSBC2.A8 R1457.2
TBTB_SBU2: D422.1 JUSBC2.B8 R1458.2
TBTB_TX0_N: C1279.2 UT1.B11
TBTB_TX0_P: C1277.2 UT1.A11
TBTB_TX1_N: C1275.2 UT1.B9
TBTB_TX1_P: C1273.2 UT1.A9
TBTB_USB2_D_N: U719.K5 UT1.D19
TBTB_USB2_D_N_R: D416.2 ML7.1 R95.1 U719.L6
TBTB_USB2_D_P: U719.L5 UT1.E19
TBTB_USB2_D_P_R: D415.1 ML7.4 R121.1 U719.K6
TBTB_USB_OC1#: R1438.2 RH125.1 UC1.M11
TBTB_VBUS: C1353.1 C1360.2 C1361.2 C1363.2 C1364.2 C1424.1 CT2.1 D425.1 DI6.2 DI7.3 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 LT106.2 PC105.1 PC118.1 PD108.2 PL101.1
TBTB_VBUS_L: C1355.1 LT106.1 U719.A10 U719.B10 U719.H11 U719.J10 U719.J11 U719.K11
TP_DDR_DRAM_RST_N: TC16.1(TP-1) UC1.BP20
TPM_DET: RH146.2 RH147.1 UC1.BJ4
TPM_GPIO0: R5715.2 U15.29
TPM_GPIO4: R5714.2 U15.13
TPM_IRQ#: RH126.1 U15.18 UC1.N10
TPM_LPM: Q344.1 R5713.1 R5716.1
TPM_LPM_R: R5713.2 U15.3
TS_EN: R220.2 U34.3 UC1.AW4
TS_I2C_SCL: R1015.1 RC82.1 UC1.AB11
TS_I2C_SDA: R1016.1 RC81.1 UC1.AB9
TS_INT#: R1017.1 RC10.2 UC1.T11
TS_INT#_R: DI5.3 JLVDS1.7 R1017.2
TS_PD#: JLVDS1.1 RC242.2 UC1.M9
TS_RST#: DI5.2 JLVDS1.10 R5757.2 RH151.1 UC1.H10
TX_BLANKING: JNGFF1.40 T17.1(TP-1)
UART2_CTS: RC203.2 TC87.1(TP-1) UC1.AD9
UART2_RXD: RC200.2 TC81.1(TP-1) UC1.AD5
UART2_TXD: RC201.2 TC83.1(TP-1) UC1.AD7
UART_MISO: R78.2 U717.F2 U719.E2
UART_MOSI: R5742.2 U717.E2 U719.F2
UF_AVDD_2.8V: C126.1 C127.1 C1246.1 C1410.1 C1432.1 J3.3 R118.2 R1075.1
UF_DVDD_1.2V: C149.1 C153.1 C165.1 C1414.2 J3.21 R116.2
UF_HCLK: C170.1 J3.7 R71.1
UF_HCLK_R: C254.1 R71.2 U16.C5
UF_I2C_CLK: C1400.2 J3.15 RH80.2 UC1.AN6
UF_I2C_DATA: C1399.2 J3.13 RH81.2 UC1.AN4
UF_SENSOR_RST#: R62.2 R92.2 R108.2 U16.C6
UF_VDD_1.8V: C125.1 C148.1 C1415.2 J3.19 R117.2
UIM_CLK: C83.1 D6.3 JNGFF1.24 JSIM1.3
UIM_DATA: C85.1 D6.6 JNGFF1.26 JSIM1.6
UIM_DET: DA2.1 JSIM1.8 R51.2 R53.2
UIM_DET#: JNGFF1.58 R53.1
UIM_RESET: C84.1 D6.1 JNGFF1.22 JSIM1.2
UPD1_I2C_ALERT#: R1083.1 U27.E4 U717.B6
UPD1_TD1_PS_SMBCLK: Q345.3 R1050.1 R1443.1 U27.B7 U717.B5
UPD1_TD1_PS_SMBDAT: Q345.6 R1049.1 R1444.1 U27.D2 U717.A5
UPD2_I2C_ALERT#: R1087.1 U27.L10 U719.B6
UPD2_TD2_EDP_SMBCLK: Q346.3 Q349.6 R1080.1 R1466.1 U27.L12 U719.B5
UPD2_TD2_EDP_SMBDAT: Q346.6 Q349.3 R1079.1 R1467.1 U27.M12 U719.A5
UPD_MRESET: R5732.2 R5734.2 R5736.2 R5741.2 U27.M9
USB2_COMP: RC87.1 UC1.N2
USB2_VBUSSENSE: RC136.1 UC1.AE6
USB3RN1: ML15.1 RH137.1 UC1.C16
USB3RN1_RC_CON: JDEBUG1.10 ML15.2 RH137.2
USB3RN2: ML12.1 R102.1 UC1.B15
USB3RN2_RC_CON: JNGFF1.21 ML12.2 R102.2
USB3RN3: ML4.1 R88.1 UC1.C18
USB3RN3_RC_CON: JCAM2.2 MD1.1 MD1.9 ML4.2 R88.2
USB3RN4: JPOGO.78 UC1.B17
USB3RP1: ML15.4 RH138.1 UC1.A16
USB3RP1_RC_CON: JDEBUG1.9 ML15.3 RH138.2
USB3RP2: ML12.4 R105.1 UC1.D15
USB3RP2_RC_CON: JNGFF1.23 ML12.3 R105.2
USB3RP3: ML4.4 R89.1 UC1.A18
USB3RP3_RC_CON: JCAM2.3 MD1.2 MD1.8 ML4.3 R89.2
USB3RP4: JPOGO.76 UC1.D17
USB3TN1: CH45.1 UC1.G16
USB3TN1_R: CH45.2 ML13.1 RH136.1
USB3TN1_RC_CON: JDEBUG1.7 ML13.2 RH136.2
USB3TN2: C137.1 UC1.F15
USB3TN2_R: C137.2 ML11.4 R101.1
USB3TN2_RC_CON: JNGFF1.27 ML11.3 R101.2
USB3TN3: C132.1 UC1.G18
USB3TN3_RC_CON: JCAM2.5 MD1.4 MD1.7 ML3.2 R87.2
USB3TN4: CH48.1 UC1.F17
USB3TN4_R: CH48.2 JPOGO.77
USB3TP1: CH44.1 UC1.J16
USB3TP1_R: CH44.2 ML13.4 RH133.1
USB3TP1_RC_CON: JDEBUG1.6 ML13.3 RH133.2
USB3TP2: C158.1 UC1.H15
USB3TP2_R: C158.2 ML11.1 R100.1
USB3TP2_RC_CON: JNGFF1.29 ML11.2 R100.2
USB3TP3: C131.1 UC1.J18
USB3TP3_RC_CON: JCAM2.6 MD1.5 MD1.6 ML3.3 R86.2
USB3TP4: CH47.1 UC1.H17
USB3TP4_R: CH47.2 JPOGO.75
USB20_N1: ML5.1 R82.1 UC1.AJ6
USB20_N1_R: D74.3 JPOGO.71 ML5.2 R82.2
USB20_N3: ML1.4 R37.1 UC1.AL6
USB20_N3_R: JNGFF3.5 ML1.3 R37.2
USB20_N5: ML2.4 R45.1 UC1.AH5
USB20_N5_R: JNGFF1.9 ML2.3 R45.2
USB20_N7: ML9.1 R1012.1 UC1.AF5
USB20_N7_CONN: DI4.3 JLVDS1.8 ML9.2 R1012.2 R1016.2 RC239.1
USB20_N9: ML14.4 R125.1 UC1.AG6
USB20_N9_R: JDEBUG1.4 ML14.3 R125.2
USB20_P1: ML5.4 R68.1 UC1.AJ4
USB20_P1_R: D74.2 JPOGO.69 ML5.3 R68.2
USB20_P3: ML1.1 R35.1 UC1.AL4
USB20_P3_R: JNGFF3.3 ML1.2 R35.2
USB20_P5: ML2.1 R44.1 UC1.AH3
USB20_P5_R: JNGFF1.7 ML2.2 R44.2
USB20_P7: ML9.4 R1013.1 UC1.AF3
USB20_P7_CONN: DI4.2 JLVDS1.9 ML9.3 R1013.2 R1015.2 RC238.1
USB20_P9: ML14.1 R124.1 UC1.AG4
USB20_P9_R: JDEBUG1.3 ML14.2 R124.2
USB_ID: RC91.1 UC1.AF7
USB_OC2#: RH123.1 UC1.F8
USB_OC3#: RH124.1 UC1.B8
USBC1_USB2_D_N_R: JUSBC1.A7 ML6.2 R93.2
USBC1_USB2_D_P_R: JUSBC1.A6 ML6.3 R94.2
USBC2_USB2_D_N_R: JUSBC2.A7 ML7.2 R95.2
USBC2_USB2_D_P_R: JUSBC2.A6 ML7.3 R121.2
VBOS: PC200.1 PC204.1 PC223.1 PC224.1 PC225.1 PC226.1 PC232.1 PD203.1 PQ202.1 PQ202.2 PQ202.3 PQ203.1 PQ203.2 PQ203.3 PQ207.1 PQ207.2 PQ207.3 PQ208.1 PQ208.2 PQ208.3 PR200.2 PR205.1 PR206.1 PR212.1 PR215.1 PR216.1 PR253.2 PU200.1 PU202.1
VCM_OUT_2.8V: C104.1 C119.1 C124.1 C1411.2 JP1.1 R75.2
VGATE: PR801.2 PU800.C9
VIBRATOR_EN#: C1164.1 Q330.2 R1082.1 U27.J2
VOUT4: PR505.2 PR509.2 PU500.L3
VPRO: RH177.1 RH178.1 UC1.U10
VSET_1641: C199.1 R193.1 U27.D12
WAKE#: RH63.2 UC1.BP9
WC_ACOK: R173.2 R1081.2
WF_AVDD_2.8V: C105.1 C120.1 C1412.2 C1431.1 JP1.23 R76.2
WF_DOVDD_1.8V: C106.1 C122.1 C1413.2 JP1.25 R77.2
WF_DVDD_1.2V: C110.1 C121.1 C123.1 C1416.2 JP1.27 R81.2
WF_HCLK: C169.1 JP1.11 R70.1
WF_HCLK_R: C207.1 R70.2 U16.D5
WF_SENSOR_RST#: R72.2 R73.2 R111.2 U16.E4
WF_SENSOR_RST#_L: C111.1 JP1.17 R72.1
WIFI_RF_KILL: RH119.1 TC69.1(TP-1) UC1.T7
WL_OFF#_R: D5.1 JNGFF3.48 R43.1
WLAN_EN: D10.1 R209.2 U30.3
WLAN_ON: D5.3 UC1.BB2
WLAN_PWR_EN: D10.2 UC1.AW10
WLAN_RST#: RH127.1 U13.2 UC1.F6
WLAN_RST#_Q: JNGFF3.44 R41.1 U13.4
WLAN_WIGIG60GHZ_DIS#: D5.2 U27.M11
WWAN_EN: D11.1 R238.2 U32.5
WWAN_OFF#: Q86.1 RH25.1 UC1.AG8
WWAN_OFF#_R: JNGFF1.8 Q86.6 R46.2
WWAN_PWR_OFF#: R50.2 UC1.AM11
WWAN_PWR_OFF#_R: C82.1 JNGFF1.6 R48.2 R50.1
WWAN_RST#: R56.1 RH128.1 UC1.AC8
WWAN_RST#_Q: JNGFF1.59 Q89.1 R61.2
WWAN_WAKE#: JNGFF1.15 R49.2
XCLK_BIASREF: RH32.1 UC1.P1
XDP_BPM#0: RC68.1 UC1.H51
XDP_BPM#1: RC65.1 UC1.J50
XDP_BPM#2_R: TC6.1(TP-1) UC1.F51
XDP_BPM#3_R: TC7.1(TP-1) UC1.G50
XDP_DBRESET#: CC161.2 JXDP2.48 RC36.2
XDP_ITP_PMODE: RC39.2 RC40.2 UC1.A60
XDP_OBS0: JXDP2.21 RC68.2
XDP_OBS1: JXDP2.23 RC65.2
XDP_PRDY#: JXDP2.5 T15.1(TP-1) UC1.D51
XDP_PREQ#: JXDP2.3 RC19.1 T16.1(TP-1) UC1.B55
XDP_PRSENT: JXDP2.60 RC26.2 RC237.1
XDP_RST#: JXDP2.46 RC28.2 RC39.1
XDP_TCK: JXDP2.57 RC27.2 RC63.2
XDP_TCK1: JXDP2.55 RC22.2
XDP_TDI: JXDP2.56 RC43.2 RC51.2
XDP_TDO: JXDP2.52 RC5.2 RC49.2
XDP_TMS: JXDP2.58 RC44.2 RC52.2
XDP_TRST#: JXDP2.54 RC12.2 RC62.2
XTAL24_IN: CH4.1 RH39.2 UC1.M1 YH1.3
XTAL24_OUT: CH3.1 RH39.1 UC1.L2 YH1.1
N387666: PR1015.1 PU800.D9
N387808: PR1006.1 PU800.F8
N387812: PR1007.1 PU800.G8
N388012: PR1016.1 PU800.G9
N388016: PR1016.2 PR1025.1
N388144: PR1017.1 PU800.F9
N388398: PR1018.1 PU800.E9
N388402: PR1018.2 PR1027.1
N388550: PR1019.1 PU800.E7
N389038: PH1001.1 PR1020.2 PU800.F6
N389071: PH1002.1 PR1021.2 PU800.G4
N389075: PH1003.1 PR1022.2 PU800.D4
N389103: PC1010.1 PR1020.1 PR1021.1 PR1022.1 PU800.J7
N389365: PR1012.1 PU800.F7
N389486: PC1009.1 PR1013.1 PU800.G6
N389491: PR1013.2 PR1014.1
N390129: PC1006.2 PC1007.2 PU800.H9
N390178: PC1008.1 PR1010.2
N390245: PC1005.2 PC1007.1 PR1009.2 PR1010.1 PR1011.1 PU800.H8
N390884: PC1004.1 PR1002.2 PR1003.1 PR1005.1 PR1006.2
N11072790: PC501.1 PC502.1 PC555.1 PL500.1 PU500.E13 PU500.E14
N11072808: PC507.1 PR501.2
N11072906: PC519.1 PC520.1 PC556.1 PL504.1 PU500.A5 PU500.B5
N11072914: PC524.1 PR511.2
N11087757: PC605.1 PR600.2
N11640528: PU500.K7 TC77.1(TP-1)
N11870202: PR703.1 PU500.H11
N12938664: PC709.1 PR711.1 PU500.H13
N12987082: PC608.2 PR601.1
N13642943: PC506.1 PR500.1
N14326592: PC800.1 PR816.2 PU800.J8 PU800.K8
N14365419: PC523.1 PR510.1
N14367233: PC521.1 PC522.1 PC553.1 PC559.1 PC560.1 PL505.2 PQ501.2 PQ501.3 PQ501.4 PQ501.10
N14384658: PC542.1 PR516.1
N14384859: PC540.1 PC541.1 PC554.1 PC561.1 PC562.1 PL508.2 PQ502.2 PQ502.3 PQ502.4 PQ502.10
N14401644: PC801.1 PR817.2 PU800.G1
N14433412: PC618.1 PC619.1 PC646.1 PL604.2 PQ600.2 PQ600.3 PQ600.4 PQ600.10
N14435020: PC620.1 PR605.1
N14435109: PC637.1 PR609.1
N14444552: PC630.1 PR608.1 PU500.G3
N14445031: PC644.1 PR613.1 PU500.M5
N14455165: PU800.D7 PU801.2
N14455169: PU800.C5 PU801.3
N14457435: PH1000.1 PR1003.2
N14458758: PC807.1 PR808.2 PR809.1 PR810.2 PR811.1
N14458814: PH800.1 PR809.2
N15733786: PR813.2 PR818.2 PU800.H5
N15737096: PC809.2 PC811.1 PR822.2 PR823.1 PR824.1 PU800.A3
N15739057: PC810.2 PC811.2 PU800.A4
N15739351: PC812.1 PR823.2
N15740039: PC813.1 PR830.1 PU800.E4
N15740054: PR828.1 PU800.D3
N15740815: PR830.2 PR831.1
N15741283: PR812.2 PR825.2 PU800.G5
N15743484: PC904.1 PR903.2 PR904.1 PR905.2 PR906.1
N15743506: PH900.1 PR904.2
N15743562: PU800.H1 PU901.2
N15743566: PU800.H3 PU901.3
N15744978: PC909.1 PR917.1 PU800.F4
N15744990: PR915.1 PU800.H4
N15745096: PR917.2 PR918.1
N15745290: PC905.2 PC906.1 PR909.2 PR910.1 PR911.1 PU800.G3
N15745420: PC906.2 PC908.2 PU800.E1
N15745514: PC907.1 PR910.2
N15746436: PC808.1 PR815.2 PR819.1 PR820.1 PU800.H6
N15749836: PR810.1 PU800.B4
N15749896: PR814.1 PU800.C3
N15750253: PR905.1 PU800.E3
N15750329: PR907.1 PU800.F3
N15771454: PC433.1 PR422.1 PU400.17
N15771478: PC410.2 PC411.1 PR402.2 PU400.1
N15771482: PC409.2 PC410.1 PR401.2 PU400.2
N15771644: PR409.2 PR411.2 PR414.1 PU400.5
N15771658: PC427.1 PR412.2 PU400.7
N15771662: PC428.1 PR415.2 PU400.8
N15771682: PR417.2 PR419.1 PU400.9
N15771750: PR416.2 PU400.10
N15771766: PR421.2 PR425.1 PU400.16
N15771786: PR423.2 PR426.2 PU400.15
N15771812: PR420.1 PU400.18
N15773152: PR418.1 PU400.21
N15773942: PR407.2 PU400.11
N15773946: PR408.2 PU400.12
N15844647: PD400.1 PD401.1 PR403.1
N15915843: CC59.2 CC60.2 CC61.1 RC167.2 UC1.AT29 UC1.AT30
N15989959: PR209.2 PR210.2 PR214.1 PU207.7
N15989983: PC219.1 PR213.2 PR217.1 PU207.6
N15989995: PC206.2 PR209.1 PR211.2 PR212.2 PU207.5
N15991505: PQ205.3 PR207.2
N15991509: PC208.1 PR214.2 PU203.1
N16003749: PL400.1 PR400.4
N16014765: PC517.1 PR503.2
N16017101: PC538.1 PR514.2
N16020352: PC548.1 PR519.2
N16021716: PC516.1 PR504.2
N16026836: PC537.1 PR513.2
N16031507: PC606.1 PR602.2
N16035665: PC629.1 PR607.2
N16039304: PC643.1 PR611.2
N16041502: PC616.1 PR603.2
N16044927: PC804.1 PR805.2
N16047467: PC806.1 PR807.2
N16068697: PC903.1 PR902.2
N16069065: PC901.1 PR900.2
N16073129: PC908.1 PR911.2
N16073217: PR908.2 PR909.1
N16073644: PC1000.1 PR1000.2
N16074745: PR1008.2 PR1009.1
N16074829: PC1006.1 PR1011.2
N16132066: PQ104.3 PR102.2 PR109.1
N16153353: PR704.2 PR735.2 PU500.M4
N16156058: PR710.1 PR712.2 PU500.N4
N16156133: PR709.1 PR713.2 PU500.P4
N16156573: PC714.2 PR717.1 PU500.L8
N16156843: PC717.2 PU500.L9
N16160539: PC701.1 PR700.2 PU500.G11
N16160582: PU500.L6 TC72.1(TP-1)
N16160613: PU500.J8 TC74.1(TP-1)
N16160642: PU500.J7 TC73.1(TP-1)
N16160671: PU500.K9 TC79.1(TP-1)
N16161077: PU500.L12 TC75.1(TP-1)
N16167521: PR717.2 PU500.K10
N16216870: PC1003.1 PR1001.2
N16313034: PR804.2 PU800.E8
N16313116: PR714.1 PR715.1 PU500.D11
N16424198: PR736.2 PU500.H7
N16424234: PU500.D7 TC71.1(TP-1)
N16454224: PR832.1 PU800.C7
N16458110: PR833.1 PU800.D5
N16458114: PR834.1 PU800.C4
N16458329: PR919.1 PU800.H2
N16458484: PR920.1 PU800.E2
N16458488: PR921.1 PU800.F2
N16784816: Q89.6 R54.2 R56.2
N16784922: CA20.1 CA21.1 R33.1 RA18.2 RA21.2
N16803391: R76.1 U16.B7
N16803911: R75.1 U16.H4
N16803963: R77.1 U16.D7
N16823076: C1286.1 C1401.1 C1402.1 L64.1 R5745.2 UT1.R13
N17205976: JDEG1.1 R192.2
N17240153: R222.1 U34.8 U34.9
N17240183: C237.1 U34.10
N17242608: R202.1 U41.8 U41.9
N17242618: C213.1 U41.10
N17243834: R224.1 U32.13 U32.14
N17243850: C247.1 U32.12
N17302212: C239.1 U33.12
N17302218: R327.1 U33.13 U33.14
N17303773: R1070.1 U32.8 U32.9
N17303797: C1238.1 U32.10
N17362824: JVOL1.1 R1071.2
N17364218: JVOL1.2 R1072.2
N17376212: PR733.2 PR734.2 PU500.L5
N17378835: PR737.2 PU500.K8
N17426516: PR837.1 PU800.J5
N17436424: PR746.1 PR747.1 PU500.G9
N17544228: CA104.1 UA2.19
N17544867: CA99.1 UA2.2
N17545095: CA90.1 UA2.28
N17545649: RA67.2 UA2.30
N17587353: CA111.1 LA20.2 RA68.1 UA2.24
N17587375: CA112.1 LA22.2 RA69.1 UA2.21
N17587387: LA22.1 UA2.39
N17587389: LA23.1 UA2.40
N17587465: LA21.1 UA2.45
N17587467: LA20.1 UA2.46
N17744387: R30.1 U711.8
N17744389: C1224.2 R30.2 R5705.1 U711.9
N17744537: R1014.1 U711.7
N17744638: C1224.1 U711.1
N17750417: RR9.2 UR1.28
N17794811: PC222.1 PQ212.1 PR243.1 PR250.1 PU206.2 PU208.3 PU208.4
N17980670: R38.1 U21.16
N17980673: R39.1 U21.17
N18114885: C1246.2 R1075.2 R1076.1 U713.2
N18123962: C118.2 R74.2
N18538645: JXDP2.1 RC31.2 RC48.2
N18719906: R91.2 U20.7 U20.8
N18720946: C1249.1 U20.21
N18800960: RA51.1 UA1.10
N18895517: PR229.1 PR243.2 PU206.5
N19065415: C1250.1 U20.24
N19349133: L21.2 U21.5
N19378285: JNGFF1.51 T38.1(TP-1)
N19378292: JNGFF1.53 T39.1(TP-1)
N19378299: JNGFF1.55 T40.1(TP-1)
N19378306: JNGFF1.57 T41.1(TP-1)
N19388147: RH76.1 UC1.BA15
N19442506: D95.1 JANT1.1 L21.1
N19442543: JANT1.2 JANT1.3 JANT1.4 U21.1
N19518245: C53.1 C54.1 U715.1
N19518277: C1248.1 U715.3
N19518297: C55.1 R182.2 R218.2 U715.6
N19639537: C232.2 R219.2 U37.1 U37.2
N19643413: R211.1 U38.7 U38.8
N19643415: C234.1 U38.6
N19643437: C253.2 R228.2 U38.1 U38.2
N19655746: PC124.2 PQ108.4 PR108.1 PR141.2
N19659677: PQ112.2 PR131.2 PR132.1
N19725601: PC122.2 PQ101.4 PQ103.1 PR107.1 PR139.2
N19726626: PC121.2 PQ100.4 PQ105.1 PQ111.3 PR102.1 PR104.2 PR145.1
N19758591: PC217.1 PR240.2 PR242.2 PU208.5
N19795095: PC231.1 PR227.2 PR230.2 PU206.1 PU209.2
N19796536: PC230.1 PR225.2 PR229.2 PU206.7 PU209.1
N19805641: PC207.2 PR238.2 PU203.5
N19813199: PQ111.5 PQ111.6
N19813289: PQ111.2 PR118.2 PR129.1
N19818897: PC432.1 PR413.1
N19824530: PR226.1 PR245.2 PU209.4
N19868559: PR1017.2 PR1026.1
N19902287: PR738.2 PU500.F4
N19912057: PC713.2 PR740.2 PU500.H8
N19918206: PC712.2 PR739.2 PU500.G7
N20063017: Q25.1 R1217.1
N20122392: R116.1 U16.C7
N20122426: R117.1 U16.A6
N20124874: R118.1 U713.1
N20566621: QT20.5 QT20.6 R1074.2
N20604762: R1038.2 UH2.1
N20604774: R1039.2 R1224.2 UH2.2
N20978000: QT18.1 R398.1 R1048.2
N21033082: JPOGO.72 R143.1
N21063245: R60.1 U15.27
N21063249: R5717.1 U15.1
N21063326: R5718.1 U15.14 U15.22
N21077232: R206.1 U37.13 U37.14
N21077234: C225.1 U37.12
N21078155: R234.1 U37.8 U37.9
N21078167: C273.1 U37.10
N21234656: R216.1 U33.8 U33.9
N21436900: JNGFF2.68 R59.1
N21793938: PR718.1 PU500.F8
N22206076: PC215.1 PQ209.2 PR223.1 PR224.1
N22206124: PQ206.2 PQ211.2 PR202.2 PR231.2
N22206126: PQ206.3 PR231.1
N22206285: PR200.1 PR204.1 PU200.4
N22206891: PQ206.5 PR232.2
N22207134: PQ206.6 PR223.2
N22211458: PQ110.3 PR107.2 PR110.1
N22219567: PC123.2 PQ107.4 PQ112.3 PR116.1 PR119.2
N22223021: PQ112.5 PQ112.6
N22231891: C1358.1 U719.H7
N22231917: R1473.1 U719.G2
N22235149: C1343.1 U717.H7
N22235165: R5684.1 R5685.1 R5759.1 U717.F10
N22235177: R1450.1 U717.G2
N22260243: PQ204.2 PU204.4
N22283370: D8.3 RA33.1
N22283372: D8.2 RA32.1
N22292307: PC220.1 PD201.1 PD202.1 PQ210.2
N22316260: PR821.2 PR822.1
N22316276: PC810.1 PR824.2
N22383371: R1434.1 U717.D7
N22383378: R1435.1 U717.H6
N22383733: R1437.1 U719.C10
N22383735: R1439.1 U719.D7
N22383737: R1438.1 U719.H6
N22391071: PD201.2 PR233.2 PR235.2
N22391100: PD202.2 PR234.2 PR236.2
N22401321: PQ110.5 PR143.1
N22407862: PQ109.5 PR147.1
N22417276: PC116.1 PR133.2 PR134.1 PU100.2
N22417312: PC117.2 PR117.2 PR128.1 PR136.2 PU100.3
N22422694: PC125.2 PR130.1 PR140.2 PR142.2 PU100.5
N22422788: PC126.1 PR137.1 PR138.2 PU100.6
N22435782: PQ109.6 PR112.1 PR116.2
N22435889: PQ109.3 PR108.2
N22440956: PQ109.2 PR135.2
N22441712: PQ103.2 PR106.2 PR127.1
N22492141: PQ110.2 PR144.2
N22492313: PQ110.6 PR127.2
N22493133: TC28.1(TP-1) U717.G4
N22493136: TC24.1(TP-1) U717.F4
N22493152: TC29.1(TP-1) U719.G4
N22493166: TC25.1(TP-1) U719.F4
N22493234: TC34.1(TP-1) U719.D10
N22493298: TC37.1(TP-1) U719.G10
N22493300: TC36.1(TP-1) U719.E10
N22493318: TC38.1(TP-1) U719.G11
N22493409: TC39.1(TP-1) U717.D10
N22493425: TC41.1(TP-1) U717.E10
N22493427: TC42.1(TP-1) U717.G10
N22493429: TC43.1(TP-1) U717.G11
N22494332: PQ104.5 PR103.2
N22511338: PQ104.6 PR145.2
N22511366: PC130.1 PQ104.2 PR146.2 PR148.2
N22631833: JNGFF3.42 R40.1
N22902923: PQ214.2 PQ214.3 PR241.2 PR248.1
N22903845: TC40.1(TP-1) U717.B2
N22903866: R1432.1 U717.C2
N23173944: QT19.2 R1463.2
N23173956: QT19.5 R1464.2
N23173999: QT19.3 QT19.6 R1440.1
N23260134: PR146.1 PU101.4
N23265666: PC223.2 PQ202.4 PR201.2 PR205.2
N23266057: PQ204.3 PR201.1
N23267237: PC224.2 PQ203.4 PR203.1 PR206.2 PR249.1
N23267569: PQ204.6 PR203.2
N23269982: PC225.2 PQ207.4 PR207.1 PR215.2
N23270361: PQ205.6 PR208.2
N23270518: PC226.2 PQ208.4 PR208.1 PR216.2
N23286560: PR829.1 PU500.J5
N23294129: PQ214.6 PR249.2
N23314109: PC209.1 PQ214.5 PR228.1
N23341117: Q340.1 R5669.2
N23346401: R135.2 R136.2 U34.5
N23354249: Q341.5 Q341.6 R18.2
N23354257: Q341.3 R1104.1
N23354742: Q342.3 R1107.1
N23355623: Q342.5 Q342.6 R21.2
N23551801: PR251.1 PU203.4
N23646933: PR252.1 PR253.1 PU202.4
N23704108: PD102.1 PQ105.3 PR158.1
N23704163: PQ105.2 PR157.1 PR158.2
N23705603: PQ120.6 PR157.2
N23707230: PQ120.2 PR159.1
N23733930: R5683.2 U719.F1
N23735438: R5686.1 R5687.1 R5760.1 U719.F10
N23738255: PD205.2 PR257.1 PU202.5
N23741494: PQ109.4 PQ120.3 PR113.1
N23741962: PQ120.5 PR160.1 PR162.1
N23762904: PQ300.1 PR302.2 PU300.3
N23762935: PR307.2 PU300.1
N23762943: PD301.1 PD302.1 PR302.1 PR303.1 PR304.1 PU300.8
N23762945: PC300.1 PR304.2 PU300.7
N23762996: PR303.2 PU300.2
N23763035: PQ300.2 PR300.2 PR301.1
N23764093: PR305.1 PU300.5
N23795786: QT21.5 QT21.6 R5703.2
N23810550: PC716.1 PR742.2 PU500.L10
N23831252: PC422.1 PQ402.3 PR404.2 PR405.1 PU400.6
N23832036: PQ402.5 PQ402.6 PR428.2
N23832206: PD402.1 PD403.1 PQ402.2
N23913209: PQ115.5 PR150.2
N23913329: PC131.1 PQ113.2 PR149.1 PR151.1
N23913347: PQ114.2 PQ115.2 PR152.2 PR153.2
N23913349: PQ115.3 PR152.1
N23913377: PQ115.6 PR151.2
N23913442: PC135.1 PR155.1 PU102.4
N24067725: R1436.1 U719.C2
N24067748: TC35.1(TP-1) U719.B2
N24108706: R5682.2 U717.F1
N24437699: R5729.1 U721.7 U721.8
N24437701: C1389.1 U721.6
N24597122: Q344.2 R5739.2
N24921198: D406.1 R716.1 R5758.2
N25304790: PD204.1 PR254.1 PR259.2
N25431332: RC140.1 UC1.AA26 UC1.AC26
N26458468: RH186.1 UC1.J11
N26494340: PR719.1 PU500.K12
N44370994: C236.1 U34.12
N44535135: C214.1 U30.10
N45346942: C227.1 U33.10
N47519532: R24.1 U7.1
N51581707: R204.1 U31.7 U31.8
N51581718: C217.1 U31.6
N51584481: R221.1 U34.13 U34.14
N51592304: R205.1 U30.8 U30.9
N51600655: R227.1 U36.13 U36.14
N51600691: R229.1 U36.8 U36.9
N51600744: C244.1 U36.12
N51600766: C245.1 U36.10
N53869491: C198.1 R180.2
N54227584: R5.1 U4.E2
N54227586: R4.1 U4.B11
N54714782: R3.1 U3.B11
N54714783: R2.1 U3.E2
N55958256: CA26.1 CA27.1 UA1.43
N55958521: CA30.1 CA31.1 UA1.21
N55958533: CA33.1 UA1.44
N55958539: CA34.1 UA1.41
N55958618: CA15.1 LA3.2 UA1.46
N55958653: CA9.1 LA2.2 UA1.51
N55960562: Q68.2 QA1.5 QA1.6 RA15.2
N55960594: QA1.2 RA13.2 RA17.2 RA19.1
N55967094: C116.1 R69.2
N55977579: C132.2 ML3.1 R87.1
N55977609: C131.2 ML3.4 R86.1
N56067860: CA22.1 CA23.1 UA1.18
N56068412: CA25.1 UA1.29
N56068450: CA24.1 UA1.31
N56068743: CA18.1 UA1.25
N56068745: CA18.2 UA1.26
N56068751: CA19.2 UA1.28
N56068753: CA19.1 UA1.27
N56194338: C7.2 R13.1
N56194376: C8.2 R17.1
N56194392: C6.2 R12.1
N57436918: R212.1 U30.13 U30.14
N57436928: C224.1 U30.12
N57439320: C1230.1 U40.12
N57439346: C1231.1 U40.10
N57439824: R1025.2 U40.3
N57468042: R1028.2 U709.4
N57468046: R1027.1 U709.6
N57468960: R1030.2 U710.4
N57468964: R1029.1 U710.6
N57645204: C261.2 R231.2 U41.1 U41.2
N57645414: C263.1 U41.12
N125071922: TC3.1(TP-1) UC1.M5
N125164302: TC63.1(TP-1) UC1.BF7
N125184377: CC31.1 UC1.AT18 UC1.AV18
N125185663: TC129.1(TP-1) UC1.B4
N125185665: TC131.1(TP-1) UC1.B3
N125185667: TC133.1(TP-1) UC1.F3
N125185669: TC135.1(TP-1) UC1.F1
N125185671: TC137.1(TP-1) UC1.L36
N125185842: TC148.1(TP-1) UC1.D49
N125185844: TC149.1(TP-1) UC1.M21
N125185848: TC153.1(TP-1) UC1.M19
N125185850: TC155.1(TP-1) UC1.L26
N125185953: TC111.1(TP-1) UC1.BL64
N125186153: TC119.1(TP-1) UC1.R12
N125186155: TC120.1(TP-1) UC1.P13
N125186157: TC121.1(TP-1) UC1.M15
N125186159: TC122.1(TP-1) UC1.L16
N125186161: TC123.1(TP-1) UC1.L18
N125186163: TC124.1(TP-1) UC1.M17
N125186165: TC126.1(TP-1) UC1.K12
N125186167: TC128.1(TP-1) UC1.H12
N125186171: TC130.1(TP-1) UC1.BN3
N125186173: TC132.1(TP-1) UC1.BP3
N125186177: TC136.1(TP-1) UC1.M23
N125186179: TC140.1(TP-1) UC1.AY20
N125186183: TC138.1(TP-1) UC1.BN1
N125186366: RC153.1 UC1.BB14
N125186425: TC150.1(TP-1) UC1.L28
N125186427: TC152.1(TP-1) UC1.M27
N126479310: TC4.1(TP-1) UC1.L4
N126490868: Q10.2 Q10.3 R1.1
N126490934: Q10.1 RH26.1
N126538537: RH54.1 TC67.1(TP-1)
N1782815210: R34.2 U21.11
N1782815211: R36.2 U21.12
