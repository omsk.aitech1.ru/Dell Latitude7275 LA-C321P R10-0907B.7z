# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CKE1: length 23.8
  IN2 w0.06: 115.96,110.96 116.51,110.4 117.22,110.4 117.23,110.39 117.4,110.39 117.49,110.48 117.65,110.48 117.66,110.47 117.67,110.47 117.76,110.38 117.76,110.35 117.76,110.35 117.76,110.26 117.89,110.13 117.9,110.13 118.09,109.94 v2(118.3,109.94) ; 115.53,111.4 115.54,111.39
  IN2 w0.076: 115.54,111.39 115.96,110.96 ; v2(108.14,114.95) 108.25,114.84 108.39,114.84 108.5,114.95 108.69,114.95 108.81,114.84 108.94,114.84 109.28,115.18 109.39,115.18 109.47,115.1 109.47,114.93 109.55,114.85 109.7,114.85 109.78,114.93 109.78,114.98 109.85,115.05 110.19,115.05 110.32,114.92 110.41,114.92 110.42,114.92 110.45,114.92 110.53,114.85 110.53,114.7 110.6,114.62 110.75,114.62 110.83,114.7 110.83,114.85 110.91,114.92 111,114.92 111,114.92 111.01,114.92 111.09,114.85 111.09,114.67 111.16,114.6 111.32,114.6 111.39,114.67 111.39,114.85 111.47,114.92 111.73,114.92 112.26,114.39 112.26,114.27 112.2,114.21 112.09,114.21 111.69,114.61 111.58,114.61 111.48,114.5 111.48,114.39 111.55,114.32 111.64,114.32 112.13,113.84 112.13,113.76 111.65,113.28 111.52,113.28 111.44,113.35 111.44,113.43 111.7,113.68 111.7,113.86 111.2,114.36 111.16,114.36 111.07,114.45 110.53,114.45 110.15,114.83 109.95,114.83 109.87,114.75 109.87,114.61 109.85,114.59 109.85,114.41 109.87,114.39 109.87,113.61 110.28,113.2 110.28,112.23 111.11,111.4 115.53,111.4
M_A_CKE2: length 24.6
  IN1 w0.06: v1(118.38,110.41) 118.25,110.41 118.11,110.55 117.89,110.55 117.81,110.46 117.48,110.46 117.45,110.44 117.45,110.44 117.4,110.39 117.23,110.39 117.15,110.46 116.99,110.46 116.95,110.43 116.54,110.43
  IN1 w0.061: 116.54,110.43 116.38,110.58 115.87,110.58 115.64,110.81 109.95,110.81 108.45,112.31 108.45,113.25 108.37,113.33 108.22,113.33 108.12,113.23 108.12,112.21 108.19,112.13 v18(108.19,111.98)
  IN2 w0.076: v2(110.14,117.45) 110.51,117.45 110.78,117.72 110.87,117.72 110.99,117.6 110.99,117.46 110.74,117.2 109.2,117.2 109.14,117.26 108.99,117.26 108.43,116.7 108.02,116.7 107.4,116.08 107.4,115.89 107.23,115.72 107.1,115.72 107.05,115.77 106.9,115.77 106.85,115.72 106.85,113.76 107.27,113.33 107.27,113.08 107.41,112.95 107.41,112.84 107.34,112.77 107.34,112.66 107.44,112.55 107.55,112.55 107.62,112.63 107.73,112.63 107.84,112.52 107.84,112.41 107.75,112.33 107.75,112.22 107.87,112.1 108.08,112.1 v18(108.19,111.98)
M_A_CKE3: length 22.2
  IN1 w0.06: v1(117.56,108.98) 117.77,108.98 118.01,109.22 118.01,109.38 117.76,109.63 117.76,109.7 117.64,109.82 117.48,109.82 117.4,109.74 117.23,109.74 116.9,110.07 116.72,110.07
  IN1 w0.061: 116.72,110.07 116.34,110.07 116.28,110.01 116.17,110.01 116.09,110.09 116.09,110.2 116.12,110.24 116.12,110.34 116.05,110.41 115.81,110.41 115.59,110.64 114.23,110.64 114.15,110.56 114.15,110.34 114.08,110.26 113.97,110.26 113.85,110.39 113.85,110.56 113.77,110.64 109.84,110.64 109.44,111.04 109.32,111.04 109.25,111.12 109.25,111.27 109.17,111.35 109.02,111.35 108.94,111.27 108.94,111.12 108.87,111.04 108.8,111.04 108.51,111.34 108.51,111.45 108.73,111.67 108.73,111.78 108.62,111.89 108.51,111.89 108.29,111.66 108.18,111.66 107.91,111.93 107.91,113.53 107.72,113.73 107.54,113.73 107.41,113.86 107.41,113.86 107.39,113.89 107.39,114.57 107.27,114.69 107.06,114.69 106.89,114.85 106.89,115.05 107.03,115.19 107.26,115.19 107.36,115.29 107.36,115.78 v18(107.16,115.98)
  IN2 w0.076: v2(109.64,117.45) 108.91,117.45 108.32,116.86 107.96,116.86 107.22,116.12 107.22,116.1 107.16,116.05 v18(107.16,115.98)
M_A_CS0_N: length 25.1
  IN1 w0.061: 107.67,116.93 107.67,116.89 107.87,116.69 108.55,116.69 109.05,116.19 109.21,116.19 109.23,116.18 109.23,116.18 109.36,116.04 109.36,115.83 108.64,115.1 v1(108.64,114.95) ; 107.67,116.93 107.63,116.89 107.4,116.89 107.34,116.83 106.78,116.83 105.89,115.94 105.89,114.65 106.52,112.67 108.2,110.4 109.31,110.03 110.2,109.75 113.6,109.75 113.86,109.49 113.86,109.2 114.2,108.86 114.84,108.86 115,109.02 116.14,109.02 116.27,108.89 116.98,108.89 v1(117.07,108.98) ; 107.67,116.93 107.69,116.96 107.69,117.07 107.62,117.14 107.62,117.25 107.72,117.36 107.83,117.36 107.93,117.26 108.04,117.26 108.15,117.36 108.15,117.47 108.05,117.57 108.05,117.68 108.16,117.79 108.26,117.79 108.34,117.71 108.45,117.71 108.56,117.82 108.56,117.95 108.64,118.03 108.79,118.03 108.86,117.95 108.86,117.8 108.95,117.72 109.41,117.72 v1(109.64,117.95)
M_A_CS1_N: length 25.4
  IN1 w0.06: 116.97,112.38 117.08,112.38 117.14,112.44 117.29,112.44 117.31,112.42 117.43,112.31 117.43,112.31 117.45,112.28 117.45,112.13 117.57,112.02 117.74,112.02 117.92,111.84 117.93,111.84 118.08,111.83 118.2,111.72 118.2,111.65 118.2,111.57 v1(118.38,111.4)
  IN1 w0.061: v18(108.68,115.89) 108.68,115.69 108.31,115.32 108.12,115.32 107.88,115.08 107.88,114.21 v1(108.13,113.95) ; v1(110.64,117.45) 110.98,117.45 111.13,117.3 111.13,117.08 110.83,116.79 110.24,116.2 109.99,116.2 109.89,116.09 109.89,115.8 110,115.69 110.1,115.69 110.17,115.61 110.17,115.41 110.09,115.32 109.98,115.32 109.85,115.45 v18(109.77,115.45) 109.77,115.18 109.84,115.11 109.84,115.06 109.86,115.04 109.86,114.86 109.76,114.76 109.76,114.37 109.85,114.28 109.85,113.87 110.02,113.71 110.73,113.71 110.9,113.87 110.9,114.57 111.05,114.72 111.22,114.72 111.22,114.73 111.3,114.73 111.49,114.91 111.49,115.64 111.56,115.72 111.71,115.72 111.79,115.64 111.79,114.91 111.87,114.84 112.02,114.84 112.1,114.91 112.1,115.64 112.17,115.72 112.32,115.72 112.4,115.64 112.4,114.91 112.48,114.84 112.63,114.84 112.7,114.91 112.7,115.79 112.78,115.87 112.93,115.87 113.01,115.79 113.01,114.91 113.09,114.84 113.2,114.84 115.65,112.38 116.97,112.38
  IN2 w0.076: v18(108.68,115.89) 108.87,115.7 109.52,115.7 v18(109.77,115.45)
M_A_DQ_0: length 29.6
  IN1 w0.06: v1(117.56,105.11) 117.35,105.11 117.27,105.19 117.27,105.19 117.15,105.31 116.98,105.31 116.93,105.26 116.6,105.26
  IN1 w0.061: 116.6,105.26 116.55,105.26 116.44,105.15 114.38,105.15 114.25,105.02 112.87,105.02 111.63,106.26 106.24,106.26 104.48,108.02 102.91,108.02 100.53,110.4 100.53,116.05 101.44,116.96 101.44,117.57 102.32,118.45 v1(103.64,118.45)
M_A_DQ_1: length 29.2
  IN1 w0.06: 116.57,105.56 116.99,105.56 117.15,105.56 117.23,105.63 117.24,105.63 117.24,105.64 117.39,105.64 117.6,105.43 v1(117.81,105.43)
  IN1 w0.061: v1(104.14,117.95) 104,117.95 103.74,117.69 103.02,117.69 102.77,117.95 102.36,117.95 101.82,117.4 101.82,116.83 100.9,115.92 100.9,110.54 103.04,108.4 104.66,108.4 106.43,106.63 111.77,106.63 113.01,105.39 114.07,105.39 114.19,105.51 116.29,105.51 116.34,105.56 116.57,105.56
M_A_DQ_2: length 26.5
  TOP w0.076: v1(102.46,117.72) 102.48,117.7 102.75,117.7 103.02,117.7 103.39,117.7 U3.J16
  IN1 w0.06: v1(117.31,106.08) UC1.AK62 116.81,106.08 116.74,106.02 116.28,106.02
  IN1 w0.061: 116.28,106.02 115.48,106.02 115.31,106.19 112.96,106.19 111.99,107.16 106.66,107.16 104.89,108.93 103.27,108.93 101.43,110.77 101.43,115.64 102.31,116.51 102.46,116.67 v1(102.46,117.72)
M_A_DQ_3: length 26.8
  TOP w0.076: U3.J15 103.89,117.21 103.24,117.21 103.04,117.21 103.03,117.21 102.79,117.21 v1(102.69,117.31)
  IN1 w0.06: v1(117.81,106.08) 117.6,106.08 117.48,106.2 117.4,106.28 117.3,106.28 117.23,106.28 117.15,106.2 116.99,106.2 116.75,106.2 116.68,106.14 116.09,106.14
  IN1 w0.061: v1(102.69,117.31) 102.66,117.28 102.66,116.61 101.61,115.56 101.61,110.87 103.37,109.11 104.99,109.11 106.75,107.36 112.06,107.36 113.04,106.38 115.42,106.38 115.6,106.19 116.04,106.19 116.09,106.14
M_A_DQ_4: length 28.6
  IN1 w0.06: 116.57,105.43 117.31,105.43 v1(117.31,105.43)
  IN1 w0.061: v1(103.64,117.95) 103.45,118.14 102.28,118.14 101.61,117.47 101.61,116.88 100.72,115.99 100.72,110.47 102.99,108.2 104.59,108.2 106.34,106.44 111.69,106.44 112.93,105.2 114.17,105.2 114.31,105.33 116.37,105.33 116.47,105.43 116.57,105.43
M_A_DQ_5: length 30.3
  IN1 w0.06: 116.55,105 116.66,105.11 v1(117.07,105.11)
  IN1 w0.061: v1(104.14,118.45) 103.88,118.7 102.29,118.7 101.26,117.67 101.26,117.04 100.34,116.12 100.34,110.31 102.83,107.82 104.41,107.82 106.14,106.09 111.56,106.09 112.81,104.84 114.35,104.84 114.5,105 116.55,105
M_A_DQ_6: length 26.3
  IN1 w0.06: 115.97,106.55 116.09,106.55 116.26,106.38 116.57,106.38 116.8,106.6 117.15,106.6 117.35,106.4 v1(117.56,106.4)
  IN1 w0.061: 115.97,106.55 115.96,106.55 115.78,106.73 113.15,106.73 112.14,107.74 106.89,107.74 105.16,109.47 103.54,109.47 101.98,111.03 101.98,115.47 104.05,117.54 104.39,117.54 104.54,117.69 104.88,117.69 v1(105.14,117.95)
M_A_DQ_7: length 26
  IN1 w0.06: 116.08,106.36 116.18,106.26 116.62,106.26 116.77,106.4 v1(117.07,106.4)
  IN1 w0.061: 116.08,106.36 115.79,106.36 115.58,106.57 113.09,106.57 112.1,107.55 106.81,107.55 105.07,109.29 103.44,109.29 101.79,110.94 101.79,115.51 102.89,116.61 102.89,117.11 102.97,117.18 103.46,117.18 103.98,117.7 104.25,117.7 104.51,117.95 v1(104.64,117.95)
M_A_DQ_8: length 21.5
  TOP w0.076: v1(102.24,114.72) 102.25,114.7 103.38,114.7 U3.C16
  IN1 w0.06: v1(117.81,106.72) 117.6,106.72 117.4,106.92 117.23,106.92 117.23,106.92 117.15,106.84 116.99,106.84 116.86,106.84 116.78,106.92 116.06,106.92 115.91,107.07
  IN1 w0.061: 115.91,107.07 115.87,107.11 113.37,107.11 112.32,108.17 107.16,108.17 103.28,112.04 103.13,112.04 102.57,112.61 102.57,114.38 v1(102.24,114.72)
M_A_DQ_9: length 20.1
  TOP w0.076: U3.B16 103.38,113.7 102.35,113.7 v1(102.31,113.65)
  IN1 w0.061: v1(117.31,106.72) 116.71,106.72 116.51,106.52 116.5,106.52 116.33,106.52 116.32,106.52 116.06,106.78 115.96,106.78 115.8,106.94 113.33,106.94 112.25,108.01 107.03,108.01 103.15,111.89 103.07,111.89 102.31,112.66 v1(102.31,113.65)
M_A_DQ_10: length 16.7
  IN1 w0.061: v1(117.81,108.01) 117.6,108.01 116.9,108.71 116.03,108.71 116.02,108.71 115.79,108.71 115.79,108.71 115.74,108.71 115.67,108.64 114.1,108.64 113.88,108.86 113.85,108.86 113.85,108.86 113.47,108.86 112.76,109.58 107.78,109.58 105.39,111.96 105.39,114.19 v1(105.14,114.45)
M_A_DQ_11: length 17.1
  IN1 w0.06: v1(117.56,107.69) 117.36,107.69 117.24,107.81 117.23,107.81 117.12,107.93 117.12,107.94 117.05,108 116.95,108.1
  IN1 w0.061: 116.95,108.1 116.66,108.39 115.96,108.39 115.89,108.32 113.94,108.32 113.73,108.54 113.34,108.54 112.68,109.2 107.67,109.2 105.04,111.84 105.04,113.66 104.89,113.81 104.89,114.2 v1(104.64,114.45)
M_A_DQ_12: length 18.9
  IN1 w0.06: v1(117.56,107.04) 117.77,107.04 117.89,107.17 118.01,107.28 118.01,107.45 117.89,107.57 117.72,107.57 117.7,107.54 117.7,107.54 117.64,107.49 117.48,107.49 117.46,107.51 117.45,107.51 117.4,107.57 117.23,107.57 117.18,107.51 117.17,107.51 117.15,107.49 116.93,107.49 116.78,107.64
  IN1 w0.061: v1(104.14,114.45) 104.38,114.21 104.38,113.24 104.57,113.04 104.57,111.79 107.49,108.87 112.55,108.87 113.21,108.21 113.62,108.21 113.87,107.96 116.45,107.96 116.78,107.64
M_A_DQ_13: length 21.8
  IN1 w0.06: 115.96,107.27 116.11,107.11 117,107.11 v1(117.07,107.04)
  IN1 w0.061: 115.96,107.27 115.92,107.31 113.4,107.31 112.34,108.37 107.23,108.37 104.1,111.5 104.1,112.61 103.97,112.74 103.45,112.74 103.06,113.13 103.06,114.54 103.41,114.9 103.41,115.04 103.54,115.18 103.55,115.18 103.56,115.19 104.24,115.19 104.37,115.06 104.37,114.85 104.24,114.72 104.07,114.72 103.9,114.54 103.9,114.19 v1(104.14,113.95)
M_A_DQ_14: length 16.2
  IN1 w0.061: v1(117.07,107.69) 116.59,108.17 116,108.17 115.96,108.13 113.92,108.13 113.66,108.38 113.27,108.38 112.62,109.03 107.59,109.03 104.87,111.75 104.87,113.55 104.64,113.79 v1(104.64,113.95)
M_A_DQ_15: length 15.9
  IN1 w0.061: v1(117.31,108.01) 116.88,108.45 116.88,108.45 116.76,108.56 115.85,108.56 115.77,108.47 114.02,108.47 113.78,108.71 113.4,108.71 112.74,109.37 107.76,109.37 105.24,111.89 105.24,113.85 v1(105.14,113.95)
M_A_DQ_16: length 21.3
  IN2 w0.06: v2(118.79,108.01) 118.58,108.01 118.5,107.93 118.38,107.81 118.22,107.81 118.19,107.84 116.35,107.84 115.89,108.3
  IN2 w0.076: v2(104.64,115.95) 104.89,116.21 105.56,116.21 105.63,116.13 105.63,115.29 105.54,115.2 105.54,114.45 104.97,113.87 104.97,111.83 108.47,108.33 115.86,108.33 115.89,108.3
M_A_DQ_17: length 19.8
  IN2 w0.06: 115.73,108.02 116.18,107.56 118.22,107.56 118.22,107.57 118.38,107.57 118.46,107.49 118.46,107.49 118.63,107.49 118.71,107.57 118.71,107.57 118.83,107.69 v2(119.04,107.69)
  IN2 w0.076: v2(105.14,114.95) 105.14,114.55 104.61,114.02 104.61,111.64 108.24,108.02 115.73,108.02
M_A_DQ_18: length 21.3
  IN2 w0.06: 115.53,107.51 115.94,107.1 115.95,107.1 116,107.04 v2(118.55,107.04)
  IN2 w0.076: 115.53,107.51 108.01,107.51 103.64,111.88 103.64,112.57 103.64,112.58 103.64,112.58 103.89,112.83 104.22,112.83 104.41,113.02 104.41,114.12 104.89,114.61 104.89,115.21 v2(105.14,115.45)
M_A_DQ_19: length 22
  IN2 w0.06: 115.47,107.35 115.94,106.88 118.15,106.88 118.2,106.92 118.38,106.92 118.46,106.84 118.63,106.84 118.75,106.96 118.75,106.97 118.83,107.04 v2(119.04,107.04)
  IN2 w0.076: v2(104.64,115.45) 103.35,114.16 103.35,111.88 107.87,107.35 115.47,107.35
M_A_DQ_20: length 21.2
  IN2 w0.06: v2(118.55,107.69) 118.53,107.7 118.44,107.7 118.43,107.69 118.17,107.69 118.16,107.7 116.27,107.7 115.8,108.17
  IN2 w0.076: 115.8,108.17 108.37,108.17 104.81,111.73 104.81,113.93 105.38,114.5 105.38,115.56 105.47,115.65 105.47,115.7 105.39,115.78 105.3,115.78 105.24,115.71 105.05,115.71 104.96,115.62 104.82,115.62 104.73,115.71 104.38,115.71 v2(104.14,115.95)
M_A_DQ_21: length 22.5
  IN2 w0.06: v2(118.3,108.01) 116.42,108.01 116.01,108.42
  IN2 w0.076: v2(103.64,115.95) 103.64,116.1 104.23,116.69 104.67,116.69 104.92,116.45 105.07,116.45 105.34,116.72 105.53,116.72 105.81,116.43 105.81,115.22 105.72,115.13 105.72,114.37 105.15,113.79 105.15,111.87 108.52,108.5 115.93,108.5 116.01,108.42
M_A_DQ_22: length 21.3
  IN2 w0.06: 115.4,107.18 115.86,106.72 v2(118.3,106.72)
  IN2 w0.076: v2(104.14,115.45) 104.14,115.23 103.18,114.28 103.18,111.77 107.78,107.18 115.4,107.18
M_A_DQ_23: length 22
  IN2 w0.06: v2(118.79,106.72) 118.58,106.72 118.5,106.64 118.38,106.52 118.22,106.52 118.18,106.56 115.81,106.56 115.34,107.03
  IN2 w0.076: 115.34,107.03 107.68,107.03 103.02,111.69 103.02,114.37 103.64,114.98 v2(103.64,115.45)
M_A_DQ_24: length 29
  IN2 w0.06: 115.95,106.26 116.02,106.26 116.03,106.24 118.18,106.24 118.22,106.28 118.39,106.28 118.46,106.2 118.63,106.2 118.83,106.4 v2(119.04,106.4)
  IN2 w0.076: v2(105.14,118.95) 104.1,117.92 102.34,117.92 101.73,117.31 101.73,116.21 102.58,115.36 102.58,111.53 107.5,106.6 115.02,106.6 115.37,106.26 115.95,106.26
M_A_DQ_25: length 27.6
  IN2 w0.06: 115.08,106.79 115.48,106.4 v2(118.55,106.4)
  IN2 w0.076: 115.08,106.79 107.59,106.79 102.78,111.6 102.78,115.44 101.9,116.32 101.9,117.19 102.41,117.71 104.39,117.71 v2(105.14,118.45)
M_A_DQ_26: length 29.5
  IN2 w0.06: v2(118.3,105.43) 118.29,105.44 117.1,105.44 117.08,105.46 117.05,105.46 117.03,105.48 114.7,105.48 114.51,105.66
  IN2 w0.076: 114.51,105.66 107.05,105.66 101.63,111.09 101.63,114.84 100.9,115.57 100.9,117.81 102.26,119.17 103.36,119.17 v2(103.64,119.45)
M_A_DQ_27: length 31.3
  IN2 w0.06: v2(118.79,105.43) 118.58,105.43 118.5,105.35 118.38,105.23 118.22,105.23 118.13,105.32 117.05,105.32 117.03,105.34 114.58,105.34 114.43,105.49
  IN2 w0.076: 114.43,105.49 106.93,105.49 101.44,110.98 101.44,114.75 100.73,115.46 100.73,117.93 102.17,119.37 103.21,119.37 103.54,119.7 103.89,119.7 v2(104.14,119.45)
M_A_DQ_28: length 28.2
  IN2 w0.06: v2(118.3,106.08) 118.28,106.09 115.96,106.09
  IN2 w0.076: 115.96,106.09 115.22,106.09 114.94,106.38 107.44,106.38 102.4,111.43 102.4,115.24 101.58,116.06 101.58,117.43 102.27,118.12 103.94,118.12 104.64,118.82 v2(104.64,118.95)
M_A_DQ_29: length 29.7
  IN2 w0.06: v2(118.79,106.08) 118.58,106.08 118.5,106 118.38,105.88 118.22,105.88 118.21,105.89 118.16,105.94 117.05,105.94 117.04,105.95 115.97,105.95 115.96,105.94
  IN2 w0.076: v2(104.64,119.45) 104.64,119.43 104.38,119.17 104.38,118.85 103.85,118.32 102.19,118.32 101.43,117.56 101.43,115.88 102.21,115.09 102.21,111.3 107.32,106.2 114.81,106.2 115.08,105.94 115.96,105.94 115.96,105.94
M_A_DQ_30: length 32.9
  IN2 w0.06: v2(119.04,105.11) 118.81,104.88 118.18,104.88 117.98,105.08 117.05,105.08 117.03,105.07 114.84,105.07 114.83,105.06 114.37,105.06 114.3,105.12
  IN2 w0.076: v2(104.14,119.95) 103.9,120.19 103.49,120.19 103.03,119.73 101.97,119.73 100.32,118.08 100.32,115.28 101.03,114.58 101.03,110.84 106.75,105.12 114.3,105.12
M_A_DQ_31: length 31
  IN2 w0.06: v2(118.55,105.11) 118.53,105.1 118.16,105.1 118.07,105.19 118.04,105.19 118.03,105.2 114.78,105.2 114.77,105.2 114.47,105.2 114.35,105.31
  IN2 w0.076: 114.35,105.31 106.84,105.31 101.23,110.92 101.23,114.67 100.52,115.38 100.52,118 102.07,119.55 103.14,119.55 103.54,119.95 v2(103.64,119.95)
M_A_DQ_32: length 16.6
  IN2 w0.06: 116.27,114.04 117.22,113.09 117.22,112.51 118.61,111.11 118.61,110.82 v2(119.02,110.41)
  IN2 w0.076: v2(109.14,120.45) 109.14,120.61 109.38,120.85 109.38,121.02 109.53,121.18 110.88,121.18 112.26,119.8 112.26,119.55 113.68,118.13 114.09,118.13 115.61,116.6 115.61,114.7 116.27,114.04
M_A_DQ_33: length 15.5
  IN2 w0.06: 115.84,113.99 116.92,112.91 116.92,112.32 118.35,110.89 118.36,110.89 118.36,110.62 119.02,109.96 v2(119.02,109.92)
  IN2 w0.076: v2(109.64,119.45) 109.62,119.46 109.44,119.46 109.38,119.41 109.38,119.26 109.45,119.19 111.45,119.19 112.38,118.26 113.09,118.26 113.58,117.77 113.86,117.77 115.2,116.43 115.2,114.62 115.84,113.99
M_A_DQ_34: length 18.1
  IN2 w0.06: 116.52,114.9 117.94,113.48 117.94,112.92 119.59,111.27 119.59,110.98 v2(119.67,110.9)
  IN2 w0.076: 116.52,114.9 116.52,117.09 114.24,119.37 113.81,119.37 113.12,120.06 113.12,120.65 112.47,121.3 111.62,121.3 111.14,121.79 109.27,121.79 108.64,121.15 v2(108.64,120.95)
M_A_DQ_35: length 18.7
  IN2 w0.06: v2(119.67,110.41) 119.59,110.49 119.59,110.7 119.47,110.82 119.47,111.17 117.81,112.83 117.81,113.39 116.32,114.88
  IN2 w0.076: 116.32,114.88 116.32,117.01 114.16,119.17 113.73,119.17 112.95,119.96 112.95,120.61 112.45,121.1 111.52,121.1 111.04,121.59 109.33,121.59 108.89,121.15 108.89,120.87 108.88,120.85 108.64,120.61 v2(108.64,120.45)
M_A_DQ_36: length 18.1
  IN2 w0.06: v2(119.67,109.92) 119.47,109.72 119.1,109.72 118.94,109.72 118.82,109.83 118.82,109.98 118.24,110.57 118.24,110.78 116.78,112.23 116.78,112.82 115.86,113.73 115.86,113.73
  IN2 w0.076: 115.86,113.73 114.99,114.61 114.99,116.33 113.73,117.6 113.54,117.6 113.06,118.07 112.29,118.07 111.67,118.69 109.03,118.69 108.89,118.83 108.89,119.05 108.74,119.21 108.54,119.21 108.39,119.35 108.39,119.55 108.54,119.69 108.74,119.69 108.74,119.69 108.77,119.69 108.93,119.53 109.05,119.53 v2(109.14,119.45)
M_A_DQ_37: length 16.1
  IN2 w0.06: 116.45,114.09 117.35,113.18 117.35,112.63 118.73,111.25 118.73,111.19 v2(119.02,110.9)
  IN2 w0.076: 116.45,114.09 115.78,114.76 115.78,116.74 113.91,118.61 113.48,118.61 112.46,119.63 112.46,119.85 110.93,121.38 109.46,121.38 109.14,121.06 v2(109.14,120.95)
M_A_DQ_38: length 16.7
  IN2 w0.06: 116.07,114.01 117.06,113.02 117.06,112.44 118.48,111.02 118.48,110.75 118.82,110.4 118.82,110.33 118.94,110.2 119.02,110.2 119.26,109.96 119.43,109.96 119.43,109.97 119.44,109.97 119.63,110.16 v2(119.99,110.16)
  IN2 w0.076: v2(109.14,119.95) 109.39,119.69 111.23,119.69 112.49,118.43 113.15,118.43 113.63,117.95 113.96,117.95 115.41,116.5 115.41,114.67 116.07,114.01
M_A_DQ_39: length 20.2
  IN2 w0.06: v2(119.99,110.66) 119.9,110.74 119.9,110.94 119.87,110.98 119.87,110.99 119.75,111.1 119.74,111.1 119.71,111.14 119.71,111.35 119.48,111.58 119.48,111.58 119.32,111.74 119.32,111.78 118.1,113 118.1,113.56 116.71,114.94
  IN2 w0.076: 116.71,114.94 116.71,117.18 114.34,119.55 113.93,119.55 113.27,120.22 113.27,120.73 112.51,121.48 111.75,121.48 111.24,121.99 109.14,121.99 108.52,121.37 108.52,121.28 108.38,121.13 108.38,120.37 108.64,120.11 v2(108.64,119.95)
M_A_DQ_40: length 24.4
  IN1 w0.06: v18(119.99,111.16) 119.99,110.94 120.23,110.7 120.23,110.61 120.11,110.49 120.11,110.33 120.31,110.13 120.31,110.13 v1(120.31,109.92)
  IN2 w0.06: 118.35,113.56 118.35,113.31 119.49,112.17 119.49,111.76 119.99,111.26 v18(119.99,111.16)
  IN2 w0.076: v2(106.14,119.45) 106.26,119.45 106.48,119.68 106.83,119.68 106.9,119.75 106.9,120.06 106.8,120.17 106.8,121.32 107.65,122.17 108.93,122.17 109.06,122.3 109.69,122.3 109.78,122.21 109.86,122.21 109.94,122.3 110.02,122.3 110.11,122.21 110.19,122.21 110.27,122.3 110.35,122.3 110.44,122.21 110.52,122.21 110.6,122.3 110.68,122.3 110.77,122.21 110.85,122.21 110.93,122.3 111.01,122.3 111.1,122.21 112.21,122.21 114.12,120.3 114.12,120.07 118.34,115.85 118.34,113.57 118.35,113.56
M_A_DQ_41: length 24.1
  IN2 w0.06: v2(120.31,110.41) 120.21,110.51 120.21,110.72 120.11,110.82 120.11,110.99 120.13,111.01 120.13,111.01 120.18,111.06 120.18,111.07 120.19,111.08 120.19,111.24 120.18,111.25 120.18,111.26 119.65,111.79 119.65,112.23 118.56,113.33 118.56,113.61
  IN2 w0.076: 118.56,113.61 118.55,113.62 118.55,115.9 114.31,120.14 114.31,120.36 112.18,122.5 108.98,122.5 108.86,122.38 107.6,122.38 106.62,121.39 106.62,120.28 106.36,120.02 106.36,119.86 106.23,119.73 105.91,119.73 v2(105.64,119.45)
M_A_DQ_42: length 27.5
  IN2 w0.06: v2(120.95,109.92) 120.95,110.13 121.15,110.33 121.15,110.49 121.15,110.5 121.15,110.5 121.08,110.57 121.08,110.74 121.17,110.83 121.17,111.12 121.27,111.23 121.27,111.6 120.82,112.06 120.82,112.9 119.78,113.94 119.78,114.25
  IN2 w0.076: 119.78,114.25 119.78,116.55 112.6,123.73 106.93,123.73 105.22,122.02 105.22,121.4 104.88,121.06 104.88,120.79 105.14,120.53 v2(105.14,120.45)
M_A_DQ_43: length 26.1
  IN2 w0.06: v2(120.95,110.41) 120.95,110.32 120.83,110.19 120.83,110.08 120.71,109.96 120.55,109.96 120.55,109.96 120.43,110.08 120.43,110.25 120.51,110.33 120.51,110.49 120.51,110.49 120.44,110.57 120.44,110.57 120.43,110.57 120.43,110.74 120.44,110.74 120.5,110.81 120.5,110.81 120.51,110.82 120.51,110.99 120.5,111 120.5,111.34 119.98,111.85 119.98,112.38 118.97,113.4 118.97,113.68
  IN2 w0.076: 118.97,113.68 118.97,115.99 114.67,120.29 114.67,120.57 112.32,122.91 108.79,122.91 108.67,122.79 107.47,122.79 106.19,121.51 106.19,120.64 105.77,120.22 105.4,120.22 v2(105.14,119.95)
M_A_DQ_44: length 23.5
  IN2 w0.06: v2(120.31,110.9) 120.33,110.92 120.33,111.3 119.8,111.83 119.8,112.33 118.76,113.38 118.76,113.63
  IN2 w0.076: v2(105.64,119.95) 105.82,119.95 105.91,120.04 106.04,120.18 106.04,120.21 106.42,120.58 106.42,121.47 107.52,122.57 108.75,122.57 108.88,122.7 112.25,122.7 114.48,120.48 114.48,120.22 118.76,115.94 118.76,113.63
M_A_DQ_45: length 25.2
  IN2 w0.06: 119.57,114.22 119.57,113.94 120.66,112.85 120.66,111.97 121.15,111.48 121.15,111.31 120.95,111.11 UC1.BG49 v2(120.95,110.9)
  IN2 w0.076: 119.57,114.22 119.57,116.48 112.52,123.53 107,123.53 105.42,121.95 105.42,121.24 v2(105.14,120.95)
M_A_DQ_46: length 26.7
  IN2 w0.06: 119.98,114.27 119.98,113.96 120.97,112.97 120.97,112.14 121.41,111.7 121.41,111.13 121.31,111.04 121.31,110.69 v2(121.28,110.66)
  IN2 w0.076: v2(104.64,120.95) 104.64,121.08 105.02,121.47 105.02,122.1 106.85,123.94 112,123.94 112.01,123.94 112.16,123.94 112.17,123.94 112.67,123.94 119.98,116.63 119.98,114.27
M_A_DQ_47: length 28.4
  IN2 w0.06: 120.18,114.25 120.18,113.97 121.12,113.03 121.12,112.23 121.55,111.8 121.55,110.93 121.48,110.86 121.48,110.54 121.28,110.34 v2(121.28,110.16)
  IN2 w0.076: 120.18,114.25 120.18,116.68 112.78,124.09 112.23,124.09 112.22,124.1 111.95,124.1 111.94,124.09 111.65,124.09 111.6,124.14 106.79,124.14 104.81,122.17 104.81,121.51 104.38,121.07 104.38,120.98 104.41,120.86 v2(104.64,120.45)
M_A_DQ_48: length 12.3
  IN1 w0.06: v1(119.02,111.4) 119,111.4 118.92,111.48 118.91,111.48 118.91,111.49 118.89,111.5 118.89,111.56 118.7,111.76 118.7,111.91 118.53,112.08 118.53,112.25 118.53,112.37 118.53,112.37 117.93,112.97
  IN1 w0.061: 117.93,112.97 117.93,113.01 117.81,113.13 117.69,113.13 117.34,113.48 117.34,113.58 116.6,114.32 116.6,114.59 113.26,117.93 112.49,117.93 111.17,119.24 110.84,119.24 v1(110.64,119.45)
M_A_DQ_49: length 12.2
  IN1 w0.06: 118.2,113.18 118.2,113.04 118.77,112.47 118.77,112.35 118.78,112.33 118.78,112.17 118.94,112.01 118.94,112 119.02,111.92 v1(119.02,111.89)
  IN1 w0.061: 118.2,113.18 117.97,113.4 117.85,113.4 117.64,113.61 117.64,113.73 116.91,114.47 116.91,114.71 113.34,118.28 112.59,118.28 111.15,119.72 111.04,119.72 110.9,119.86 110.73,119.86 v1(110.64,119.95)
M_A_DQ_50: length 13.6
  IN1 w0.06: v1(119.67,111.4) 119.3,111.4 119.1,111.6 119.03,111.6 119.03,111.6 118.82,111.81 118.82,111.96 118.65,112.13 118.65,112.3 118.65,112.42 118.05,113.02 118.05,113.1
  IN1 w0.061: v1(110.14,119.95) 110.39,119.69 110.73,119.69 110.73,119.69 110.8,119.69 111.02,119.47 111.17,119.47 112.54,118.1 113.3,118.1 116.75,114.65 116.75,114.39 117.49,113.66 117.49,113.53 117.75,113.27 117.88,113.27 118.05,113.1
M_A_DQ_51: length 13.9
  IN1 w0.06: v1(119.67,111.89) 119.67,112.1 119.47,112.3 119.47,112.58 119.23,112.82 119.11,112.82 118.93,113.01
  IN1 w0.061: 118.93,113.01 118.78,113.15 118.78,113.66 118.15,114.29 117.97,114.29 117.54,114.73 117.54,115.05 114.44,118.15 114.44,118.54 113.98,118.99 113,118.99 111.88,120.11 111.64,120.11 111.36,120.39 111.36,120.44 111.36,120.44 111.36,120.63 111.27,120.72 111.06,120.72 110.79,120.45 v1(110.64,120.45)
M_A_DQ_52: length 12.8
  IN1 w0.06: v1(119.02,112.38) 119.02,112.4 118.35,113.06 118.35,113.25
  IN1 w0.061: 118.35,113.25 118.06,113.54 117.92,113.54 117.8,113.67 117.8,113.81 117.06,114.55 117.06,114.78 113.37,118.46 112.65,118.46 111.47,119.64 111.47,120 111.26,120.2 110.38,120.2 v1(110.14,120.45)
M_A_DQ_53: length 14.6
  IN1 w0.06: v1(119.67,112.38) 119.67,112.58 119.29,112.96
  IN1 w0.061: v1(110.14,120.95) 110.38,120.7 110.71,120.7 110.88,120.87 110.88,121.04 111.02,121.17 111.04,121.17 111.04,121.18 111.23,121.18 111.23,121.17 111.27,121.17 111.51,120.94 111.51,120.69 111.52,120.69 111.52,120.5 111.74,120.27 111.75,120.27 111.88,120.27 111.88,120.27 111.94,120.27 113.05,119.17 114.06,119.17 114.62,118.61 114.62,118.2 117.72,115.1 117.72,114.83 118.1,114.45 118.2,114.45 119.01,113.63 119.01,113.49 119.27,113.23 119.27,112.97 119.29,112.96
M_A_DQ_54: length 17.2
  IN1 w0.06: v1(119.99,112.13) 119.99,112.25 119.99,112.68 119.54,113.13 119.54,113.33 119.32,113.56 119.32,113.74 118.28,114.78
  IN1 w0.061: 118.28,114.78 118.07,114.99 118.07,115.19 114.97,118.29 114.97,118.76 114.21,119.53 113.14,119.53 112.08,120.59 111.95,120.59 111.83,120.71 111.83,121.23 111.54,121.52 111.49,121.52 110.2,121.52 109.89,121.21 109.89,119.83 110.14,119.58 v1(110.14,119.45)
M_A_DQ_55: length 15.2
  IN1 w0.06: 118.23,114.62 119.14,113.71 119.14,113.54 119.41,113.27 119.41,113.07 119.87,112.62 119.87,112.3 119.85,112.28 119.85,112.28 119.79,112.22 119.79,112.05 119.99,111.85 v1(119.99,111.64)
  IN1 w0.061: v1(110.64,120.95) 110.64,121.11 110.9,121.37 111.43,121.37 111.67,121.13 111.67,120.57 111.82,120.43 112.01,120.43 113.09,119.35 114.14,119.35 114.8,118.69 114.8,118.25 117.9,115.16 117.9,114.9 118.18,114.62 118.23,114.62
M_A_DQ_56: length 23
  IN1 w0.06: 119.11,115.43 119.11,115.26 120.75,113.62 120.75,112.46 120.75,112.3 120.81,112.24 120.81,112.24 120.83,112.22 120.83,112.05 120.77,111.99 120.77,111.99 120.75,111.97 120.75,111.81 120.81,111.75 120.81,111.74 120.83,111.72 120.83,111.56 120.8,111.53 120.8,111.53 120.75,111.48 120.75,111.47 120.71,111.43 120.56,111.43 120.33,111.66 120.33,111.86 v1(120.31,111.89)
  IN1 w0.061: 119.11,115.43 119.11,116.18 118.43,116.86 118.18,116.86 116.14,118.89 116.14,119.4 114.1,121.44 113.74,121.44 112.08,123.11 108.44,123.11 106.64,121.3 v1(106.64,120.95)
M_A_DQ_57: length 20.5
  IN1 w0.06: 118.47,115.81 118.47,115.07 120.11,113.43 120.11,112.3 120.19,112.22 120.19,112.05 120.11,111.97 120.11,111.9 120.11,111.81 120.2,111.71 120.2,111.5 v1(120.31,111.4)
  IN1 w0.061: 118.47,115.81 118.14,116.15 117.79,116.15 115.41,118.53 115.41,119.14 113.81,120.74 113.4,120.74 111.77,122.37 109.44,122.37 108.74,121.68 108.54,121.68 108.42,121.56 108.35,121.56 107.5,120.7 107.23,120.7 107.14,120.8 v1(107.14,120.95)
M_A_DQ_58: length 23.1
  IN1 w0.06: 119.47,115.43 119.47,115.31 121.05,113.73 121.05,112.57 121.15,112.46 121.15,112.3 121.07,112.22 121.07,112.22 120.95,112.1 v1(120.95,111.89)
  IN1 w0.061: 119.47,115.43 119.47,116.35 118.61,117.21 118.4,117.21 116.52,119.09 116.52,119.55 114.28,121.8 113.9,121.8 112.21,123.48 108.25,123.48 106.14,121.37 v1(106.14,120.95)
M_A_DQ_59: length 20.9
  IN1 w0.06: 118.31,115.74 118.31,115 119.67,113.64 v18(119.67,113.51)
  IN1 w0.061: v1(107.14,120.45) 107.38,120.21 107.76,120.21 107.91,120.36 107.91,120.59 108.01,120.69 108.23,120.69 108.36,120.83 108.36,121.02 108.52,121.18 108.75,121.18 109,121.43 109,121.67 109.51,122.18 111.71,122.18 113.32,120.57 113.73,120.57 115.23,119.07 115.23,118.46 117.72,115.97 118.07,115.97 118.31,115.74
  IN2 w0.06: v18(119.67,113.51) 120.46,112.72 120.46,111.98 120.95,111.49 v2(120.95,111.4)
M_A_DQ_60: length 22.5
  IN1 w0.06: 119.29,115.39 119.29,115.3 120.89,113.69 120.89,112.44 v1(120.95,112.38)
  IN1 w0.061: v1(106.14,120.45) 106.38,120.7 106.38,121.34 108.33,123.28 112.16,123.28 113.79,121.65 114.15,121.65 116.35,119.45 116.35,118.99 118.29,117.05 118.52,117.05 119.29,116.28 119.29,115.39
M_A_DQ_61: length 20.4
  IN1 w0.06: 118.63,115.89 118.63,115.1 120.28,113.45 120.28,112.41 v1(120.31,112.38)
  IN1 w0.061: 118.63,115.89 118.2,116.33 117.87,116.33 115.59,118.6 115.59,119.21 113.88,120.92 113.48,120.92 111.83,122.57 109.41,122.57 108.68,121.84 108.48,121.84 108.36,121.72 108.35,121.72 108.35,121.71 108.26,121.71 107.73,121.18 107,121.18 106.89,121.08 106.89,120.71 v1(106.64,120.45)
M_A_DQ_62: length 27.3
  IN1 w0.06: 119.83,115.48 119.83,115.34 121.32,113.84 121.36,113.81 121.36,113.38 121.32,113.34 121.32,112.64 121.48,112.48 121.48,112.22 121.48,112.05 121.36,111.93 121.35,111.93 121.28,111.86 v1(121.28,111.64)
  IN1 w0.061: 119.83,115.48 119.83,116.55 118.77,117.61 118.57,117.61 116.85,119.32 116.85,119.68 114.34,122.19 113.95,122.19 112.29,123.84 108.07,123.84 105.91,121.68 105.55,121.68 105.39,121.53 105.39,120.32 105.52,120.19 105.75,120.19 105.89,120.06 105.89,119.8 105.99,119.69 106.39,119.69 v1(106.64,119.45)
M_A_DQ_63: length 24.9
  IN1 w0.06: v1(121.28,112.13) 121.28,112.51 121.19,112.59 121.19,113.59 121.19,113.59 121.19,113.78 121.18,113.79 119.65,115.32 119.65,115.42
  IN1 w0.061: 119.65,115.42 119.65,116.45 118.67,117.43 118.49,117.43 116.68,119.25 116.68,119.64 114.31,122 113.92,122 112.27,123.66 108.13,123.66 105.88,121.4 105.88,120.38 106.06,120.2 106.39,120.2 v1(106.64,119.95)
M_A_DQS_DN_0: length 28.5
  IN1 w0.06: 116.1,105.84 116.11,105.84 116.12,105.83 116.82,105.83 116.94,105.96 117.15,105.96 117.25,105.86 117.46,105.86 v1(117.56,105.76)
  IN1 w0.069: 116.1,105.84 115.33,105.84 115.18,105.98 112.86,105.98 111.9,106.94 106.58,106.94 104.8,108.72 103.14,108.72 101.21,110.65 101.21,115.78 102.17,116.74 v18(102.22,116.74)
  IN2 w0.091: v18(102.22,116.74) 102.4,116.74 102.91,117.24 104.22,117.24 104.51,116.96 104.78,116.96 104.94,117.12 104.94,117.26 v2(105.14,117.45)
M_A_DQS_DN_1: length 19.8
  IN1 w0.06: 116.5,107.48 116.62,107.36 117.22,107.36 117.22,107.37 v1(117.31,107.37) ; 116.35,107.64 116.28,107.71 116.03,107.71 116.02,107.71 116.01,107.71
  IN1 w0.061: 116.5,107.48 116.35,107.64
  IN1 w0.069: v1(104.14,114.95) 103.95,114.95 103.76,114.77 103.76,114.69 103.35,114.27 103.35,114.1 103.46,114 103.7,114 103.77,113.92 103.77,113.77 103.7,113.69 103.46,113.69 103.35,113.58 103.35,113.35 103.56,113.14 104.06,113.14 104.38,112.82 104.38,111.65 107.37,108.67 112.47,108.67 113.17,107.97 113.43,107.71 116.01,107.71
M_A_DQS_DN_2: length 25.2
  IN1 w0.069: v1(105.14,116.45) 104.97,116.45 104.72,116.7 103.55,116.7 103.35,116.5 103.35,116.38 103.22,116.25 103.03,116.25 102.73,115.95 102.72,115.95 102.44,115.66 102.44,114.89 102.75,114.57 102.75,112.69 103.21,112.23 103.71,112.23 103.87,112.07 v18(103.87,112.07)
  IN2 w0.06: 116.39,107.21 118.17,107.21 118.22,107.17 118.38,107.17 118.5,107.28 118.58,107.37 v2(118.79,107.37)
  IN2 w0.091: v18(103.87,112.07) 103.99,112.19 104.12,112.19 104.25,112.06 104.25,111.51 108.08,107.68 113.26,107.68 115.56,107.68 116.03,107.21 116.04,107.21 116.04,107.21 116.39,107.21
M_A_DQS_DN_3: length 29.5
  IN2 w0.06: 118.11,105.78 118.11,105.78 118.13,105.76 118.16,105.76 118.17,105.75 118.54,105.75 v2(118.55,105.76)
  IN2 w0.091: v2(104.14,118.95) 103.91,118.73 103.72,118.73 103.65,118.65 103.65,118.62 103.57,118.55 103.42,118.55 103.34,118.62 103.34,118.65 103.21,118.79 103.1,118.79 103.03,118.71 103.03,118.64 102.95,118.56 102.8,118.56 102.72,118.64 102.72,118.71 102.64,118.79 102.36,118.79 101.24,117.67 101.24,115.76 102,115 102,111.2 107.2,105.99 114.7,105.99 114.83,105.86 114.92,105.77 114.98,105.77 114.98,105.77 116.03,105.77 116.04,105.78 117.08,105.78 117.08,105.78 118.11,105.78
M_A_DQS_DN_4: length 21
  IN1 w0.069: v18(112.38,120.62) 112.33,120.67 112.33,121.23 112.07,121.5 111.64,121.93 109.6,121.93 109.23,121.55 109.23,121.37 108.88,121.02 108.88,120.34 108.76,120.22 108.76,120.22 108.74,120.2 108.05,120.2 107.91,120.06 107.91,119.68 v1(108.14,119.45)
  IN2 w0.06: v2(119.34,110.16) 119.34,110.37 119.17,110.54 119.17,110.54 119.14,110.57 119.14,110.74 119.17,110.77 119.17,110.77 119.22,110.82 119.22,110.99 117.65,112.57 117.51,112.7 117.51,113.28 115.97,114.82 115.97,114.87 115.95,114.89 115.95,114.92 115.94,114.94 115.94,114.94
  IN2 w0.091: 115.94,114.94 115.94,116.88 114.03,118.78 113.57,118.78 112.62,119.74 112.62,120.38 112.38,120.62 v18(112.38,120.62)
M_A_DQS_DN_5: length 25.3
  IN2 w0.06: 119.2,113.56 119.2,113.51 119.23,113.48 119.23,113.36 120.15,112.44 120.15,111.89 120.63,111.41 v2(120.63,110.66)
  IN2 w0.091: 119.2,113.56 119.2,116.04 114.86,120.38 114.86,120.68 112.38,123.16 108.66,123.16 108.66,123.16 108.64,123.16 108.51,123.03 107.66,123.03 107.49,123.2 107.36,123.2 107.27,123.11 107.27,122.92 107.1,122.75 106.74,122.75 106.66,122.67 106.66,122.58 106.7,122.54 106.7,122.43 106.6,122.32 106.49,122.32 106.46,122.35 106.36,122.34 106.26,122.24 106.26,122.14 106.32,122.07 106.32,121.95 106.23,121.85 106.1,121.85 106.08,121.87 105.92,121.87 105.81,121.77 105.81,121.11 105.88,121.05 105.88,120.84 105.64,120.6 v2(105.64,120.45)
M_A_DQS_DN_6: length 15.2
  IN1 w0.06: v1(119.34,112.13) 119.35,112.14 119.35,112.53 119.18,112.7 119.06,112.7 118.63,113.13 118.63,113.62 118.11,114.14 117.87,114.14 117.38,114.63 117.38,114.77 117.38,114.78 117.38,114.79
  IN1 w0.069: v18(111.78,119.71) 111.81,119.74 112.02,119.74 112.96,118.8 113.93,118.8 114.25,118.48 114.25,118.09 117.38,114.96 117.38,114.79
  IN2 w0.091: v2(109.64,120.45) 109.47,120.45 109.42,120.51 109.42,120.64 109.48,120.7 109.83,120.7 109.92,120.61 109.92,120.15 110.14,119.93 111.68,119.93 111.78,119.83 v18(111.78,119.71)
M_A_DQS_DN_7: length 22.8
  IN1 w0.06: v1(120.63,111.64) 120.63,111.85 120.43,112.05 120.43,112.22 120.51,112.3 120.51,112.52 120.46,112.56 120.46,113.51 118.83,115.14 118.83,115.84 118.83,115.84 118.83,115.86
  IN1 w0.069: 118.83,115.86 118.83,116.02 118.31,116.54 118.01,116.54 115.82,118.72 115.82,119.29 113.97,121.14 113.61,121.14 111.95,122.8 108.73,122.8 108.19,122.26 108.19,122.01 v18(108.27,121.94)
  IN2 w0.091: v2(107.14,119.45) 107.14,119.46 107.31,119.63 107.83,119.63 108.13,119.93 108.13,121.24 108.19,121.3 108.19,121.87 v18(108.27,121.94)
M_A_DQS_DP_0: length 28.4
  IN1 w0.06: v1(117.07,105.76) 117.03,105.71 116.12,105.71 116.11,105.71 116.1,105.71
  IN1 w0.069: v18(102.13,117.11) 102.13,116.97 101.99,116.83 101.99,116.74 101.08,115.83 101.08,110.6 103.09,108.59 104.75,108.59 106.53,106.81 111.84,106.81 112.8,105.85 115.13,105.85 115.27,105.71 116.1,105.71
  IN2 w0.091: v2(104.64,117.45) 104.66,117.45 104.79,117.32 104.79,117.18 104.72,117.11 104.57,117.11 104.29,117.4 102.84,117.4 102.44,116.99 102.34,116.96 102.2,116.98 102.13,117.07 v18(102.13,117.11)
M_A_DQS_DP_1: length 19.7
  IN1 w0.06: 116.41,107.4 116.42,107.39 116.45,107.36 116.57,107.24 117.08,107.24 117.15,107.24 117.17,107.23 117.17,107.23 117.23,107.17 117.4,107.17 117.48,107.24 117.69,107.24 v1(117.81,107.37) ; 116.26,107.55 116.23,107.59 116.02,107.59 116.02,107.58 116.01,107.58
  IN1 w0.061: 116.26,107.55 116.41,107.4
  IN1 w0.069: 116.01,107.58 113.38,107.58 113.11,107.84 112.42,108.54 107.31,108.54 104.25,111.6 104.25,112.76 104.01,113.01 103.51,113.01 103.22,113.29 103.22,114.33 103.64,114.74 v1(103.64,114.95)
M_A_DQS_DP_2: length 25.3
  IN1 w0.069: v18(103.86,112.48) 103.74,112.36 103.27,112.36 102.88,112.74 102.88,114.62 102.57,114.94 102.57,115.07 102.64,115.15 102.99,115.15 103.06,115.22 103.06,115.38 102.99,115.45 102.64,115.45 102.57,115.53 102.57,115.61 102.69,115.73 103.1,115.73 103.15,115.67 103.23,115.67 103.36,115.8 103.36,116.06 103.5,116.2 103.75,116.2 103.88,116.07 103.88,115.84 104,115.72 104.23,115.72 104.36,115.85 104.36,116.35 104.47,116.45 v1(104.64,116.45)
  IN2 w0.06: 116.39,107.37 v2(118.3,107.37)
  IN2 w0.091: v18(103.86,112.48) 104,112.35 104.19,112.35 104.41,112.13 104.41,111.57 108.15,107.83 115.62,107.83 116.09,107.37 116.39,107.37
M_A_DQS_DP_3: length 29.6
  IN2 w0.06: v2(119.04,105.76) 118.83,105.76 118.75,105.67 118.63,105.56 118.46,105.56 118.39,105.63 118.38,105.63 118.22,105.63 118.21,105.62 118.16,105.62 118.15,105.63 118.11,105.63
  IN2 w0.091: v2(103.64,118.95) 103.62,118.94 102.29,118.94 101.08,117.73 101.08,115.69 101.84,114.93 101.84,111.14 107.14,105.84 114.63,105.84 114.85,105.62 114.92,105.62 114.92,105.62 116.09,105.62 116.1,105.63 117.01,105.63 117.02,105.63 118.11,105.63
M_A_DQS_DP_4: length 21.2
  IN1 w0.069: v1(108.14,119.95) 108.38,119.7 108.38,119.31 108.5,119.2 108.71,119.2 108.86,119.35 108.86,120.09 108.98,120.21 109.2,120.21 109.23,120.23 109.23,120.23 109.36,120.36 109.36,121.34 109.36,121.34 109.36,121.5 109.66,121.8 111.58,121.8 111.98,121.4 112.2,121.18 112.2,120.98 112.07,120.85 v18(112.07,120.85)
  IN2 w0.06: 116.09,114.94 116.09,114.87 117.63,113.33 117.63,112.75 117.73,112.65 117.9,112.49 119.34,111.04 v2(119.34,110.66)
  IN2 w0.091: v18(112.07,120.85) 112.48,120.85 112.77,120.56 112.77,119.8 113.64,118.93 114.1,118.93 116.09,116.94 116.09,114.94
M_A_DQS_DP_5: length 25.3
  IN2 w0.06: v2(120.63,110.16) 120.75,110.29 120.75,110.5 120.83,110.57 120.83,110.74 120.82,110.75 120.75,110.82 120.75,111.46 120.27,111.94 120.27,112.49 119.35,113.41 119.35,113.53 119.35,113.56
  IN2 w0.091: 119.35,113.56 119.35,113.79 119.35,113.79 119.35,116.1 115.01,120.44 115.01,120.74 112.45,123.31 108.59,123.31 108.59,123.31 108.57,123.31 108.45,123.18 107.72,123.18 107.55,123.35 107.29,123.35 107.11,123.17 107.11,122.98 107.04,122.9 106.68,122.9 106.51,122.73 106.51,122.71 106.1,122.31 106.1,122.27 105.66,121.83 105.66,121.15 105.6,121.09 105.6,120.99 v2(105.64,120.95)
M_A_DQS_DP_6: length 15.2
  IN1 w0.06: v1(119.34,111.64) 119.34,111.85 119.14,112.05 119.14,112.22 119.17,112.24 119.17,112.24 119.22,112.3 119.22,112.46 119.1,112.58 119.01,112.58 118.51,113.09 118.51,113.57 118.06,114.02 117.82,114.02 117.26,114.58 117.26,114.77 117.25,114.78 117.25,114.79
  IN1 w0.069: v18(112.05,119.38) 112.2,119.38 112.91,118.67 113.87,118.67 114.12,118.42 114.12,118.04 117.25,114.91 117.25,114.79
  IN2 w0.091: v18(112.05,119.38) 112.05,119.38 112.02,119.41 112.02,119.81 111.74,120.08 110.21,120.08 110.07,120.22 110.07,120.67 109.79,120.95 v2(109.64,120.95)
M_A_DQS_DP_7: length 22.7
  IN1 w0.06: 118.96,115.86 118.96,115.84 118.95,115.84 118.95,115.19 120.58,113.56 120.58,112.61 120.63,112.56 120.63,112.25 120.63,112.25 120.63,112.24 120.63,112.14 v1(120.63,112.13)
  IN1 w0.069: v18(107.87,121.88) 108.06,122.07 108.06,122.32 108.68,122.93 112,122.93 113.66,121.27 114.02,121.27 115.95,119.34 115.95,118.78 118.06,116.67 118.37,116.67 118.96,116.08 118.96,115.86
  IN2 w0.091: v2(107.14,119.95) 107.3,119.78 107.77,119.78 107.98,119.99 107.98,120.14 107.94,120.18 107.88,120.18 107.8,120.25 107.8,120.4 107.88,120.48 107.93,120.48 107.98,120.53 107.98,121.31 108.04,121.37 108.04,121.63 107.87,121.8 v18(107.87,121.88)
M_A_ODT0: length 25.1
  IN1 w0.061: 106.55,118.04 106.55,118.41 106.69,118.54 106.79,118.54 107.1,118.24 107.23,118.24 107.33,118.33 107.33,118.44 107.01,118.76 107.01,118.87 107.59,119.45 v1(107.64,119.45) ; 106.55,118.04 106.18,118.04 105.98,117.84 105.98,117.73 106.29,117.43 106.29,117.32 106.18,117.21 106.08,117.21 105.77,117.52 105.66,117.52 105.14,116.99 v1(105.14,116.95) ; 106.55,118.04 106.64,117.95 106.64,117.12 106.77,116.99 107.08,116.99 108.29,118.2 109.27,118.2 109.39,118.33 109.39,118.55 109.53,118.69 109.76,118.69 109.89,118.56 109.89,118.34 110.03,118.2 110.85,118.2 111.85,117.2 111.85,117.09 111.37,116.61 111.37,116.5 111.48,116.4 111.58,116.4 112.06,116.88 112.17,116.88 112.28,116.77 112.28,116.66 111.75,116.13 111.75,116.02 111.83,115.94 111.99,115.94 112.49,116.45 112.6,116.45 113.35,115.69 113.35,115.19 113.95,114.59 113.95,114.3 115.71,112.55 116.93,112.55 116.97,112.59 117.34,112.59 117.43,112.5 117.43,112.5 117.66,112.27 v1(117.66,112.22)
M_B_CA_0_0: length 17.7
  IN1 w0.06: 128.77,114.88 128.61,114.72 128.61,114.62 128.26,114.28 128.25,114.28 127.49,113.52 127.47,113.52 127.18,113.23 127.18,113.22 127.17,113.21 127.17,112.94 127.17,112.77 127.17,112.77 127.17,112.59 127.27,112.49 127.27,112.22 127.27,112.22 127.27,112.05 127.27,112.05 127.27,112.04 127.21,111.98 127.21,111.78 v1(127.07,111.64)
  IN1 w0.061: 128.77,114.88 128.81,114.92 128.81,115.18 128.84,115.2 128.84,115.62 128.92,115.69 128.92,116.14 128.79,116.27 128.69,116.27 128.61,116.34 128.61,116.49 128.69,116.57 129.01,116.57 129.07,116.63 129.07,116.78 129,116.85 128.84,116.85 v18(128.84,116.86)
  IN2 w0.076: v18(128.84,116.86) 128.84,116.89 128.89,116.94 128.89,117.93 128.86,117.96 128.86,118.61 128.96,118.7 128.96,119.05 128.76,119.24 128.46,119.55 128.46,119.8 128.64,119.98 128.64,120.53 128.37,120.8 128.37,121.35 128.7,121.68 128.7,121.95 128.49,122.17 128.08,122.17 128.01,122.09 128.01,121.18 127.93,121.1 127.78,121.1 127.67,121.2 127.67,122.09 127.6,122.17 127.45,122.17 127.37,122.09 127.37,121.66 127.29,121.58 127.14,121.58 127.07,121.66 127.07,122.08 126.99,122.15 126.88,122.15 126.74,122.01 v2(126.74,121.92)
M_B_CA_0_1: length 17.3
  IN1 w0.06: 128.18,115.6 128.18,114.8 126.74,113.35 126.74,112.4 v1(126.75,112.38)
  IN1 w0.061: v18(128.08,116.68) 128.05,116.65 128.05,115.78 128.18,115.64 128.18,115.6 ; v18(127.44,119.22) 127.04,119.22 126.5,119.75 126.5,120.54 126.66,120.69 126.84,120.69 126.84,120.69 126.89,120.69 127.14,120.95 127.14,121.15 127.04,121.25 126.9,121.25 126.84,121.19 126.67,121.19 126.51,121.02 126.51,120.85 126.35,120.69 126.34,120.69 126.34,120.69 126.15,120.69 126.15,120.69 126.1,120.69 126,120.8 126,121.53 126.13,121.66 127.25,121.66 127.3,121.72 127.3,121.86 v1(127.24,121.92)
  IN2 w0.076: v18(128.08,116.68) 128.13,116.63 128.13,116.4 128.05,116.33 127.43,116.33 127.37,116.38 127.37,116.46 127.46,116.54 127.77,116.54 127.84,116.61 127.84,116.72 127.75,116.81 127.32,116.81 127.24,116.89 127.24,117.05 127.3,117.12 127.41,117.12 127.49,117.04 127.58,117.04 127.65,117.11 127.65,117.64 127.78,117.77 127.78,118.3 127.59,118.49 127.59,119.06 v18(127.44,119.22)
M_B_CA_0_2: length 18
  IN1 w0.06: v1(126.43,112.13) 126.43,112.14 126.43,112.25 126.43,112.25 126.43,112.51 126.43,112.51 126.43,112.77 126.46,112.8 126.46,113.58 127.21,114.33 127.28,114.33 127.48,114.54 127.48,114.79 127.27,115 127.27,115.89 127.62,116.24 127.62,116.25 127.65,116.28 127.65,117.33 127.67,117.36 127.67,117.91
  IN1 w0.061: 127.67,117.91 127.67,118.05 127.75,118.12 128.18,118.12 128.26,118.2 128.26,118.31 128.21,118.36 127.19,118.36 v18(127.14,118.3) ; v18(127.14,119.55) 126.98,119.7 126.98,120.51 127.31,120.83 127.31,121.14 127.52,121.35 127.52,121.49 127.5,121.51 127.5,122.01 127.37,122.14 127.14,122.14 127.07,122.07 126.96,122.07 126.91,122.12 126.91,122.26 126.97,122.32 126.99,122.34 126.99,122.57 127.11,122.69 127.4,122.69 127.5,122.6 127.5,122.34 127.74,122.1 v1(127.74,121.92)
  IN2 w0.076: v18(127.14,118.3) 127.05,118.3 126.81,118.53 126.81,118.86 126.89,118.93 127.14,118.93 127.22,119.01 127.22,119.16 127.14,119.24 126.89,119.24 126.81,119.31 126.81,119.73 126.96,119.88 127.05,119.88 127.28,120.11 127.5,120.11 127.57,120.03 127.57,119.94 127.51,119.88 127.51,119.57 127.42,119.47 127.21,119.47 v18(127.14,119.55)
M_B_CA_0_3: length 18
  IN1 w0.06: v1(124.82,111.89) 124.82,112.1 125.02,112.3 125.02,112.46 125.01,112.47 124.94,112.54 124.94,114.56 124.94,114.56 124.94,115.12 124.94,115.12 124.94,115.93 125.11,116.1
  IN1 w0.061: v18(125.61,118.1) 125.47,118.25 125.47,118.33 125.57,118.43 125.72,118.43 125.89,118.6 125.89,118.79 125.97,118.87 126.12,118.87 126.2,118.79 126.2,118.2 126.42,117.97 126.42,117.87 126.33,117.78 126.22,117.78 125.98,118.02 125.92,118.02 125.85,117.95 125.85,117.95 125.85,117.85 126.1,117.6 126.5,117.6 126.63,117.73 126.63,118.18 126.56,118.25 126.46,118.25 126.38,118.33 126.38,118.48 126.46,118.56 126.56,118.56 126.63,118.63 126.63,118.84 126.56,118.92 126.4,118.92 126.33,118.99 126.33,119.1 126.4,119.18 126.48,119.18 126.56,119.25 126.56,119.41 126.48,119.48 126.4,119.48 126.33,119.56 126.33,120.19 125.77,120.74 125.77,121.53 125.92,121.68 125.92,121.94 126.14,122.15 126.48,122.15 v1(126.74,122.42) ; 125.11,116.1 125.22,116.2 125.22,116.6 v18(125.08,116.73)
  IN2 w0.076: v18(125.61,118.1) 125.49,117.97 125.49,117.82 125.38,117.71 125.09,117.71 125.03,117.66 125.03,117.54 125.09,117.48 125.37,117.48 125.46,117.38 125.46,117.06 125.13,116.73 v18(125.08,116.73)
M_B_CA_0_4: length 16.9
  IN1 w0.06: v1(126.75,110.9) 126.75,111.11 126.95,111.31 126.95,111.48 126.94,111.49 126.94,111.49 126.87,111.56 126.87,111.72 126.94,111.79 126.94,111.79 126.95,111.81 126.95,111.97 126.87,112.05 126.87,112.22 126.89,112.23 126.89,112.23 126.97,112.31 126.97,112.45 126.88,112.54 126.88,113.3 128.34,114.75 128.34,115.65 128.33,115.65 128.33,115.71 128.28,115.76
  IN1 w0.061: 128.28,115.76 v18(128.28,116.1)
  IN2 w0.06: 128.23,116.89 128.31,116.81 128.31,116.13 v18(128.28,116.1)
  IN2 w0.076: 128.23,116.89 128.23,117.2 128.12,117.32 128.12,118.56 127.93,118.74 127.93,118.97 128.08,119.12 128.08,119.24 128.02,119.3 127.95,119.3 127.83,119.43 127.83,119.72 127.96,119.85 128.28,119.85 128.45,120.03 128.45,120.51 128.22,120.75 128.22,120.81 128.13,120.9 127.99,120.9 127.92,120.82 127.92,120.31 127.84,120.24 127.69,120.24 127.32,120.61 127.32,120.8 127.29,120.82 127.29,120.93 127.45,121.09 127.45,121.2 127.35,121.3 127.24,121.3 127.08,121.14 126.97,121.14 126.91,121.21 126.91,121.32 126.96,121.37 126.96,121.48 126.86,121.59 126.75,121.59 126.7,121.54 126.61,121.54 126.52,121.64 126.52,122.03 126.97,122.48 127.18,122.48 v2(127.24,122.42)
M_B_CA_0_5: length 18.3
  IN1 w0.06: 124.8,115.83 124.8,112.4 v1(124.82,112.38)
  IN1 w0.061: v18(125.59,118.68) 125.74,118.83 125.74,118.89 125.87,119.02 126.02,119.02 126.18,119.17 126.18,119.25 126.1,119.33 125.69,119.33 125.62,119.4 125.62,119.55 125.69,119.63 126.1,119.63 126.18,119.71 126.18,119.79 126.1,119.87 125.69,119.87 125.62,119.94 125.62,120.1 125.69,120.17 125.85,120.17 125.92,120.25 125.92,120.35 125.87,120.41 125.73,120.41 125.59,120.54 125.59,121.86 125.93,122.2 125.93,122.31 125.59,122.65 125.59,122.77 125.66,122.85 125.77,122.85 126.2,122.42 126.41,122.42 126.53,122.54 126.53,122.76 126.36,122.92 125.97,122.92 125.9,123 125.9,123.11 125.97,123.18 126.33,123.18 126.34,123.19 126.47,123.32 126.48,123.34 126.48,123.49 126.63,123.64 127.24,123.64 127.3,123.69 127.3,123.86 v1(127.24,123.92) ; 124.8,115.83 124.8,116.17 124.95,116.33 v18(124.98,116.33)
  IN2 w0.076: v18(125.59,118.68) 125.67,118.6 125.67,118.44 125.61,118.38 125.54,118.38 124.78,117.62 124.78,117.38 124.86,117.3 125.18,117.3 125.24,117.24 125.24,117.12 125.08,116.96 124.96,116.96 124.8,116.81 124.8,116.48 124.96,116.33 v18(124.98,116.33)
M_B_CA_0_6: length 18.2
  IN1 w0.06: 125.69,115.58 125.69,115.2 125.59,115.11 125.59,113.65 125.58,113.63 125.58,113.62 125.56,113.6 125.56,112.67 125.66,112.57 125.66,112.3 125.55,112.18 125.55,112.09 125.66,111.97 125.66,111.8 125.55,111.69 125.45,111.69 125.34,111.58 125.34,111.56 125.22,111.44 125.06,111.44 125.05,111.45 125,111.5 124.92,111.5 v1(124.82,111.4)
  IN1 w0.061: 125.69,115.58 125.65,115.61 125.65,115.62 125.56,115.71 125.56,117.32 124.96,117.93 124.96,119.37 125.13,119.55 125.13,124.75 125.39,125.01 127.11,125.01 127.48,124.64 127.48,123.93 127.56,123.84 127.67,123.84 v1(127.74,123.91)
M_B_CA_0_7: length 17.2
  IN1 w0.06: v1(125.46,111.4) 125.82,111.4 125.86,111.44 125.87,111.44 125.99,111.56 125.99,111.72 125.91,111.8 125.91,111.97 125.99,112.05 125.99,112.22 125.92,112.28 125.92,112.28 125.91,112.3 125.91,112.46 125.94,112.5 125.94,112.82 125.81,112.96 125.81,113.49 125.99,113.67 125.99,115.67
  IN1 w0.061: 125.99,115.67 125.92,115.74 125.92,117.45 125.31,118.06 125.31,119.17 125.44,119.29 125.44,123.19 125.72,123.47 125.72,123.58 125.55,123.74 125.55,123.85 125.66,123.96 125.77,123.96 126.04,123.69 126.15,123.69 126.22,123.76 126.22,123.86 125.89,124.19 125.89,124.3 126,124.4 126.1,124.4 126.66,123.84 126.86,123.84 127.02,124 127.02,124.26 126.86,124.42 v1(126.74,124.42)
M_B_CA_0_8: length 16.9
  IN1 w0.06: v1(125.79,112.13) UC1.BM34 125.78,112.75 125.69,112.85 125.69,113.54 125.77,113.62 125.77,114.63 125.84,114.7 125.84,115.62
  IN1 w0.061: v1(127.24,124.42) 127.24,124.66 127.04,124.86 126.6,124.86 126.52,124.78 126.52,124.55 126.45,124.48 126.29,124.48 126.22,124.55 126.22,124.78 126.14,124.86 125.99,124.86 125.91,124.78 125.91,124.55 125.84,124.48 125.68,124.48 125.61,124.55 125.61,124.78 125.53,124.86 125.45,124.86 125.28,124.69 125.28,124.43 125.36,124.36 125.49,124.36 125.57,124.28 125.57,124.13 125.49,124.05 125.36,124.05 125.28,123.98 125.28,119.44 125.13,119.3 125.13,117.98 125.74,117.37 125.74,115.73 125.79,115.68 125.79,115.67 125.84,115.62
M_B_CA_0_9: length 18
  IN1 w0.06: 125.42,115.67 125.52,115.57 125.52,115.56 125.55,115.52 125.55,115.32 125.41,115.18 125.41,112.65 125.46,112.6 v1(125.46,112.38)
  IN1 w0.061: v1(127.74,124.42) 127.98,124.66 128.44,124.66 128.58,124.8 128.58,125.02 128.41,125.19 125.26,125.19 124.96,124.88 124.96,119.6 124.78,119.42 124.78,117.85 125.38,117.24 125.38,115.7 125.42,115.67
