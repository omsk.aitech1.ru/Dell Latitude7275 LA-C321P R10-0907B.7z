# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTB_HD2CA_1_P: length 24.8
  TOP w0.14: C1273.1 arc(17.7,32.68) 17.58,32.75 arc(17.34,32.73) v7(17.13,32.61)
  BOTTOM w0.14: v7(17.13,32.61) 17.08,32.65 arc(17.04,32.68) 16.99,32.69 16.94,32.69 arc(16.89,32.68) 16.85,32.65 16.52,32.32 arc(16.49,32.27) 16.48,32.22 16.48,29.54 arc(16.37,28.98) 16.05,28.51 14.12,26.58 arc(13.86,26.2) 13.77,25.75 13.77,24.61 arc(13.84,24.46) 13.99,24.39 D84.2 13.99,24.22 arc(13.83,23.98) 13.78,23.71 13.78,22.31 arc(13.68,21.82) 13.4,21.41 13.09,21.1 arc(12.94,20.86) 12.88,20.59 12.88,19.88 arc(12.71,19.02) 12.22,18.28 8.43,14.49 arc(8.25,14.37) 8.04,14.33 6.9,14.33 arc(6.73,14.26) JUSBC2.B2
TBTB_HPD: length 337.6
  TOP w0.076: UT1.G2 22.95,30.72 23.18,30.49 23.18,29.97
  TOP w0.119: 23.18,29.97 23.18,29.82 23.64,29.36 v1(23.64,28.52) ; R1437.2 32.02,53.9 v1(32.04,53.88)
  IN1 w0.089: v3(44.48,94.17) 46.7,94.17 47.72,95.18 49.82,95.18 50.35,94.65 51.95,94.65 53.7,96.4 62.8,96.4 64.89,94.31 76.12,94.31 77.22,93.2 79.86,93.2 80.24,93.58 86.75,93.58 88.55,95.39 88.55,97.67 90.7,99.82 90.7,101.21 91.24,101.76 92.64,101.76 94.24,103.36 94.24,106.03 94.95,106.74 94.95,117 94.15,117.81 94.15,122.19 v5(94.27,122.31) ; v1(233.31,122.25) 233.05,121.99 232.19,121.99 232.06,122.12 232.06,122.99 231.58,123.48 230.65,123.48 230.48,123.64 230.3,123.64 229.96,123.98 229.8,123.98 229.47,123.65 228.98,123.65 228.71,123.92 227,123.92 226.92,124 226.54,124 224.64,125.9 223.61,125.9 223.44,126.07 218.51,126.07 218.36,126.23 217.47,126.23 217.23,126.46 216.14,126.46 215.91,126.23 215.16,126.23 214.82,125.88 213.94,125.88 213.59,126.24 211.32,126.24 210.47,125.39 210.47,124.49 209.52,123.54 208.84,123.54 208.07,122.77 207.66,122.77 206.56,121.67 205.83,121.67 205.49,121.33 205.49,120.86 205.29,120.66 204.84,120.66 204.48,120.29 204.48,119.87 204.28,119.67 203.79,119.67 203.38,119.27 199.56,119.27 197.39,117.1 197.39,116.03 191.7,110.34 191.7,108.95 191.36,108.62 191.36,107.69 190.8,107.13 190.8,106.63 189.53,105.36 189.53,104.23 188.91,103.61 187.58,103.61 187.23,103.27 183.05,103.27 182.7,102.91 179.91,102.91 179.66,102.66 172.31,102.66 171.9,103.07 167.49,103.07 167.38,103.18 165.48,103.18 165.39,103.09 157.77,103.09 156.4,104.47 153.88,104.47 152.61,105.73 152.61,108.49 151.54,109.56 v8(151.54,109.85) ; v3(37.09,93.9) 37.09,93.82 34.85,91.58 33.91,91.58 31.47,89.14 31.47,88.45 31.08,88.06 31.08,83.9 30.63,83.46 30.63,80.63 29.79,79.79 29.79,78.19 28.89,77.29 28.89,76.13 28.18,75.42 28.18,73.48 27.93,73.22 27.93,62.21 30.87,59.27 30.87,55.15 32.04,53.98 v1(32.04,53.88) 32.05,53.88 32.32,53.61 32.32,50.48 32.6,50.2 32.6,44.84 32.25,44.5 32.25,44.33 31.48,43.57 31.48,42.84 30.53,41.89 30.53,40.67 29.86,40.01 29.86,36.93 29.76,36.82 29.76,33.77 28.78,32.79 27.37,32.79 26.83,32.24 26.83,31.26 26.79,31.22 26.79,29.41 26.3,28.91 26.3,28.51 24.91,27.12 24.38,27.12 24.06,27.44 24.06,27.97 23.64,28.39 v1(23.64,28.52)
  GND1 w0.119: v8(151.54,109.85) 151.5,109.89 151.5,110.26 v4(151.49,110.27) ; v4(94.67,122.31) v5(94.27,122.31)
  IN2 w0.084: v3(44.48,94.17) 43.58,94.17 43.11,94.64 41.97,94.64 41.23,93.9 v3(37.09,93.9)
  GND3 w0.119: v4(151.49,110.27) 151.36,110.4 141.49,110.4 140.76,109.66 140.01,109.66 138.84,110.83 138.54,110.83 138.09,110.38 137.46,110.38 137.27,110.57 132.35,110.57 131.57,111.36 117,111.36 111.68,116.68 100.43,116.68 96.02,121.09 96.02,122.06 95.73,122.35 94.71,122.35 v4(94.67,122.31)
TBTB_I2C_ALERT#: length 29.7
  GND1 w0.119: v10(22.03,30.74) 22.12,30.82 v4(22.12,31.12)
  IN2 w0.084: v4(22.12,31.12) 22.28,31.28 22.28,32.25 22.78,32.75 22.78,33.14 23.51,33.88 25.53,33.88 26.15,34.5 26.44,34.5 26.65,34.7 26.65,35.39 25.95,36.09 25.95,38.41 25.67,38.69 25.67,40.05 26.16,40.53 26.16,42.19 27.44,43.47 27.44,45.12 26.52,46.04 26.52,46.96 25.98,47.5 25.98,48.23 25.65,48.56 25.65,49.13 25.55,49.23 25.55,50.68 v2(22.75,53.48)
  GND4 w0.119: v4(22.12,31.12) 21.73,30.73 v9(21.69,30.73)
TBTB_I2C_D_N: length 56.6
  TOP w0.112: R5680.2 28,46.9 v7(28.45,46.9)
  IN1 w0.066: v7(15.73,19.72) 15.73,19.65 15.4,19.32 15.05,19.32 14.46,18.73 14.46,17.76 15.32,16.9 15.32,15.7 15.27,15.65 15.02,15.65 14.95,15.58 v1(14.95,15.42) 15.2,15.42 15.3,15.32 15.3,15.2 15.22,15.12 14.89,15.12 14.23,15.78 8.75,15.78 8.35,16.18 8.35,16.37 8.13,16.58 7.66,16.58 7.45,16.8 JUSBC2.B7
  BOTTOM w0.112: v7(28.45,46.9) 28.62,47.06 29.79,47.06 34.21,42.64 34.21,34.66 23.94,24.4 20.31,24.4 17.29,21.38 17.29,20.61 16.17,19.48 15.91,19.48 15.73,19.66 v7(15.73,19.72)
TBTB_I2C_D_N_R: length 3.4
  TOP w0.112: R5680.1 26.59,47.14 26.26,47.14 25.77,47.63 25.77,49.46 U719.L7
TBTB_I2C_D_P: length 56.6
  TOP w0.112: R5681.2 28.07,47.46 v7(28.45,47.46)
  IN1 w0.066: v7(15.73,19.14) 15.12,19.14 14.64,18.65 14.64,17.84 15.5,16.98 15.5,15.57 v1(15.65,15.42) 15.48,15.25 15.48,15.12 15.29,14.94 14.82,14.94 14.15,15.6 8.68,15.6 8.17,16.11 8.17,16.29 8.06,16.4 7.75,16.4 JUSBC2.B6
  BOTTOM w0.112: v7(28.45,47.46) 28.59,47.32 29.9,47.32 33.24,43.97 34.47,42.75 34.47,34.56 24.05,24.14 20.42,24.14 17.55,21.27 17.55,20.5 16.27,19.22 15.88,19.22 15.88,19.22 15.82,19.22 v7(15.73,19.14)
TBTB_I2C_D_P_R: length 3.5
  TOP w0.06: 26.03,49.25 26.03,49.33 26,49.36 26,49.65 25.75,49.9 U719.K7
  TOP w0.112: R5681.1 26.69,47.4 26.36,47.4 26.03,47.73 26.03,49.25
TBTB_LDO_BMC: length 5
  TOP w0.119: U719.E1 22.59,52.48 22.08,52.99 22.08,53.61 21.11,54.58 21.11,55.48 21.32,55.68 21.32,56.22 C1344.1
TBTB_LSRX: length 25.2
  TOP w0.119: v1(23.27,47.54) 23.27,47.44 R5725.1
  IN1 w0.089: v1(23.27,47.54) 23.74,47.54 24.06,47.86 24.82,47.86 25.03,47.66 25.39,47.66 v3(25.77,47.28)
  GND1 w0.119: v3(25.77,47.28) 25.72,47.28 25.48,47.52 25.48,47.63 v4(25.46,47.66) ; v4(21.09,32.29) 20.83,32.29 v10(20.65,32.12)
  IN2 w0.084: v4(21.09,32.29) 21.12,32.32 21.12,33.83 21.29,34 21.29,35.49 20.67,36.11 20.67,37.58 21.09,38 23.49,38 24.19,38.7 24.19,39.81 24.45,40.06 24.45,41.95 26.04,43.54 26.04,45.23 26.05,45.24 26.05,47.01 v3(25.77,47.28)
  IN3 w0.084: v6(25.85,47.66) v4(25.46,47.66)
  GND4 w0.119: v4(21.09,32.29) 21.08,32.28 v9(20.67,32.28)
  BOTTOM w0.119: v6(25.85,47.66) 26.14,47.95 R5693.1
TBTB_LSRX_DEG4: length 3.9
  IN2 w0.084: v2(24.25,49.98) 23.91,49.63 23.91,48.5 24.14,48.27 24.14,48.04 23.7,47.61 23.7,47.2 23.96,46.95 v2(24.34,46.95)
TBTB_LSRX_R: length 0.9
  BOTTOM w0.119: R5695.1 R5693.2
TBTB_LSTX: length 28
  TOP w0.119: R5726.1 R5724.1 v10(24.47,47.54)
  IN1 w0.089: v3(25.77,46.86) 25.19,47.44 24.57,47.44 v10(24.47,47.54)
  GND1 w0.119: v4(21.09,31.78) 20.78,31.78 v10(20.65,31.66) ; v10(24.47,47.54) 24.15,47.54 v4(24.06,47.46)
  IN2 w0.084: v4(21.09,31.78) 20.89,31.78 20.66,32.01 20.66,32.44 20.94,32.72 20.94,33.75 20.48,34.21 20.48,37.66 21.01,38.18 23.41,38.18 24.01,38.78 24.01,39.89 24.26,40.14 24.26,42.03 25.81,43.58 25.81,46.82 v3(25.77,46.86)
  IN3 w0.084: v4(24.06,47.46) 24.29,47.68 24.29,49.03 v6(24.7,49.44)
  GND4 w0.119: v4(21.09,31.78) 21.08,31.77 20.73,31.77 v9(20.67,31.71)
  BOTTOM w0.119: v9(20.67,31.71) 20.67,31.54 20.41,31.28 20.05,31.28 19.93,31.16 19.93,29.93 20.26,29.6 R5696.1 ; R5692.1 v6(24.7,49.44)
TBTB_LSTX_DEG3: length 1.4
  TOP w0.076: R5724.2 24.43,48.59 24.25,48.76 U719.L4
TBTB_LSTX_R: length 0.7
  BOTTOM w0.119: R5694.1 R5692.2
TBTB_PD_SBU1: length 14.7
  IN1 w0.089: v1(28.47,45.79) 26.85,47.41 26.85,47.54 27.84,48.52 27.84,48.67 27.73,48.77 27.58,48.77 26.65,47.84 26.42,47.84 26.04,48.22 26.04,49.76 v10(26.25,49.98)
  GND1 w0.119: v10(26.25,49.98) 26.67,49.98 v4(26.7,49.94)
  IN3 w0.084: v6(26.56,49.44) 26.84,49.44 26.97,49.31 26.97,49.17 26.82,49.02 25.63,49.02 25.33,49.32 25.33,49.44 25.59,49.7 25.71,49.7 26.02,49.39 26.14,49.39 26.26,49.51 26.26,49.63 25.95,49.94 25.95,50.06 26.04,50.15 26.24,50.15 26.5,50.4 26.82,50.4 26.94,50.27 26.94,50.1 26.79,49.94 v4(26.7,49.94)
TBTB_PD_SBU2: length 13.7
  TOP w0.119: R1458.1 26.7,45.93 27.03,46.26 28.78,46.26 29.08,46.55 29.08,47.23 28.94,47.38 28.94,47.54 28.34,48.14 26.94,48.14 v7(26.44,48.65) 26.25,48.83 U719.L8
  BOTTOM w0.119: R5695.2 27.22,47.95 27.5,47.67 27.73,47.67 28.01,47.95 28.31,47.95 28.44,48.08 28.44,48.29 27.63,49.11 27.46,49.11 27.34,48.99 27.34,48.5 27.22,48.38 26.98,48.38 26.86,48.5 26.86,48.99 26.74,49.11 26.63,49.11 26.44,48.92 v7(26.44,48.65)
TBTB_RESET_N: length 4.2
  TOP w0.119: D101.1 30.9,52.78 30.68,52.56 28.95,52.56 28.36,51.98 U719.F11
TBTB_SBU1: length 50
  TOP w0.119: R1457.2 27.13,45.79 v1(27.01,45.66) ; JUSBC2.A8 8.08,15.76 7.93,15.91 v1(7.93,17.47)
  IN1 w0.081: 7.87,18.41 7.87,18.03 7.93,17.97 7.93,17.65
  IN1 w0.089: v1(27.01,45.66) 19.92,45.66 18.65,44.39 18.65,40.76 17.74,39.84 17.74,38.53 v3(17.57,38.36) ; v3(17.8,30.7) 17.41,30.31 17.41,30.02 16.87,29.48 16.87,29.19 15.58,27.9 15.45,27.9 14.93,27.38 14.93,24.75 15.2,24.48 15.2,22.5 15.03,22.33 14.03,22.33 v1(13.74,22.04) 12.9,21.21 12.9,20.23 12.36,19.69 12.05,19.69 11.6,20.14 11.49,20.14 11.35,20 11.35,19.89 11.63,19.6 11.63,19.5 11.49,19.35 11.45,19.35 10.85,19.95 10.57,19.95 10.14,20.38 9.28,20.38 7.87,18.97 7.87,18.41 ; 7.93,17.65 v1(7.93,17.47)
  IN2 w0.084: v3(17.57,38.36) 17.48,38.27 17.48,37.54 18.09,36.94 18.09,36.72 18.41,36.39 18.89,36.39 19.27,36.01 19.27,34.48 17.96,33.17 17.96,30.86 v3(17.8,30.7)
TBTB_SBU2: length 50
  IN1 w0.089: v1(25.23,45.93) 25.2,45.96 19.95,45.96 18.46,44.47 18.46,40.85 17.51,39.89 17.51,38.77 v3(17.46,38.72) ; v3(14.84,22.66) 14.84,24.57 14.74,24.67 14.74,27.62 16.68,29.56 17.12,30 v3(17.12,31.46) ; v2(13.46,15.17) 13.28,14.99 v3(11.41,14.99)
  IN2 w0.084: v3(11.41,14.99) 11.26,14.99 10.24,16.01 8.99,16.01 7.63,17.37 6.71,17.37 JUSBC2.B8 ; v3(14.84,22.66) 14.38,22.21 14.38,16.57 13.57,15.76 13.57,15.29 v2(13.46,15.17) ; v3(17.46,38.72) 17.29,38.55 17.29,37.45 17.68,37.05 17.68,34.65 17.77,34.57 18.71,34.57 18.79,34.49 18.79,34.31 18.71,34.23 17.77,34.23 17.68,34.15 17.68,33.9 17.77,33.82 17.97,33.82 18.05,33.74 18.05,33.57 17.97,33.48 17.77,33.48 17.68,33.4 17.68,31.49 17.61,31.42 17.16,31.42 v3(17.12,31.46)
TBTB_TX0_N: length 2.5
  TOP w0.076: UT1.B11 20.54,34.76 arc(20.41,34.68) 20.27,34.65 19.84,34.65 arc(19.74,34.63) 19.66,34.58 19.38,34.3 arc(19.29,34.24) 19.18,34.22 18.89,34.22 arc(18.66,34.17) 18.47,34.04 C1279.2
TBTB_TX0_P: length 2.5
  TOP w0.076: C1277.2 18.44,34.56 arc(18.64,34.42) 18.89,34.37 19.18,34.37 arc(19.23,34.38) 19.27,34.41 19.88,35.02 arc(19.98,35.09) 20.11,35.11 20.22,35.11 arc(20.29,35.08) 20.33,35 20.33,35 arc(20.29,34.91) 20.21,34.88 UT1.A11
TBTB_TX1_N: length 2.8
  TOP w0.076: UT1.B9 20.56,34.06 arc(20.42,34.15) 20.25,34.19 19.97,34.19 arc(19.8,34.15) 19.66,34.05 18.91,33.31 arc(18.91,33.31) 18.9,33.3 arc(18.72,33.18) 18.51,33.14 C1275.2
TBTB_TX1_P: length 2.8
  TOP w0.076: UT1.A9 20.27,33.96 arc(20.33,33.94) 20.35,33.88 20.35,33.84 arc(20.31,33.76) 20.23,33.73 19.73,33.73 arc(19.56,33.69) 19.42,33.6 18.96,33.13 18.9,33.08 18.42,32.59 arc(18.38,32.57) C1273.2
TBTB_USB2_D_N: length 14.3
  IN2 w0.066: v2(21.35,38.59) 21.47,38.59 21.59,38.71 21.59,38.82 22.1,39.33 22.1,41.88 22.34,42.12 22.34,45.23 23.08,45.97 24.22,45.97 24.92,46.68 24.92,47.93 24.61,48.25 24.51,48.25 24.17,48.59 24.17,49.5 24.52,49.85 24.63,49.85 v2(24.75,49.98)
TBTB_USB2_D_N_R: length 50.1
  TOP w0.089: U719.L6 25.25,49.44 v7(24.67,48.85)
  TOP w0.112: R95.1 15.04,16.37 ML7.1 15.57,16.55 15.71,16.69 16.16,16.69 16.38,16.91 16.38,17.81 v1(16.59,18.02)
  IN1 w0.066: v1(16.59,18.02) 16.33,18.28 16.33,18.79 16.67,19.14 16.67,20.12 16.17,20.62 15.86,20.62 15.63,20.85 v7(15.63,20.9)
  BOTTOM w0.112: v7(24.67,48.85) 24.75,48.85 24.96,48.64 24.96,47.39 25.96,46.4 27.27,46.4 28.37,45.29 28.93,45.29 29.22,45 29.5,45 33.33,41.17 33.33,35.1 23.62,25.4 20.07,25.4 16.37,21.71 16.37,21.08 16.05,20.77 15.76,20.77 v7(15.63,20.9)
TBTB_USB2_D_P: length 14.2
  IN2 w0.066: v2(22,38.59) 21.81,38.59 21.74,38.67 21.74,38.76 22.25,39.27 22.25,41.82 22.49,42.06 22.49,45.16 23.14,45.82 24.28,45.82 25.07,46.61 25.07,47.99 24.67,48.4 24.57,48.4 24.31,48.65 24.31,49.44 24.58,49.7 24.67,49.7 24.75,49.62 v2(24.75,49.48)
TBTB_USB2_D_P_R: length 50.1
  TOP w0.076: v7(25.25,48.88) 25.25,49.11 25.5,49.35 25.5,49.84 25.36,49.98 U719.K6
  TOP w0.112: v1(15.89,18.02) 16.12,17.79 16.12,17.02 16.05,16.95 15.74,16.95 15.64,17.05 ML7.4 15.04,17.23 R121.1
  IN1 w0.066: v1(15.89,18.02) 16.15,18.28 16.15,18.87 16.49,19.21 16.49,20.05 16.1,20.44 15.75,20.44 v7(15.63,20.32)
  BOTTOM w0.112: v7(25.25,48.88) 25.22,48.84 25.22,47.5 26.07,46.66 27.37,46.66 28.48,45.55 29.04,45.55 29.33,45.26 29.61,45.26 33.59,41.28 33.59,35 23.73,25.14 20.17,25.14 16.63,21.6 16.63,20.98 16.16,20.51 15.79,20.51 15.63,20.35 v7(15.63,20.32)
TBTB_USB_OC1#: length 226
  IN1 w0.089: v1(25.13,47.1) 24.7,46.67 21.72,46.67 21.63,46.76 18.85,46.76 v3(18.35,46.25)
  IN2 w0.06: 137.17,96.2 137.04,96.32 137.04,96.33 136.61,96.76 136.61,97.26 136.92,97.57 136.92,98.13 136.79,98.26 136.79,98.87 136.51,99.15 136.14,99.15 135.61,99.68 134.39,99.68 133.85,100.22 132.99,100.22 v2(132.93,100.28)
  IN2 w0.084: v7(19.2,87.63) 18.82,87.24 17.85,87.24 17.06,86.46 17.06,79.76 17.95,78.87 17.95,66.58 20.9,63.64 20.9,61.58 22.4,60.08 22.4,56.82 21.04,55.46 21.04,52.8 20.79,52.55 20.79,51.75 20.25,51.2 20.25,49 18.35,47.09 v3(18.35,46.25) ; v4(45.57,81.26) 45.62,81.21 45.62,80.93 46.18,80.37 46.68,80.37 47.41,79.64 132.62,79.64 134.7,81.72 v4(134.7,82.62) ; v4(147.99,90.71) 144.34,90.71 143.52,91.53 139.81,91.53 139.31,92.03 139.31,93.95 137.36,95.9 137.36,95.96 v4(137.23,96.1) 137.17,96.16 137.17,96.2
  IN3 w0.084: v6(49.64,81.64) 49.43,81.85 46.68,81.85 46.09,81.26 v4(45.57,81.26)
  GND4 w0.119: v9(148.37,90.13) 148.37,90.33 v4(147.99,90.71) ; v4(137.23,96.1) 137.24,96.08 v9(137.65,96.08) ; v4(134.7,82.62) 134.7,82.84 v9(134.5,83.05)
  BOTTOM w0.119: v7(19.2,87.63) 19.21,87.64 20.9,87.64 22.58,89.33 26.81,89.33 27.91,88.22 30.82,88.22 31.94,89.33 42.65,89.33 49.64,82.35 v6(49.64,81.64) ; v9(148.37,90.13) 148.29,90.13 143.9,85.74 141.88,85.74 141.41,85.26 136.76,85.26 134.55,83.05 v9(134.5,83.05)
TBTB_VBUS: length 12.2
  GND1 w0.254: v10(13.67,22.83) 13.21,22.83 v4(13.2,22.84)
  IN3 w1.016: 30.07,54.96 30.07,56.15 30.5,56.59 30.5,62.62
  BOTTOM w0.254: C1361.2 8.64,16.35 JUSBC2.B4 ; C1360.2 8.49,17.57 7.63,17.57 7.45,17.75 JUSBC2.B9
  vias: v1(31.16,46.55) v1(31.15,46.25) v1(31.49,46.55) v1(31.49,46.25) v1(31.8,46.57) v1(31.81,46.25) v2(9,17.75) v2(9,15.25) v2(10.56,12.84) v2(10.75,19.64) v2(13.75,18.66) v4(8.26,17.72) v4(8.35,17.2) v4(11.51,23.88) v4(11.55,23.32) v4(11.46,22.04) v4(13.11,23.89) v4(13.08,23.33) v4(28.1,49.91) v4(28.42,50.26) v4(28.92,50.31) v4(29.14,49.89) v4(29.41,50.34) v4(29.61,49.91) v4(30.3,63.65) v4(30.79,63.64) v5(29.14,49.42) v5(29.15,49.08) v5(29.46,49.44) v5(29.48,49.06) v5(29.8,49.45) v5(29.8,49.08) v6(9.44,53.06) v6(9.44,52.74) v6(9.76,53.06) v6(9.76,52.74) v6(10.08,53.06) v6(10.08,52.74) v6(10.46,53.06) v6(10.46,52.74) v6(10.78,53.06) v6(10.78,52.74) v6(29.85,54.24) v6(30.19,54.22) v7(19.56,52.91) v7(20.06,52.65) v7(47.69,104.29) v7(47.87,103.75) v7(48.25,104.29) v7(48.85,104.26) v7(49.41,104.28) v9(29.85,50.35) v9(29.98,50.07) v9(30.18,50.33) v9(30.19,49.83) v9(30.37,50.08) v9(30.52,49.82) v10(30.79,63.2) v10(31.08,63.01) v11(35.89,45.45) v11(35.89,44.84) v13(29.88,49.06) v13(32.11,47.94) v16(28.04,50.71) v16(28.38,50.71) v16(28.8,50.72) v16(29.15,50.72) v16(29.47,50.72) v16(29.8,50.73)
TBTB_VBUS_L: length 6.9
  TOP w0.254: U719.B10 U719.A10 27.13,54.6 v7(27.13,54.95)
  BOTTOM w0.508: v7(28.63,49.7) 27.63,50.71 27.63,53.46 27.13,53.96 v7(27.13,54.95)
TP_DDR_DRAM_RST_N: length 2.1
  TOP w0.119: UC1.BP20 130.29,114.7 TC16.1
TPM_DET: length 28.7
  TOP w0.119: v1(152.41,101.15) 152.63,101.38 RH147.1 154.95,101.86 155.99,101.86 156.37,101.48 RH146.2
  IN1 w0.06: 139.85,111.37 139.6,111.37 139.17,110.95 137.55,110.95 137.36,111.13 136.98,111.13 136.67,110.82 135.83,110.82 135.36,111.3 134.63,111.3 v1(134.56,111.37)
  IN1 w0.089: 139.85,111.37 143.15,111.37 143.54,110.98 143.54,110.98 143.69,110.83 144.47,110.83 144.7,110.6 145.22,110.6 145.42,110.4 145.42,110.37 146.04,109.75 146.04,109.28 148.43,106.89 148.43,104.77 152.05,101.15 v1(152.41,101.15)
TPM_GPIO0: length 2.7
  TOP w0.119: U15.29 199.13,136.09 199.78,136.74 200.63,136.74 R5715.2
TPM_GPIO4: length 1.4
  TOP w0.119: R5714.2 199.45,129.9 199.63,130.09 U15.13
TPM_IRQ#: length 122.5
  TOP w0.119: U15.18 202.48,131.87 202.67,132.06 v7(203.03,132.06)
  IN1 w0.06: v5(138.59,97.82) 138.59,97.42 138.69,97.32
  IN1 w0.089: 138.69,97.32 139.25,96.76 139.9,96.76 140.19,96.46 140.41,96.46 140.85,96.02 141.59,96.02 142.33,95.28 143.34,95.28 143.64,94.98 144.32,94.98 144.39,94.9 149.9,94.9 150.28,95.28 151.94,95.28 152.27,95.61 153.55,95.61 153.9,95.97 154.92,95.97 155.71,95.18 156.19,95.18 156.43,94.95 158.61,94.95 159.29,94.27 165.39,94.27 168.05,91.61 178.2,91.61 180.18,93.59 183.62,93.59 184.03,93.18 187.08,93.18 191.04,97.14 193,97.14 194.21,98.35 196.45,98.35 197.1,99 197.1,100.92 196.13,101.88 196.13,102.75 196.72,103.34 196.72,104.09 197.89,105.27 198.17,105.27 202.03,109.13 203.91,109.13 208.05,113.27 208.05,113.48 208.49,113.91 208.71,113.91 210.51,115.71 v7(210.51,116.16)
  GND1 w0.119: v4(138.33,98.15) 138.59,97.9 v5(138.59,97.82)
  IN2 w0.06: v2(133.17,100.6) 133.26,100.69 133.47,100.69 133.58,100.8 133.75,100.8 133.87,100.69 133.9,100.69 134.53,100.06 135.74,100.06 136.28,99.53 137.01,99.53 138.33,98.2 v4(138.33,98.15)
  IN3 w0.084: v7(203.03,132.06) 203.23,131.86 203.23,130.32 202.5,129.59 202.5,119.69 203.22,118.96 204.46,118.96 207.26,116.16 v7(210.51,116.16)
  GND4 w0.119: v9(138.62,97.87) 138.61,97.87 v4(138.33,98.15)
  BOTTOM w0.119: v9(138.62,97.87) 138.94,97.87 139.47,97.35 RH126.1
TPM_LPM: length 38.5
  TOP w0.119: R5713.1 195.35,133.31 194.88,133.78 v1(194.88,134.07) ; R5716.1 200.59,147.95 200.59,147.02 Q344.1 199.55,145.22 199.8,144.97 200.67,144.97 201.19,144.45 201.19,143.58 202.25,142.51 v2(202.25,141.32)
  IN1 w0.089: v1(194.88,134.07) 201.84,134.07 203.25,135.48 204.05,135.48 207.56,138.99 209.75,138.99 210.37,139.61 210.37,139.81 v5(210.39,139.84)
  GND1 w0.119: v12(210.7,141.04) 210.7,140.24 210.39,139.94 v5(210.39,139.84)
  IN2 w0.084: v12(210.7,141.04) 204.84,141.04 204.46,140.66 203.73,140.66 203.06,141.32 v2(202.25,141.32)
TPM_LPM_R: length 1.5
  TOP w0.119: R5713.2 195.79,133.87 U15.3
TS_EN: length 68.5
  TOP w0.119: U34.3 191.22,100.7 R220.2 191.19,100.69 190.61,100.11 189.97,100.11 189.55,99.69 188.61,99.69 188.3,99.37 186.53,99.37 v1(186.52,99.39)
  IN1 w0.06: v1(134.65,108.98) 134.6,108.98 134.25,109.33 134.17,109.33 133.96,109.54 133.96,109.7 134.17,109.91 134.17,109.99 134.35,110.18 134.63,110.18 134.68,110.12 135.26,110.12 135.43,109.96 136.76,109.96 137.16,109.55 137.64,109.55 137.9,109.81 138.24,109.81 138.27,109.84 140.38,109.84 140.51,109.96 141.33,109.96
  IN1 w0.089: 141.33,109.96 141.45,109.96 141.74,110.25 142.22,110.25 142.35,110.38 143.33,110.38 143.45,110.25 144.24,110.25 145.16,109.33 145.46,109.33 148.05,106.73 148.05,104.59 152.32,100.33 152.67,100.33 152.94,100.06 152.94,99.76 153.47,99.23 156.39,99.23 156.46,99.17 160.56,99.17 160.82,98.91 163.69,98.91 164.05,99.27 167.88,99.27 168.61,100.01 173.57,100.01 173.7,99.87 176.29,99.87 176.43,100.01 176.91,100.01 177.3,99.61 179.3,99.61 179.34,99.56 180.36,99.56 181.02,98.91 183.59,98.91 183.79,98.71 185.47,98.71 186.14,99.39 v1(186.52,99.39)
TS_I2C_SCL: length 63.4
  TOP w0.152: v2(142.53,100.25) 142.54,100.26 142.54,100.57 142.81,100.83 RC82.1
  IN2 w0.06: 139.55,101.53 139.55,102.73 139.12,103.16 138.28,103.16 138.24,103.2 137.37,103.2 137.22,103.35 136.56,103.35 135.88,104.03 133.76,104.03 133.55,103.83 133.46,103.83 133.21,103.58 133,103.58 v2(132.93,103.5)
  IN2 w0.084: v2(184.17,100.47) 184.13,100.43 182.08,100.43 181.71,100.06 176.86,100.06 176.8,100 176.45,99.65 173.53,99.65 172.17,98.3 168.96,98.3 168.31,97.65 168.31,96.12 168.04,95.85 167.49,95.85 167.16,96.17 164.82,96.17 163.57,94.93 160.67,94.93 159.94,95.65 157.22,95.65 157,95.87 152.96,95.87 152.71,95.62 150.31,95.62 147.53,98.39 146.8,98.39 146.35,98.85 145.57,98.85 144.17,100.25 v2(142.53,100.25) 142.18,100.59 141.67,100.59 141.03,101.24 139.85,101.24 139.55,101.53
TS_I2C_SDA: length 62.5
  TOP w0.152: RC81.1 146.7,100.83 147.02,100.52 v2(147.02,97.91)
  IN2 w0.06: 139.55,100.86 139.4,101.01 139.4,101.84 138.41,102.83 138.41,102.85 138.23,103.03 137.37,103.03 137.17,103.23 136.51,103.23 135.83,103.91 133.81,103.91 133.6,103.71 133.55,103.71 133.42,103.57 v2(133.42,103.5)
  IN2 w0.084: v2(184.14,99.45) 184.11,99.49 181.92,99.49 181.86,99.55 177.01,99.55 176.31,98.85 176.31,97.02 175.96,96.68 169.52,96.68 168.23,95.39 167.29,95.39 166.97,95.71 165.01,95.71 163.76,94.46 160.47,94.46 159.75,95.18 157.02,95.18 156.81,95.4 153.15,95.4 152.63,94.88 150.39,94.88 147.36,97.91 v2(147.02,97.91) 146.63,97.91 146.15,98.38 145.37,98.38 144.03,99.73 142.39,99.73 141.99,100.13 141.48,100.13 141.24,100.37 140.04,100.37 139.55,100.86
TS_INT#: length 70.8
  IN1 w0.06: v8(138.33,97.47) 137.68,98.12 136.46,98.12 136.28,98.3 136.28,98.39 135.15,99.51 134.43,99.51 134.27,99.68 134.16,99.68 133.9,99.93 133.81,99.93 133.62,100.12 133.62,100.36 133.41,100.58 133.41,100.66 132.93,101.13 v2(132.93,101.57)
  GND1 w0.089: v8(138.33,97.47) 137.93,97.47 v4(137.78,97.32)
  IN2 w0.06: v4(137.78,97.32) 137.73,97.37 136.89,97.37 136.73,97.21 136.73,96.81 136.99,96.55 137.32,96.55 137.42,96.45
  IN2 w0.084: 137.42,96.45 137.73,96.15 137.73,96.02 139.65,94.09 139.65,93.56 140.01,93.2 141.28,93.2 141.78,92.71 143.15,92.71 144.79,91.07 149.45,91.07 150.08,91.69 154.03,91.69 154.77,90.96 170.18,90.96 170.97,91.75 174.48,91.75 176.4,89.84 182.59,89.84 188.7,95.94 188.7,96.9 v2(188.66,96.93)
  GND4 w0.089: v9(137.93,97.82) 137.93,97.47 v4(137.78,97.32)
  BOTTOM w0.152: RC10.2 137.76,97.66 v9(137.93,97.82)
TS_INT#_R: length 4.9
  TOP w0.152: JLVDS1.7 189.65,95.51 DI5.3 190.6,96.93 R1017.2
TS_PD#: length 78.6
  TOP w0.119: JLVDS1.1 192.65,94.51 192.41,94.74 v2(192.41,94.83)
  IN1 w0.06: v1(133.42,100.28) 133.21,100.28 133.01,100.08 132.75,100.08 132.48,100.35 132.48,100.61 132.36,100.73 132.35,100.73 132.21,100.88 132.21,101.7 132.59,102.09 132.6,102.09 132.76,102.09 132.85,102 133,102 133.09,102.09 133.09,102.09 133.26,102.09 133.38,101.97 133.38,101.89 133.58,101.7 133.58,101.7 133.58,101.69 133.75,101.69 133.76,101.7 133.76,101.7 133.85,101.79 135.21,101.79 135.96,101.04 136.46,101.04 137.05,100.46 v5(137.36,100.46) 137.97,100.46 138.47,99.96 139.48,99.96 139.91,99.53 140.16,99.53 140.2,99.49
  IN1 w0.089: 140.2,99.49 141.06,98.63 141.06,98.18 141.63,97.61 141.63,97.06 142.6,96.09 143.61,96.09 143.82,95.88 145.52,95.88 146.11,96.47 147.19,96.47 147.67,96.95 150.66,96.95 150.81,97.1 151.45,97.1 152.08,96.48 154.32,96.48 154.62,96.77 155.54,96.77 156.97,95.34 159.75,95.34 159.96,95.14 161.8,95.14 162.21,94.72 165.48,94.72 168.22,91.99 178.04,91.99 179.68,93.63 179.68,94.15 179.95,94.42 183.34,94.42 184.2,93.56 186.92,93.56 190.88,97.52 192.66,97.52 v3(192.74,97.6)
  GND1 w0.119: v5(137.36,100.46) 137.07,100.74 v4(137.03,100.74)
  IN2 w0.084: v2(192.41,94.83) 192.74,95.15 v3(192.74,97.6)
  IN3 w0.084: v4(137.03,100.74) 137.03,100.62 136.2,99.79 v6(136.2,99.67)
TS_RST#: length 79.1
  TOP w0.14: v1(187.64,95.08) 187.94,95.08 188.15,94.88 JLVDS1.10 ; DI5.2 190.39,95.25 v1(190.39,94.88) ; v1(164.45,91.83) 164.45,93.66 R5757.2 RH151.1
  IN1 w0.06: v1(133.28,99.22) 133.39,99.11 133.39,98.76 133.79,98.36 133.79,98.01 134.43,97.37 134.57,97.37 135.06,96.89 136.07,96.89 136.42,96.54
  IN1 w0.084: v3(184.08,94.47) 186.76,94.47 187.37,95.08 v1(187.64,95.08) ; v3(162.62,91.45) 163,91.83 v1(164.45,91.83) 164.48,91.83 166.84,89.47 167.2,89.47 167.59,89.08 171.35,89.08 171.5,89.23 178.84,89.23 v3(181.79,92.18) 181.8,92.17 182.84,92.17 183.37,91.65 187.58,91.65 189.06,93.12 190.11,93.12 190.46,93.47 190.46,94.82 v1(190.39,94.88) ; v3(140.11,93.83) 139.7,94.25 139.61,94.25 139.46,94.4 139.46,94.44 138.77,95.13 138.59,95.13 138.21,95.51 137.73,95.51 136.94,96.3 136.66,96.3 136.42,96.54
  IN2 w0.079: v3(140.11,93.83) 141.3,93.83 141.97,93.17 143.34,93.17 144.98,91.53 149.26,91.53 149.89,92.16 151.19,92.16 151.61,92.58 152.55,92.58 152.97,92.16 154.22,92.16 154.93,91.45 v3(162.62,91.45) ; v3(184.08,94.47) 184.07,94.47 181.98,92.38 181.98,92.37 v3(181.79,92.18)
TX_BLANKING: length 3.1
  BOTTOM w0.119: T17.1 21.05,102.18 JNGFF1.40
UART2_CTS: length 13.5
  IN1 w0.06: 140.06,103.38 138.69,103.38 137.95,104.12 136.94,104.12 136.88,104.18 135.38,104.18 135.09,104.47 134.54,104.47 134.53,104.46 134.44,104.46 134.24,104.26 134.08,104.26 133.99,104.35 133.86,104.35 133.85,104.35 133.83,104.35 133.71,104.23 133.71,104.22 133.5,104.22 v2(133.42,104.15)
  IN1 w0.089: 140.06,103.38 141.22,103.38 141.99,102.61 142.19,102.61 142.41,102.4 142.94,102.4 v5(143.2,102.13)
  GND1 w0.119: v4(142.92,101.12) 142.92,101.12 142.92,101.12 142.92,101.46 143.2,101.74 v5(143.2,102.13)
  GND4 w0.119: v9(142.86,100.31) 142.92,100.38 v4(142.92,101.12)
  BOTTOM w0.089: v9(142.86,100.31) RC203.2
UART2_RXD: length 13.1
  IN1 w0.06: v1(134.41,104.15) 134.52,104.26 134.73,104.26 134.81,104.34 134.82,104.34 134.99,104.34 135.12,104.21 135.17,104.21 135.32,104.06 136.34,104.06 136.7,103.7 136.94,103.7 137.23,104 137.9,104 138.71,103.18 140.06,103.18
  IN1 w0.089: 140.06,103.18 141.15,103.18 141.91,102.42 142.11,102.42 142.33,102.21 142.75,102.21 143.1,101.85 143.41,101.85 v5(143.64,102.08)
  GND1 w0.119: v4(143.47,101.11) 143.64,101.29 v5(143.64,102.08)
  GND4 w0.119: v4(143.47,101.11) 143.47,100.34 v9(143.49,100.31)
  BOTTOM w0.089: v9(143.49,100.31) RC200.2
UART2_TXD: length 10.6
  IN1 w0.06: v1(133.91,104.15) 134,104.06 134.21,104.06 134.3,103.97 134.3,103.97 134.33,103.94 134.49,103.94 134.57,104.03 134.74,104.03 134.82,103.95 135.1,103.95 135.22,103.82 136.24,103.82 136.6,103.46 137.03,103.46 137.1,103.39 137.52,103.39 137.98,102.93 139.53,102.93 139.8,102.66 140.06,102.66
  IN1 w0.089: v5(140.13,102.66) 140.06,102.66
  GND1 w0.119: v5(140.13,102.66) 140.13,102.33 140.14,102.32 v4(140.14,102.13)
  GND4 w0.119: v9(140.31,101.35) 140.3,101.36 140.3,101.87 140.14,102.03 v4(140.14,102.13)
  BOTTOM w0.119: RC201.2 TC83.1 141.19,100.36 140.31,101.24 v9(140.31,101.35)
UART_MISO: length 26.4
  IN1 w0.089: v1(23.25,52.48) 23.5,52.23 23.5,51.84 23.39,51.72 23,51.72 21.99,52.73 21.62,52.73 20.98,53.37 19.37,53.37 18.23,52.23 17.71,52.23 17.65,52.17 15.42,52.17 15.08,52.52 14.14,52.52 14.11,52.49 13.8,52.49 13.58,52.71 11.8,52.71 11.63,52.54 10.22,52.54 v1(9.92,52.23) 9.76,52.23 8.68,53.31 6.15,53.31 5.62,52.78 5.62,48.06 6,47.68 v1(6,47.47)
UART_MOSI: length 19
  IN1 w0.089: v1(7.84,55.11) 7.58,54.84 7.58,54.18 8.14,53.61 8.85,53.61 9.1,53.36 9.1,53.14 9.51,52.73 v1(9.92,52.73) 9.94,52.71 11.51,52.71 12.99,54.19 15.45,54.19 15.75,53.88 18.22,53.88 18.54,53.56 21.06,53.56 21.64,52.98 22.01,52.98 23.01,51.98 v1(23.25,51.98)
UF_AVDD_2.8V: length 60.2
  TOP w0.203: v2(129.13,132.25) 129.24,132.37 J3.3
  TOP w0.508: v11(94.32,134.07) 94.32,134.7 95.08,135.47 99.52,135.47 100.34,134.65 100.34,132.98 101.16,132.15 109.47,132.15 v7(111.28,133.97) 112.88,133.97 113.3,133.55 113.3,132.57 113.94,131.94 121.7,131.94 v2(123.21,133.44)
  IN1 w0.508: v11(94.32,134.07) 93.72,134.07 90.07,130.41 87.34,130.41 86.4,129.47 84.63,129.47 v1(84.37,129.22) ; v7(111.28,133.97) 111.28,132.97 112.69,131.56 v1(112.69,130.27)
  IN2 w0.508: v2(129.13,132.25) 129.13,132.39 128.21,133.3 124.76,133.3 124.62,133.44 v2(123.21,133.44)
  BOTTOM w0.102: v11(94.32,134.07) v14(93.3,134.07)
UF_DVDD_1.2V: length 127.5
  TOP w0.203: v7(125.25,132.66) 125.64,133.06 J3.21
  TOP w0.457: v7(191.19,141.23) 191.19,141.27 190.57,141.89 R116.2
  IN1 w0.508: v5(195.23,140.67) 193.9,140.67 193.21,141.36 191.32,141.36 v7(191.19,141.23)
  GND1 w0.508: v4(195.54,140.34) 195.23,140.65 v5(195.23,140.67)
  IN2 w0.508: 109.3,130.54 v4(110.29,130.54) ; 109.3,130.54 109.3,130.36 109.07,130.13 v2(109.07,129.74) ; 109.3,130.54 109.45,130.69 109.45,132.46 110.33,133.33 111.61,133.33 113.21,134.93 v4(113.21,135.11)
  IN3 w0.508: v4(113.21,135.11) 115.94,135.11 116.39,134.67 122,134.67 124.01,132.66 v7(125.25,132.66)
  GND4 w0.508: v4(110.29,130.54) v9(111.03,130.54) ; v9(196.11,138.91) 196.11,139.77 v4(195.54,140.34)
  BOTTOM w0.508: v9(196.11,138.91) 194.62,137.42 193.15,137.42 188.5,132.77 188.5,131.61 187.64,130.74 177.21,130.74 177.06,130.89 174,130.89 173,129.9 165.32,129.9 165.14,130.07 163.37,130.07 163.13,129.83 162.05,129.83 161.06,130.81 155.18,130.81 154.14,129.77 148.77,129.77 144,125 139.12,125 138.84,124.72 125.86,124.72 v14(124.85,125.74) 120.78,125.74 120.68,125.64 115.35,125.64 113.39,127.6 113.39,128.58 112.71,129.27 112.71,130.12 112.29,130.54 v9(111.03,130.54)
UF_HCLK: length 79.5
  TOP w0.089: v2(188.32,138.41) 188.86,137.87 188.86,137.12 189.55,136.43 189.55,135.83 189.85,135.54 191.07,135.54 191.17,135.64 191.17,136.36 190.93,136.6 C170.1 190.73,137.55 R71.1
  TOP w0.119: J3.7 128.44,133.09 v1(128.48,133.05)
  IN1 w0.089: v1(128.48,133.05) 128.96,133.54 129.55,133.54 130.07,134.06 v3(130.07,134.82)
  IN2 w0.081: 156.06,136.94 156,136.88
  IN2 w0.084: v3(130.07,134.82) 130.07,134.7 130.98,133.79 130.98,133.23 132.19,132.02 141.32,132.02 142.91,133.61 142.91,136.91 143.12,137.12 143.12,137.48 143.4,137.77 143.77,137.77 144.18,137.36 144.18,136.75 144.68,136.24 148.13,136.24 148.44,136.56 150.45,136.56 151.22,135.79 154.91,135.79 156,136.88 ; v2(188.32,138.41) 188.32,137.88 187.6,137.16 183.48,137.16 182.84,136.52 179.87,136.52 179.11,135.75 173.95,135.75 173.19,136.52 161.38,136.52 160.38,135.51 159.8,135.51 158.69,136.62 157.75,136.62 157.3,137.07 156.19,137.07 156.06,136.94
UF_HCLK_R: length 5.9
  TOP w0.119: v1(190.73,139.06) 190.72,139.05 R71.2
  IN1 w0.089: v3(192.22,140.85) 192.22,140.13 191.15,139.06 v1(190.73,139.06)
  IN2 w0.084: v2(194.17,142.1) 193.74,142.1 193.11,141.47 192.84,141.47 v3(192.22,140.85)
UF_I2C_CLK: length 54.7
  TOP w0.119: v1(126.47,132.1) 126.47,133.04 126.84,133.41 J3.15 ; v10(115.27,129.08) RH80.2
  IN1 w0.089: v1(126.47,132.1) 126.4,132.02 124.82,132.02 123.9,132.95 121.56,132.95 120.77,132.16 116.69,132.16 115.04,130.51 115.04,129.31 v10(115.27,129.08)
  GND1 w0.119: v4(115.16,128.7) 115.27,128.81 v10(115.27,129.08)
  IN2 w0.06: v2(134.16,107.04) 134.17,107.04 134.47,107.35 134.8,107.35 v4(134.87,107.41)
  IN3 w0.084: v4(134.87,107.41) 134.81,107.47 134.81,108.88 134.92,108.99 134.92,116.46 132.68,118.7 125.58,118.7 124.31,119.97 124.31,124.67 121.24,127.74 116.87,127.74 115.91,128.7 v4(115.16,128.7)
UF_I2C_DATA: length 58
  TOP w0.119: J3.13 127.24,133.34 126.88,132.98 126.88,132.13 v1(126.87,132.11) ; v10(114.64,129.08) RH81.2
  IN1 w0.089: v10(114.64,129.08) 114.97,128.74 115.34,128.74 115.56,128.96 115.56,129.21 115.25,129.52 115.25,130.45 116.77,131.97 120.85,131.97 121.64,132.76 123.82,132.76 124.77,131.81 126.56,131.81 v1(126.87,132.11)
  GND1 w0.119: v10(114.64,129.08) 114.08,129.08 v4(114.07,129.09)
  IN2 w0.06: v4(135.32,107.17) 135.2,107.04 v2(134.65,107.04)
  IN3 w0.084: v4(114.07,129.09) 115.61,129.09 115.82,128.88 115.99,128.88 116.94,127.93 121.32,127.93 124.52,124.73 124.52,120.03 125.66,118.88 132.78,118.88 135.11,116.56 135.11,108.97 135,108.87 135,107.74 135.32,107.41 v4(135.32,107.17)
UF_SENSOR_RST#: length 12
  TOP w0.119: v1(201.15,146.01) 201.11,146.05 R62.2 R108.2 201.11,147.53 201.42,147.84 201.49,147.84 201.97,148.33 R92.2
  IN1 w0.06: v1(193.76,142.1) 193.96,142.3 194.33,142.3 194.4,142.37 194.42,142.37
  IN1 w0.089: 194.42,142.37 194.47,142.37 195.75,143.65 195.75,143.79 197.04,145.08 200.16,145.08 201.09,146.01 v1(201.15,146.01)
UF_VDD_1.8V: length 160
  TOP w0.203: J3.19 126.04,132.77 v7(125.94,132.67)
  TOP w0.305: C125.1 111.74,130.23 v2(111.72,130.26)
  TOP w0.508: R117.2 192.77,138.01 191.73,136.96 191.73,135.16 190.58,134.02 v7(190.58,133.05)
  IN2 w0.508: v7(200.18,147.63) 199.98,147.84 197.01,147.84 196.4,147.22 192.64,147.22 191.07,145.65 190.33,145.65 188.53,143.84 v2(188.53,143.34) ; 112.15,130.91 112.15,132.84 113.49,134.18 115.4,134.18 v4(115.62,134.4)
  IN3 w0.305: v6(112.07,129.88) 112.2,130.01 v4(112.2,130.28)
  IN3 w0.508: v4(115.62,134.4) 115.96,134.06 121.75,134.06 123.75,132.05 125.5,132.05 125.94,132.49 v7(125.94,132.67)
  BOTTOM w0.508: v7(200.18,147.63) 200.18,145.12 198.44,143.38 198.44,141.26 197.01,139.83 197.01,138.23 195.24,136.46 193.6,136.46 192.93,135.78 192.93,134.06 192.57,133.7 191.23,133.7 v7(190.58,133.05) 189.72,132.19 189.72,130.3 188.59,129.17 187.73,129.17 185.76,127.2 185.76,125.29 183.71,123.25 182.96,123.25 181.92,122.21 179.03,122.21 178.57,122.66 178.57,125.23 177.21,126.59 166.6,126.59 164.6,128.58 163.99,128.58 163.67,128.27 161.48,128.27 160.42,129.33 155.74,129.33 154.73,128.33 149.79,128.33 149.41,127.95 149.41,124.34 148.22,123.15 140.14,123.15 138.74,121.75 126.12,121.75 v14(125.51,122.36) 123.53,124.34 121.39,124.34 121.32,124.42 114.85,124.42 112.05,127.22 112.05,129.85 v6(112.07,129.88)
UIM_CLK: length 60.3
  TOP w0.119: v7(24.01,74.48) 24.29,74.48 C83.1 23.77,73.3 D6.3
  IN1 w0.089: v7(24.01,74.48) 24.28,74.21 24.28,72.69 21.67,70.09 19.25,70.09 17.16,72.17 6.76,72.17 5.54,70.95 v1(5.54,70.76)
  IN2 w0.084: v7(24.01,74.48) 24.01,75 23.73,75.28 23.73,80.39 24.66,81.32 24.66,84.96 25,85.29 25,87.37 25.42,87.8 25.42,94.04 25.17,94.29 v4(25.17,94.66)
  IN3 w0.084: v6(23.88,98.1) 25.17,96.82 v4(25.17,94.66)
  BOTTOM w0.119: v6(23.88,98.1) 25.08,99.3 26.69,99.3 27.62,100.23 27.62,101.58 25.05,104.15 JNGFF1.24
UIM_DATA: length 64.4
  TOP w0.119: v7(26.4,70.95) 26.16,70.72 D6.6 25.67,69.72 v1(25.75,69.64)
  IN1 w0.089: v1(6.51,71) 6.72,71.22 10.17,71.22 11.74,69.64 v1(25.75,69.64)
  IN2 w0.084: v4(26.17,94.43) 25.79,94.06 25.79,87.64 25.37,87.22 25.37,85.14 25.03,84.8 25.03,81.17 24.1,80.23 24.1,75.46 24.48,75.09 25.06,75.09 25.85,74.29 25.85,74.09 25.67,73.91 25.67,71.68 v7(26.4,70.95)
  IN3 w0.084: v6(23.48,98.1) 23.76,98.38 24.54,98.38 26.17,96.76 v4(26.17,94.43)
  BOTTOM w0.076: JNGFF1.26 24.55,104.14
  BOTTOM w0.119: 24.55,104.14 27.36,101.33 27.36,100.29 26.6,99.53 24.82,99.53 23.48,98.18 v6(23.48,98.1)
UIM_DET: length 41.9
  TOP w0.119: JSIM1.8 17.71,68.91 17.71,71.84 15.51,74.04 v7(14.75,74.04) 12.29,76.5 v1(9.29,76.5) ; v7(15.16,96.2) 15.16,96.85 DA2.1 15.55,96.93 16.46,96.02 17.49,96.02 18.12,95.39 R53.2 R51.2
  IN1 w0.089: v5(12.95,90.85) 10.98,88.88 10.98,78.19 v1(9.29,76.5)
  GND1 w0.119: v5(12.95,90.85) v4(12.95,91.23)
  IN3 w0.084: v4(12.95,91.23) 12.95,92.94 13.46,93.45 13.46,95.32 13.86,95.72 14.67,95.72 v7(15.16,96.2)
UIM_DET#: length 14.7
  TOP w0.119: R53.1 18.56,95.89 17.92,95.89 17.58,96.24 16.55,96.24 15.75,97.04 v1(15.75,97.24)
  IN1 w0.089: v1(15.75,97.24) 15.75,97.44 14.81,98.38 14.81,99.12 13.77,100.16 13.77,102.27 14.51,103.01 15.45,103.01 16.54,104.1 16.54,105.21 JNGFF1.58
UIM_RESET: length 61.1
  TOP w0.119: v2(25.51,74.16) 25.67,74 D6.1
  IN1 w0.089: v7(17.25,70.89) 18.27,69.87 21.91,69.87 25.51,73.46 v2(25.51,74.16) ; v1(5.41,68.9) 6.12,68.9 6.55,69.32 v3(15.65,69.32)
  IN2 w0.084: v2(25.51,74.16) 24.77,74.9 24.4,74.9 23.92,75.39 23.92,80.31 24.85,81.24 24.85,84.88 25.19,85.22 25.19,87.3 25.61,87.72 25.61,94.18 25.65,94.22 v4(25.65,94.47) ; v7(17.25,70.89) 15.69,69.32 v3(15.65,69.32)
  IN3 w0.084: v6(24.34,98.1) 25.65,96.79 v4(25.65,94.47)
  BOTTOM w0.076: JNGFF1.22 25.55,104.09
  BOTTOM w0.119: v6(24.34,98.1) 25.3,99.07 26.77,99.07 27.84,100.14 27.84,101.79 25.55,104.09
UPD1_I2C_ALERT#: length 391.4
  IN1 w0.06: v1(233.81,125.25) 233.83,125.25 234.42,125.83 234.42,126
  IN1 w0.089: v5(102.72,129.55) 102.81,129.46 102.81,128.78 101.58,127.54 100.05,127.54 98.3,125.79 98.3,123.46 98.18,123.34 98.18,121.78 96.86,120.45 96.86,112.18 96.37,111.7 96.37,106.26 95.59,105.48 95.59,101.9 93.07,99.38 93.07,98.26 91.94,97.13 91.94,94.15 89.06,91.27 76.94,91.27 76.18,90.51 65.98,90.51 62.36,94.13 58.25,94.13 58.14,94.02 53.04,94.02 52.51,93.49 49.8,93.49 49.44,93.14 45.45,93.14 43.63,91.32 43.11,91.32 42.64,90.85 41.43,90.85 38.07,87.49 38.07,84.73 35.2,81.86 35.03,81.68 35.03,76.84 34.04,75.85 34.04,65.05 35.35,63.74 35.35,55.91 37.06,54.2 37.06,38.71 36.3,37.95 36.3,34.12 36.13,33.94 v3(36.13,31.86) ; v5(149.16,120.79) 149.35,120.79 150.65,119.49 160,119.49 161.25,120.74 163.25,120.74 163.91,120.07 164.12,120.07 164.7,119.5 164.7,116.03 166.01,114.72 166.01,114.07 166.7,113.38 167.5,113.38 168.99,111.9 169.72,111.9 170.24,111.38 170.24,110.98 170.59,110.63 170.99,110.63 171.82,109.8 172.81,109.8 173.93,108.69 175.91,108.69 176.14,108.46 176.55,108.46 176.98,108.88 177.76,108.88 178.73,109.85 178.73,111.97 177.15,113.56 177.15,117.16 178.35,118.37 183.55,118.37 184.05,117.86 184.88,117.86 185.31,118.3 185.31,118.78 187.25,120.72 187.25,122.39 188.81,123.94 190.24,123.94 192.02,125.73 193.92,125.73 195.19,127 197.36,127 198.22,127.85 201.24,127.85 201.38,127.99 202.45,127.99 203.33,128.87 204.36,128.87 206.1,130.61 206.66,130.61 211.24,135.19 211.24,135.41 212.57,136.74 221.87,136.74 222.01,136.87 228.21,136.87 228.64,136.44 228.94,136.44 230.31,135.08 230.31,134.58 230.83,134.06 231.97,134.06 232.37,133.66 232.37,133.03 232.78,132.61 v7(232.92,132.61) 233.56,132.61 233.93,132.24 235.82,132.24 236.25,131.81 236.25,131.07 235.79,130.61 235.79,128.75 234.55,127.5 234.55,126.13 234.42,126
  GND1 w0.119: v4(148.72,121.06) 148.74,121.08 148.86,121.08 v5(149.16,120.79) ; v4(103.03,130.01) 102.83,129.8 102.83,129.65 v5(102.72,129.55)
  IN2 w0.084: v2(11.92,54.23) 11.92,51.62 11.24,50.95 11.24,50.66 10.3,49.72 10.3,47.97 10.79,47.47 11.76,47.47 13.72,45.51 13.72,45.25 17.16,41.81 17.16,40.27 16.28,39.4 16.28,37.76 15.76,37.24 15.76,33.25 16.57,32.44 16.57,31.15 18.32,29.39 19.83,29.39 20.51,28.71 23.98,28.71 24.55,29.27 27.19,29.27 28.23,30.31 28.73,30.31 29.52,31.11 29.52,31.74 29.83,32.05 33.59,32.05 34.05,31.58 35.85,31.58 v3(36.13,31.86)
  GND3 w0.119: v4(148.72,121.06) 148.34,120.68 147.89,120.68 147.75,120.82 147.75,121.12 147.01,121.85 145.24,121.85 144.49,121.1 140.69,121.1 139.22,119.63 136.01,119.63 135.63,120.01 127.11,120.01 126.25,119.15 124.9,119.15 123.25,120.81 123.13,120.81 121.47,122.48 121.47,123.91 120.33,125.04 114.41,125.04 111.26,128.19 110.66,128.19 110.2,128.66 105.39,128.66 104.04,130.01 v4(103.03,130.01)
  BOTTOM w0.119: R1083.1 232.57,132.61 v7(232.92,132.61)
UPD1_TD1_PS_SMBCLK: length 393.8
  TOP w0.119: v2(58.85,144.28) 58.85,144.01 58.61,143.78 58.61,143.31 58.1,142.79 Q345.3 ; R1443.1 9.1,47.28 v1(9.12,47.25) ; v2(237.13,124.32) 237.14,124.3 237.52,124.3 R1050.1
  IN1 w0.089: v2(237.13,124.32) 236.98,124.32 236.7,124.04 236.02,124.04 235.73,123.75 v1(235.31,123.75) ; v3(10.8,51.14) 10.73,51.06 10.73,49.54 10.9,49.37 10.9,48.92 10.37,48.38 10.16,48.38 9.12,47.34 v1(9.12,47.25) ; v2(11.42,54.23) 11.68,54.49 11.68,56.42 11.16,56.94 11.16,60.39 10.19,61.36 5.4,61.36 4.83,61.93 4.83,70.84 13.47,79.48 13.47,87.67 15.18,89.38 18.64,89.38 19.32,88.71 22.75,88.71 23.51,87.95 25.63,87.95 27.27,89.59 30.13,89.59 30.56,90.02 30.56,93.04 31.72,94.2 36.53,94.2 38.59,96.26 40.05,96.26 41.68,97.88 44.21,97.88 45.42,99.09 47.85,99.09 49.87,101.1 58.57,101.1 60.17,102.7 60.17,110.31 62.19,112.33 62.19,116.82 65.35,119.99 65.75,119.99 69.38,123.62 70.98,123.62 72.65,125.29 73.12,125.29 v3(73.38,125.55)
  IN2 w0.084: v2(58.85,144.28) 59.38,144.28 59.7,144.61 66.66,144.61 66.85,144.79 v4(67.49,144.79) 67.6,144.68 71.36,144.68 75.28,140.76 75.28,131.44 73.92,130.09 73.92,128.92 74.1,128.74 74.1,126.27 v3(73.38,125.55) ; v2(11.42,54.23) 11.42,51.76 v3(10.8,51.14) ; v2(237.13,124.32) 237.13,124.34 238.64,125.85 240.34,125.85 240.53,126.04 240.53,129.77 239.1,131.2 236.66,131.2 236.34,131.52 236.34,131.92 235.86,132.4 235.43,132.4 234.7,133.13 233.72,133.13 232.02,134.83 232.02,140.19 231.68,140.53 230.65,140.53 228.65,142.53 228.25,142.53 227.99,142.79 225.16,142.79 223.74,144.22 222.52,144.22 222.23,144.51 221.35,144.51 217.13,148.74 211.51,148.74 210.81,148.04 210.81,145.47 209.74,144.41 205.21,144.41 204.31,145.31 201.17,145.31 201.01,145.15 192.33,145.15 189.13,141.95 189.13,139.08 189.46,138.75 189.46,136.82 188.9,136.26 183.76,136.26 183.08,135.58 180.4,135.58 179.71,134.9 173.4,134.9 172.74,135.56 163.47,135.56 163.16,135.25 162.57,135.25 v4(162.15,135.67)
  GND3 w0.119: v4(126.79,134.62) 126.79,134.4 130.51,130.68 140.15,130.68 145.04,135.57 148.9,135.57 149.4,135.07 154.18,135.07 155.61,136.49 158.22,136.49 158.71,136.01 159.33,136.01 159.87,135.47 160.88,135.47 161.27,135.86 161.96,135.86 v4(162.15,135.67)
  IN3 w0.084: v4(126.79,134.62) 126.54,134.62 126.02,135.14 123.65,135.14 121.06,137.73 102.91,137.73 102.12,136.94 96.75,136.94 96.38,136.57 90.47,136.57 89.84,137.2 79.77,137.2 79.33,137.63 70.86,137.63 68.98,139.52 68.98,141.8 67.49,143.29 v4(67.49,144.79)
UPD1_TD1_PS_SMBDAT: length 383.2
  TOP w0.119: R1444.1 8.53,47.33 8.91,46.95 9.51,46.95 v1(9.86,47.3) ; v1(234.26,127.52) 234.88,128.14 R1049.1
  IN1 w0.06: v1(234.31,126.25) 234.31,126.47 234.26,126.53
  IN1 w0.089: v1(9.86,47.3) 9.86,47.81 10.24,48.19 10.45,48.19 11.08,48.82 11.08,49.44 10.95,49.57 10.95,50.75 v3(10.99,50.78) ; v3(235.29,131.45) 235.11,131.28 235.11,129.34 234.98,129.22 234.98,128.24 v1(234.26,127.52) 234.26,126.53 ; v3(73.01,125.56) 72.65,125.56 70.9,123.81 69.14,123.81 68.65,123.31 67.98,123.31 67.65,122.98 67.65,122.15 65.67,120.18 65.26,120.18 62,116.91 62,112.41 59.98,110.39 59.98,102.78 58.81,101.61 50.1,101.61 47.85,99.37 45.43,99.37 44.51,98.45 41.6,98.45 39.79,96.64 38.44,96.64 36.37,94.58 31.56,94.58 30.12,93.14 30.12,92.26 29.01,91.15 27.81,91.15 26.05,89.39 23.81,89.39 23.43,89.76 14.99,89.76 13.09,87.87 13.09,81.33 11.4,79.64 11.4,77.95 4.45,71 4.45,61.77 5.24,60.98 10.03,60.98 10.56,60.45 10.56,59.18 10.97,58.77 10.97,56.17 11.42,55.72 v2(11.42,54.73)
  IN2 w0.084: v3(10.99,50.78) 10.99,50.95 11.66,51.62 11.66,54.49 v2(11.42,54.73) ; v3(235.29,131.45) 235.13,131.45 231.27,135.32 231.27,136.7 231.83,137.27 231.83,140.12 231.61,140.35 230.57,140.35 228.57,142.35 227.96,142.35 227.7,142.61 225.09,142.61 223.67,144.03 222.45,144.03 222.15,144.33 221.28,144.33 217.07,148.53 211.62,148.53 210.99,147.91 210.99,145.4 209.8,144.2 205,144.2 204.07,145.13 201.29,145.13 201.1,144.94 192.42,144.94 189.32,141.83 189.32,139.16 189.65,138.83 189.65,136.75 188.97,136.07 183.83,136.07 183.16,135.4 180.48,135.4 179.77,134.69 173.27,134.69 172.59,135.37 163.55,135.37 163.24,135.06 161.88,135.06 v4(161.45,135.49) ; v3(73.01,125.56) 73.91,126.47 73.91,128.67 73.72,128.86 73.72,130.14 75.09,131.52 75.09,140.68 71.84,143.93 69.22,143.93 68.81,144.35 67.07,144.35 v4(67,144.42) 59.8,144.42 58.91,143.53 57.23,143.53 v2(56.8,143.96)
  GND3 w0.119: v4(161.45,135.49) 161.21,135.25 159.56,135.25 159.29,134.99 156.77,134.99 156.6,134.82 147.75,134.82 146.83,133.9 143.69,133.9 140.25,130.46 130.36,130.46 128.86,131.96 128.86,131.96 128.33,132.48 125.55,135.26 123.6,135.26 122.71,136.15 117.81,136.15 117.59,136.37 v4(115.64,136.37)
  IN3 w0.084: v4(115.64,136.37) 114.47,137.54 102.98,137.54 102.18,136.74 97.35,136.74 96.62,136 95.69,136 95.52,136.17 90.34,136.17 89.7,136.81 79.63,136.81 79.29,137.16 69.5,137.16 67.54,139.11 67.54,139.86 67.16,140.24 67.16,142.97 67.29,143.1 67.29,144.13 v4(67,144.42)
UPD2_I2C_ALERT#: length 292.1
  IN2 w0.084: v2(230.81,122.25) 230.81,122.29 231.1,122.58 231.1,122.83 231.27,123 231.74,123 232,123.26 232,125.57 231.97,125.6 231.97,126.36 232.24,126.63 232.24,127.41 232.09,127.57 v4(232.09,127.8) ; v4(20.67,69.99) 20.78,69.99 23.33,67.44 23.33,58.49 24.22,57.61 25,57.61 25.41,57.2 25.41,54.14 v2(25.25,53.98) ; v4(48.42,80.83) 48.65,81.06 50.9,81.06 51.39,80.57 126.03,80.57 126.92,81.46 127.27,81.46 127.35,81.37 131.59,81.37 132.83,82.62 132.83,83.06 133.6,83.83 140.67,83.83 142.15,85.32 143.47,85.32 144.11,85.96 148.99,85.96 150.58,87.55 160.52,87.55 161.22,86.84 167.86,86.84 168.58,86.12 175.4,86.12 176.22,85.3 189.44,85.3 192.11,87.97 198.19,87.97 199.88,89.66 199.88,97.58 199.48,97.98 199.48,102.16 198.64,103 198.64,104.9 200.42,106.69 202.39,106.69 203.06,107.36 206.58,107.36 207.11,107.88 207.78,107.88 208.05,108.15 v4(208.05,108.43)
  IN3 w0.084: v4(232.09,127.8) 231.92,127.63 231.92,127.02 231.44,126.54 231.21,126.54 228.95,124.29 228.95,122.88 229.23,122.6 229.23,120.04 228.44,119.25 226.76,119.25 v6(226.47,119.54)
  GND4 w0.119: v4(208.05,108.43) 208.05,109.71 v9(208.03,109.7) ; v4(20.67,69.99) 20.77,70.08 v9(21.05,70.08) ; v4(48.42,80.83) 47.86,81.39 v9(47.83,81.39)
  BOTTOM w0.119: v6(226.47,119.54) 226.61,119.68 R1087.1 226.61,120.65 226.01,121.25 219.38,121.25 218.63,120.51 216.54,120.51 211.66,115.62 211.66,112.76 211.34,112.45 210.94,112.45 210.33,113.06 209.87,113.06 207.05,110.24 207.05,109.65 207.28,109.42 207.75,109.42 v9(208.03,109.7) ; v9(21.05,70.08) 29.58,70.08 33.72,74.22 33.72,80.1 38.69,85.07 43.54,85.07 45.32,83.28 45.56,83.28 46.96,81.89 47.34,81.89 v9(47.83,81.39)
UPD2_TD2_EDP_SMBCLK: length 366.4
  TOP w0.119: v1(214.22,117.91) 213.91,118.22 213.54,118.22 213.03,117.71 210.6,117.71 v2(210.1,118.21) ; v7(207.88,128.3) 207.88,128.56 207.47,128.97 206.5,128.97 205.91,129.56 205.91,129.95 205.72,130.15 204.2,130.15 204.05,130 Q349.6
  IN1 w0.089: v1(214.22,117.91) 214.24,117.91 215.6,119.27 222.56,119.27 223.41,118.42 226.36,118.42 226.85,118.92 v1(226.85,119.59) 227.21,119.59 227.67,119.13 227.67,118.81 228.04,118.44 228.73,118.44 229.09,118.8 229.33,118.8 229.98,119.45 229.98,120.3 230.81,121.13 v1(230.81,121.25) ; v1(182.3,101.97) 182.57,102.23 183.03,102.23 183.16,102.1 184.47,102.1 185.07,102.69 187.47,102.69 187.82,103.04 189.15,103.04 190.11,104 190.11,105.12 191.38,106.39 191.38,106.89 192.3,107.82 192.3,110.13 198.87,116.7 198.87,117.11 200.39,118.63 203.56,118.63 204.02,119.1 205.24,119.1 v3(205.47,119.32)
  IN2 w0.084: v3(205.47,119.32) 205.59,119.32 205.82,119.1 209.21,119.1 v2(210.1,118.21) 210.25,118.21 210.45,118.4 210.45,119.59 v4(211.18,120.33) ; v4(20.13,70.5) 20.19,70.45 20.19,69.87 20.43,69.63 20.87,69.63 23.15,67.36 23.15,58.42 24.14,57.42 24.93,57.42 25.23,57.12 25.23,54.45 v2(24.75,53.98) 24.39,54.34 22.64,54.34 22.16,53.86 22.16,52.83 22.72,52.27 22.72,49.7 23.09,49.33 23.09,47.48 v2(22.57,46.95) ; v4(209.12,108.43) 208.1,107.4 207.23,107.4 206.63,106.79 203.33,106.79 202.6,106.06 200.6,106.06 199.32,104.78 199.32,103.14 199.86,102.6 199.86,98.16 200.27,97.76 200.27,89.51 198.34,87.58 192.25,87.58 189.59,84.93 168.79,84.93 168.08,85.64 168.08,85.9 167.54,86.44 161.09,86.44 160.34,87.18 150.73,87.18 149.14,85.59 144.27,85.59 141.92,83.24 133.98,83.24 133.52,82.78 133.52,81.92 131.79,80.2 49.48,80.2 v4(49.13,80.55)
  IN3 w0.084: v6(210.84,120.53) 211.04,120.33 v4(211.18,120.33) 211.26,120.33 211.6,119.99 211.6,117.17 211.23,116.8 209.14,116.8 208.88,116.55 207.77,116.55 206.77,117.55 206.77,118.3 206.9,118.44 206.9,123.07 207.61,123.78 207.61,126.99 207.31,127.29 207.31,127.99 207.88,128.56 v7(207.88,128.3)
  GND4 w0.119: v4(209.12,108.43) 208.98,108.57 v9(208.98,109.49) ; v9(20.52,70.5) v4(20.13,70.5) ; v9(48.83,81.34) 49.13,81.03 v4(49.13,80.55)
  BOTTOM w0.119: v6(210.84,120.53) 210.73,120.53 207.14,116.94 206.53,116.94 205.57,115.98 205.57,113.85 206.66,112.76 206.66,109.62 207.18,109.1 208.59,109.1 v9(208.98,109.49) ; v9(20.52,70.5) 29.66,70.5 33.47,74.32 33.47,80.27 38.51,85.31 43.61,85.31 45.4,83.52 45.63,83.52 47.05,82.11 48.06,82.11 v9(48.83,81.34)
UPD2_TD2_EDP_SMBDAT: length 372
  TOP w0.119: v1(181.31,102.42) 181,102.73 Q346.6 ; v2(209.96,117.84) 210.32,117.48 213.21,117.48 v1(213.66,117.93) ; Q349.3 205.61,127.29 205.9,127.29 206.17,127.03 206.17,126.4 v1(206.03,126.27)
  IN1 w0.06: 230.31,121.12 v1(230.31,121.25)
  IN1 w0.089: v3(205.09,119.37) 205.01,119.29 203.94,119.29 203.48,118.82 200.31,118.82 198.68,117.19 198.68,116.78 192.11,110.21 192.11,107.9 191.19,106.97 191.19,106.47 189.92,105.2 189.92,104.08 189.07,103.23 187.74,103.23 187.39,102.88 184.99,102.88 184.39,102.29 183.24,102.29 183.11,102.42 v1(181.31,102.42) ; v1(206.03,126.27) 205.7,125.93 v3(205.02,125.93) ; 230.31,121.12 230.31,120.95 228.71,119.35 228.71,118.96 228.4,118.65 228.1,118.65 227.88,118.87 227.88,119.18 226.89,120.18 v1(226.85,120.18) 226.7,120.18 226.55,120.02 226.55,118.88 226.28,118.61 223.49,118.61 222.64,119.46 215.52,119.46 214.3,118.25 214.18,118.25 213.86,117.93 v1(213.66,117.93)
  IN2 w0.084: v2(22.55,47.53) 22.87,47.84 22.87,49.31 22.55,49.63 22.55,52.18 21.84,52.89 21.84,54.59 22.2,54.95 24.28,54.95 v2(24.75,54.48) 25.04,54.77 25.04,57.04 24.85,57.23 23.19,57.23 22.77,57.66 22.77,60.23 22.31,60.69 22.31,61.12 22.93,61.74 22.93,67.2 20.77,69.36 20.24,69.36 v4(19.83,69.77) ; v4(211.19,120.85) 211.59,120.45 211.59,118.35 211.01,117.76 210.04,117.76 v2(209.96,117.84) 208.9,118.91 205.4,118.91 205.09,119.22 v3(205.09,119.37) ; v4(47.43,80.83) 48.25,80.01 131.87,80.01 133.7,81.85 133.7,82.7 134.06,83.06 141.99,83.06 144.34,85.41 149.22,85.41 150.81,86.99 160.27,86.99 161.2,86.06 166.79,86.06 168.11,84.74 189.67,84.74 192.32,87.4 198.42,87.4 200.45,89.43 200.45,97.83 200.05,98.24 200.05,102.68 199.51,103.22 199.51,104.7 200.68,105.87 202.67,105.87 203.41,106.61 206.74,106.61 207.33,107.2 208.44,107.2 v4(209.66,108.42) ; v4(204.01,126.07) 204.15,125.93 v3(205.02,125.93)
  IN3 w0.084: v4(204.01,126.07) 203.5,125.57 203.5,119.73 204.07,119.16 204.9,119.16 207.69,116.37 208.96,116.37 209.21,116.62 211.31,116.62 211.78,117.09 211.78,120.65 211.58,120.85 v4(211.19,120.85) 211.19,121.35 v6(211.21,121.37)
  GND4 w0.119: v9(209.38,109.51) 209.38,108.7 209.66,108.42 v4(209.66,108.42) ; v9(47.2,81.44) 47.2,81.06 v4(47.43,80.83) ; v4(19.83,69.77) 19.86,69.74 v9(20.3,69.74)
  BOTTOM w0.119: v9(47.2,81.44) 47.09,81.44 45.49,83.04 45.25,83.04 43.46,84.84 38.78,84.84 33.95,80 33.95,74.12 29.57,69.74 v9(20.3,69.74) ; v9(209.38,109.51) 209.38,109.41 208.85,108.88 207.08,108.88 206.29,109.67 206.29,112.67 205.35,113.61 205.35,116.07 206.46,117.18 207.07,117.18 211.21,121.32 v6(211.21,121.37)
UPD_MRESET: length 272.1
  TOP w0.119: R5741.2 26.88,63.65 v1(26.38,63.65)
  IN1 w0.089: v3(29.3,89.11) 30.28,88.13 30.28,84.23 30.04,83.99 30.04,83.69 30.44,83.28 30.44,80.71 29.6,79.87 29.6,78.27 28.7,77.37 28.7,76.24 27.99,75.53 27.99,73.56 27.74,73.3 27.74,64.16 27.22,63.65 v1(26.38,63.65) 26.18,63.65 26.01,63.82 24.15,63.82 v1(23.94,63.6) ; v10(225.67,122.99) 226.1,123.43 226.68,123.43 226.76,123.34 228.45,123.34 229.17,122.63 230.19,122.63 v1(230.31,122.75)
  GND1 w0.119: v10(225.67,122.99) v4(225.67,122.59)
  IN2 w0.084: v3(29.3,89.11) 29.32,89.13 v4(29.32,89.5)
  IN3 w0.084: v6(155.3,87.15) 163.67,87.15 164.65,88.12 169.57,88.12 170.77,89.33 v6(175.18,89.33) ; v6(133.22,80.64) 132.97,80.64 132.8,80.47 110.58,80.47 107.25,83.8 103.93,83.8 102.71,85.01 100.02,85.01 98.87,86.16 92.78,86.16 92.5,85.89 92.5,85.26 v6(92.05,84.82) ; v6(205.96,114.34) 205.82,114.2 197.44,114.2 196.63,113.39 v6(193.27,113.39) ; v6(225.67,121.61) 225.67,121.62 v4(225.67,122.59) ; v6(29.76,89.5) v4(29.32,89.5)
  BOTTOM w0.119: v6(133.22,80.64) 133.4,80.82 134.36,80.82 137.3,83.76 140.72,83.76 141.49,82.99 142.31,82.99 143.64,84.31 145.74,84.31 148.57,87.15 v6(155.3,87.15) ; v6(175.18,89.33) 180,94.15 182.79,94.15 185.87,97.23 185.87,102.64 189.93,106.69 189.93,108.8 193.05,111.92 193.05,113.17 v6(193.27,113.39) ; v6(29.76,89.5) 30.54,89.5 31.53,90.49 43.13,90.49 46.44,87.18 47.65,87.18 53.04,81.79 61.57,81.79 67.4,87.62 74.65,87.62 77.65,84.62 80.45,84.62 83.49,87.66 87.99,87.66 90.83,84.82 v6(92.05,84.82) ; v6(225.67,121.61) 225.53,121.47 219.28,121.47 218.58,120.76 216.48,120.76 212.38,116.66 209.25,116.66 208.95,116.35 206.42,116.35 205.96,115.89 v6(205.96,114.34)
