# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_WWAN_WAKE#: length 174.8
  IN1 w0.06: v10(132.68,105.76) 132.68,105.99 133.71,107.02 133.71,107.45 133.84,107.58 133.99,107.58 134.12,107.45 134.32,107.45 134.44,107.57 135.09,107.57 135.37,107.29 136.18,107.29 136.32,107.15 136.97,107.15 137.03,107.21 139.06,107.21 139.16,107.32 139.5,107.32 139.76,107.07 139.78,107.07 139.79,107.06 139.97,107.06 139.99,107.07 140.01,107.07
  IN1 w0.089: v3(84.49,132.74) 83.5,131.75 83.5,131.62 83.18,131.29 80.21,131.29 75.32,126.4 72.42,126.4 71.85,125.83 68.41,125.83 65.92,123.34 65.92,122.47 64.57,121.12 64.13,121.12 60.76,117.75 59.16,117.75 58.74,118.17 54.81,118.17 53.12,116.47 53.12,114.14 51.16,112.19 51.16,110.73 48.79,108.35 48.79,106.16 47.29,104.67 47.29,102.78 43.97,99.46 41.24,99.46 39.4,97.62 35.79,97.62 35.63,97.79 34.7,97.79 34.49,97.57 33.51,97.57 v1(33.13,97.19) ; 140.01,107.07 140.38,107.07 141.49,108.19 144.68,108.19 145.98,106.89 146.89,106.89 v5(146.92,106.87)
  GND1 w0.119: v5(146.92,106.87) 147.12,106.87 v4(147.36,107.11)
  IN2 w0.084: v3(84.49,132.74) 84.72,132.74 v4(84.86,132.6)
  GND3 w0.119: v4(149.28,117.1) 148.29,117.1 147.73,117.66 146.89,117.66 146.46,117.23 146.46,116.98 144.93,115.44 141.13,115.44 140.98,115.59 138.75,115.59 138.66,115.68 137.43,115.68 136.92,116.19 134.67,116.19 133.94,115.46 122.36,115.46 117.75,120.08 115.04,120.08 113.95,121.17 113.1,121.17 111.92,122.35 109.09,122.35 108.81,122.63 105.3,122.63 104.98,122.95 102.26,122.95 96.8,128.41 95.48,128.41 94.58,129.31 88.53,129.31 85.25,132.6 v4(84.86,132.6)
  IN3 w0.084: v4(149.28,117.1) 149.28,117.03 149.35,116.96 149.35,113.69 149.05,113.39 149.05,109.69 147.68,108.31 v6(147.68,107.42) v4(147.36,107.11)
  BOTTOM w0.119: v6(147.68,107.42) 148.19,106.92 RH182.1
PCIE_PRX_DTX_N5: length 131
  TOP w0.152: v2(22.94,100.81) 22.87,100.88 22.87,101.5 22.8,101.58 JNGFF1.33
  IN1 w0.06: v1(129.01,98.09) 129.01,97.85 129.21,97.65 129.21,97.42 129.13,97.34 129.13,97.26 128.17,96.3 128.17,95.66 128.06,95.55 128.06,94.71 128.11,94.66
  IN1 w0.089: 128.11,94.66 128.11,93.51 128.48,93.14 128.48,91.8 127.5,90.83 127.25,90.83 126.64,90.22 126.64,89.44 125.15,87.96 122.69,87.96 121.77,87.04 121.77,86.88 121.24,86.34 114.36,86.34 113.3,87.4 112.93,87.4 111.97,86.43 109.91,86.43 108.85,87.49 105.64,87.49 104.8,88.33 103.58,88.33 103.15,88.76 101.87,88.76 98.81,91.82 98.81,93.2 v5(98.72,93.29)
  GND1 w0.089: v5(98.72,93.29) 98.72,93.88 v4(98.59,94.02)
  IN2 w0.084: v4(23.45,99.59) 23.54,99.68 23.54,100.29 23.22,100.6 23.22,101.01 23.1,101.13 22.87,101.13 22.8,101.06 22.8,100.95 v2(22.94,100.81)
  IN3 w0.084: v4(98.59,94.02) 98.73,94.16 98.73,94.63 98.31,95.04 89.72,95.04 86.86,92.18 80.22,92.18 79.75,92.66 75.59,92.66 74.12,94.13 65.14,94.13 61.15,98.12 48.96,98.12 47.47,96.63 43.32,96.63 42.5,97.46 36.72,97.46 36.33,97.06 28.42,97.06 26.99,98.49 25.85,98.49 25.42,98.92 23.68,98.92 23.47,99.13 23.47,99.57 v4(23.45,99.59)
PCIE_PRX_DTX_N7: length 5.2
  TOP w0.152: JNGFF2.43 v2(199.04,94.23)
  IN2 w0.084: v4(196.6,91.45) 196.8,91.26 196.94,91.26 197.79,92.1 197.79,93.41 198.38,94 198.81,94 v2(199.04,94.23)
  GND4 w0.089: v4(196.6,91.45) 196.97,91.45 v9(197,91.47)
PCIE_PRX_DTX_N7_R: length 88.1
  IN1 w0.06: 126.77,93.89 126.77,93.9 126.72,93.95 126.72,95.21 126.55,95.39 126.55,95.85 127.56,96.86 128.02,96.86 128.56,97.4 128.56,97.65 128.36,97.85 v1(128.36,98.09)
  IN1 w0.089: 126.77,93.89 126.77,92.9 v7(126.93,92.74)
  IN3 w0.084: v6(190.35,92.87) 190.25,92.97 190.25,93.12 189.91,93.46 189.07,93.46 188.5,94.04 188.5,94.47 183.47,99.5 182.63,99.5 179.32,102.81 168.49,102.81 166.44,100.75 164.05,100.75 162.47,99.18 161.48,99.18 159.53,97.22 157.6,97.22 156.83,96.45 153.09,96.45 151.37,94.73 148.19,94.73 146.55,93.1 145.06,93.1 143.67,91.7 139.81,91.7 139.63,91.52 132.97,91.52 132.74,91.3 131.91,91.3 131.43,91.77 130.25,91.77 129.7,91.23 127.75,91.23 126.88,92.1 126.88,92.69 v7(126.93,92.74)
  BOTTOM w0.152: v6(190.35,92.87) 190.34,92.86 190.34,92.21 191.38,91.18 196.11,91.18 RH179.2
PCIE_PRX_DTX_N8: length 92.5
  TOP w0.152: JNGFF2.29 v2(199.04,90.73)
  IN1 w0.06: v1(128.68,97.84) 128.69,97.84 128.69,97.35 128.06,96.72 127.87,96.72 127.29,96.14 127.29,94.56 127.35,94.49 127.35,94.47
  IN1 w0.089: 127.35,94.47 127.35,93.89 127.29,93.82 127.29,93.27 127.37,93.18 127.37,92.74 127.64,92.48 127.9,92.48 v5(127.95,92.43)
  GND1 w0.089: v4(128.48,91.87) 128.14,92.2 128.14,92.23 v5(127.95,92.43)
  IN2 w0.084: v4(191.03,93.4) 191.14,93.4 191.32,93.23 191.32,92.41 195,88.73 197.87,88.73 198.66,89.52 198.66,90.74 198.72,90.8 198.96,90.8 v2(199.04,90.73)
  IN3 w0.084: v4(128.48,91.87) 128.66,92.05 129.09,92.05 129.13,92.01 130.92,92.01 131.43,92.52 133.01,92.52 133.05,92.48 139.09,92.48 139.66,93.05 142.5,93.05 142.57,93.11 143.53,93.11 144.62,94.21 146.29,94.21 148.14,96.06 150.06,96.06 151.51,97.51 156.21,97.51 157.02,98.32 159,98.32 160.88,100.2 162.15,100.2 163.66,101.71 164.85,101.71 165.87,102.73 166.94,102.73 168,103.79 180.17,103.79 183.33,100.63 183.91,100.63 190.49,94.05 191.33,94.05 191.48,93.9 191.48,93.73 191.15,93.4 v4(191.03,93.4)
PCIE_PRX_DTX_N9: length 166.4
  IN1 w0.06: v1(127.72,98.09) 127.52,97.89 127.23,97.89 127.08,97.73 127.08,97.31 125.07,95.31 125.07,95.09 125.03,95.04 125.03,95.03
  IN1 w0.089: v5(125.03,92.64) 124.95,92.72 124.76,92.72 124.56,92.92 124.56,93.77 125.03,94.24 125.03,95.03
  GND1 w0.089: v4(246.01,118.89) 246.02,118.87 v10(246.39,118.87) ; v5(125.03,92.64) 125.33,92.64 v4(125.41,92.57)
  IN3 w0.084: v4(246.01,118.89) 246.19,118.7 246.36,118.7 246.48,118.82 246.48,120.09 243.49,123.07 240.7,123.07 238.14,120.52 238.14,118.29 234.41,114.56 218.78,114.56 211.69,107.48 199.02,107.48 197.9,106.36 196.2,106.36 194.91,105.07 194.91,102.79 193.68,101.56 193.68,98.41 193.27,98 193.27,95.03 194.17,94.13 194.17,91.79 193.16,90.78 187.44,90.78 185.31,92.9 185.31,93.54 178.35,100.51 168.6,100.51 165.54,97.44 164.7,97.44 164.13,96.87 162.33,96.87 161.78,96.32 161.78,95.29 161.31,94.82 159.48,94.82 158.96,94.29 154.59,94.29 153.75,93.45 149.07,93.45 145.9,90.28 140.32,90.28 140.25,90.22 139.14,90.22 138.73,89.81 133.87,89.81 133.78,89.72 127.72,89.72 125.8,91.64 125.8,92.68 125.73,92.75 125.59,92.75 v4(125.41,92.57)
PCIE_PRX_DTX_N10: length 128
  TOP w0.152: v2(30.01,85.28) 30.02,85.3 31.45,85.3 31.76,84.98 31.76,84.43 31.69,84.36 31.54,84.36 31.46,84.28 C141.1
  IN1 w0.06: v1(128.04,97.84) 128.04,97.46 127.82,97.24 127.4,97.24 125.77,95.61 125.77,95.09 125.72,95.04 125.72,95.03
  IN1 w0.089: 125.72,95.03 125.72,91.94 123.38,89.6 123.38,89.29 123.19,89.1 122.55,89.1 121.95,88.5 121.38,88.5 120.48,87.6 119.77,87.6 119.67,87.5 116.86,87.5 116.3,88.06 113.98,88.06 113.65,88.39 112.67,88.39 112.13,87.85 110.37,87.85 109.91,88.32 106.38,88.32 105.49,89.2 103.88,89.2 103.63,89.45 103.63,89.99 103.04,90.58 102.71,90.58 99.4,93.89 98.13,93.89 97.87,94.16 97.87,94.49 v5(97.96,94.59)
  GND1 w0.089: v5(97.96,94.59) 97.89,94.51 97.89,94.19 v4(98.06,94.02)
  IN2 w0.084: v4(32.18,94.5) 32.18,94.42 31.84,94.08 31.41,94.08 30.22,92.89 30.22,89.39 29.52,88.69 29.52,85.92 29.72,85.72 29.72,85.54 29.98,85.28 v2(30.01,85.28)
  IN3 w0.084: v4(32.18,94.5) 32.18,94.41 32.52,94.08 35.81,94.08 38.79,97.06 42.33,97.06 43.21,96.18 47.58,96.18 49.13,97.73 60.88,97.73 65.08,93.53 74.1,93.53 75.41,92.22 79.49,92.22 79.91,91.79 87.12,91.79 89.97,94.65 97.5,94.65 97.75,94.4 97.75,94.19 97.93,94.02 v4(98.06,94.02)
PCIE_PRX_DTX_N10_C: length 4.3
  TOP w0.152: C141.2 31.46,82.95 31.53,82.89 31.67,82.89 31.76,82.8 31.76,82.63 31.49,82.36 31.49,82.13 31.76,81.86 31.76,81.7 30.97,80.91 30.37,80.91 30.31,80.97 UR1.8
PCIE_PRX_DTX_P5: length 131
  TOP w0.152: v2(22.34,100.81) 22.42,100.81 22.54,100.94 22.54,101.36 22.3,101.6 JNGFF1.35
  IN1 w0.06: 127.95,94.64 127.95,94.66 127.94,94.66 127.94,95.6 128.05,95.71 128.05,96.35 129.01,97.3 v1(129.01,97.57)
  IN1 w0.089: 127.95,94.64 127.9,94.58 127.9,93.42 128.26,93.05 128.26,91.89 127.41,91.04 127.16,91.04 126.42,90.31 126.42,89.53 125.06,88.17 122.6,88.17 121.56,87.13 121.56,86.97 121.15,86.56 114.45,86.56 113.39,87.61 112.85,87.61 111.88,86.65 110,86.65 108.94,87.71 105.73,87.71 104.89,88.55 103.67,88.55 103.24,88.97 101.96,88.97 99.03,91.91 99.03,93.24 v5(99.08,93.29)
  GND1 w0.089: v4(99.2,94.02) 99.08,93.9 v5(99.08,93.29)
  IN2 w0.084: v4(23.98,99.59) 23.95,99.59 23.7,99.83 23.7,100.35 23.39,100.67 23.39,101.07 23.17,101.29 22.8,101.29 22.64,101.13 22.64,100.92 22.53,100.81 v2(22.34,100.81)
  IN3 w0.084: v4(99.2,94.02) 99.08,94.02 98.89,94.21 98.89,94.7 98.38,95.21 89.65,95.21 86.79,92.35 80.29,92.35 79.81,92.82 75.66,92.82 74.19,94.29 65.21,94.29 61.22,98.28 48.89,98.28 47.4,96.79 43.39,96.79 42.57,97.62 36.66,97.62 36.26,97.22 28.48,97.22 27.06,98.65 25.91,98.65 25.49,99.08 23.75,99.08 23.63,99.2 23.63,99.27 23.95,99.59 v4(23.98,99.59)
PCIE_PRX_DTX_P7: length 5.1
  TOP w0.152: JNGFF2.41 v2(199.04,93.73)
  IN2 w0.084: v4(196.6,90.94) 196.75,91.09 197.01,91.09 197.95,92.03 197.95,93.34 198.45,93.84 198.93,93.84 v2(199.04,93.73)
  GND4 w0.089: v4(196.6,90.94) 196.89,90.94 v9(197,90.84)
PCIE_PRX_DTX_P7_R: length 88.1
  IN1 w0.06: 126.55,93.89 126.55,93.9 126.6,93.95 126.6,95.16 126.43,95.34 126.43,95.9 127.51,96.98 127.97,96.98 128.44,97.45 128.44,97.53 128.4,97.57 v1(128.36,97.57)
  IN1 w0.089: 126.55,93.89 126.55,92.92 v7(126.37,92.74)
  IN3 w0.084: v7(126.37,92.74) 126.72,92.39 126.72,92.03 127.68,91.06 129.77,91.06 130.31,91.61 131.37,91.61 131.84,91.13 132.81,91.13 133.04,91.36 139.69,91.36 139.87,91.54 143.73,91.54 145.13,92.94 146.62,92.94 148.25,94.57 151.44,94.57 153.16,96.29 156.89,96.29 157.67,97.06 159.6,97.06 161.55,99.02 162.54,99.02 164.12,100.59 166.5,100.59 168.56,102.65 179.25,102.65 182.57,99.34 183.4,99.34 188.34,94.4 188.34,93.97 189.01,93.3 189.84,93.3 190.09,93.06 190.09,92.96 v6(190,92.87)
  BOTTOM w0.152: RH180.2 191.24,90.84 190,92.07 190,92.87 v6(190,92.87)
PCIE_PRX_DTX_P8: length 92.4
  TOP w0.152: JNGFF2.31 v2(199.04,91.23)
  IN1 w0.06: 127.5,94.51 127.41,94.61 127.41,96.09 127.92,96.6 128.11,96.6 128.81,97.3 128.81,97.65 128.88,97.73 128.88,97.92 128.68,98.13 v1(128.68,98.34)
  IN1 w0.089: v5(127.95,92.78) 127.86,92.69 127.73,92.69 127.59,92.83 127.59,93.27 127.5,93.36 127.5,94.51
  GND1 w0.089: v4(128.48,92.38) 128.17,92.68 128.05,92.68 v5(127.95,92.78)
  IN2 w0.084: v2(199.04,91.23) 199.04,91.1 198.9,90.96 198.66,90.96 198.5,90.8 198.5,89.59 197.8,88.89 195.07,88.89 191.48,92.48 191.48,93.24 v4(191.65,93.4)
  IN3 w0.084: v4(128.48,92.38) 128.65,92.21 129.16,92.21 129.2,92.17 130.85,92.17 131.36,92.68 133.07,92.68 133.12,92.64 139.02,92.64 139.59,93.21 142.43,93.21 142.5,93.28 143.46,93.28 144.56,94.37 146.22,94.37 148.07,96.22 149.99,96.22 151.44,97.67 156.14,97.67 156.96,98.48 158.93,98.48 160.81,100.36 162.08,100.36 163.59,101.87 164.79,101.87 165.8,102.89 166.87,102.89 167.93,103.96 180.23,103.96 183.39,100.8 183.98,100.8 190.56,94.22 191.4,94.22 191.64,93.97 191.64,93.41 v4(191.65,93.4)
PCIE_PRX_DTX_P9: length 166.4
  IN1 w0.06: v1(127.72,97.57) 127.52,97.77 127.28,97.77 127.2,97.68 127.2,97.26 125.19,95.26 125.19,95.09 125.24,95.04 125.24,95.03
  IN1 w0.089: v5(125.03,93) 124.96,92.93 124.85,92.93 124.77,93.01 124.77,93.68 125.24,94.15 125.24,95.03
  GND1 w0.089: v10(246.39,118.37) 246.39,118.37 246.02,118.37 v4(246.01,118.36) ; v5(125.03,93) 125.33,93 v4(125.41,93.07)
  IN3 w0.084: v4(125.41,93.07) 125.57,92.91 125.8,92.91 125.96,92.75 125.96,91.7 127.78,89.88 133.71,89.88 133.8,89.97 138.66,89.97 139.07,90.38 140.19,90.38 140.25,90.45 145.83,90.45 149,93.62 153.69,93.62 154.52,94.46 158.89,94.46 159.42,94.98 161.24,94.98 161.62,95.35 161.62,96.39 162.26,97.04 164.07,97.04 164.63,97.61 165.47,97.61 168.53,100.67 178.42,100.67 185.48,93.61 185.48,92.97 187.51,90.94 193.1,90.94 194.01,91.86 194.01,94.06 193.11,94.96 193.11,98.07 193.52,98.48 193.52,101.62 194.75,102.85 194.75,105.14 196.13,106.52 197.83,106.52 198.95,107.64 211.63,107.64 218.71,114.73 234.35,114.73 237.98,118.36 237.98,120.58 240.63,123.23 243.56,123.23 246.64,120.15 246.64,118.75 246.42,118.54 246.19,118.54 v4(246.01,118.36)
PCIE_PRX_DTX_P10: length 128.1
  TOP w0.152: C138.1 32.1,85.12 31.59,85.63 30.04,85.63 v2(30.01,85.67)
  IN1 w0.06: v1(128.04,98.34) 128.04,98.13 128.23,97.94 128.23,97.94 128.24,97.93 128.24,97.76 128.16,97.68 128.16,97.41 127.87,97.12 127.45,97.12 125.89,95.56 125.89,95.09 125.94,95.04 125.94,95.03
  IN1 w0.089: 125.94,95.03 125.94,91.85 123.6,89.51 123.6,89.2 123.28,88.89 122.64,88.89 122.04,88.29 121.47,88.29 120.57,87.38 119.86,87.38 119.76,87.28 116.77,87.28 116.21,87.84 113.89,87.84 113.56,88.17 112.76,88.17 112.22,87.64 110.28,87.64 109.82,88.1 106.29,88.1 105.4,88.98 103.79,88.98 103.42,89.36 103.42,89.91 102.95,90.37 102.62,90.37 99.31,93.68 98.04,93.68 97.65,94.07 97.65,94.49 v5(97.56,94.59)
  GND1 w0.089: v5(97.56,94.59) 97.62,94.52 97.62,94.18 v4(97.45,94.02)
  IN2 w0.084: v2(30.01,85.67) 29.68,85.99 29.68,88.62 30.38,89.32 30.38,92.82 31.48,93.92 v4(32.18,93.92)
  IN3 w0.084: v4(97.45,94.02) 97.59,94.15 97.59,94.33 97.43,94.49 90.04,94.49 87.19,91.63 79.84,91.63 79.42,92.06 75.34,92.06 74.03,93.37 65.02,93.37 60.82,97.57 49.19,97.57 47.65,96.02 43.14,96.02 42.26,96.9 38.86,96.9 35.88,93.92 v4(32.18,93.92)
PCIE_PRX_DTX_P10_C: length 4.4
  TOP w0.152: C138.2 32.1,81.56 31.11,80.57 UR1.7
PCIE_PTX_DRX_N5: length 137.1
  TOP w0.152: v2(21.3,101.75) JNGFF1.39
  IN2 w0.084: v4(21.29,100.68) 21.26,100.68 21.11,100.83 21.11,101.56 v2(21.3,101.75) ; v2(132.45,93.95) 132.51,93.95 132.8,93.66 132.8,92.11 132.4,91.72 132.13,91.72 131.33,90.91 130.88,90.91 130.25,90.28 129.48,90.28 127.69,88.49 126.88,88.49 123.74,85.34 108.86,85.34 108.2,84.68 103.34,84.68 101.87,86.15 99.66,86.15 99.18,86.62 97.83,86.62 97.59,86.38 87.13,86.38 86.88,86.13 83.55,86.13 82.99,86.69 75.42,86.69 75.2,86.91 63.85,86.91 61.18,89.58 50.87,89.58 50.53,89.93 50.53,91.2 48.61,93.11 40.82,93.11 40.52,92.8 37.3,92.8 35.57,91.08 34.81,91.08 33.94,90.2 33.6,90.2 33.37,90.43 v4(33.37,90.48)
  IN3 w0.084: v4(33.37,90.48) 33.37,90.43 33.11,90.18 32.05,90.18 30.26,91.97 26.79,91.97 24.05,94.71 18.21,94.71 17.89,95.03 17.89,96.81 21.07,99.98 21.07,100.46 21.29,100.68 v4(21.29,100.68)
PCIE_PTX_DRX_N5_C: length 7.1
  IN2 w0.06: v2(132.45,94.53) 132.4,94.59 132.4,94.74 132.48,94.81 132.87,94.81 132.91,94.85 132.91,95 131.85,96.05 131,96.05 129,98.05 129,98.96 128.97,98.99 128.97,99.04 v2(129.01,99.07)
PCIE_PTX_DRX_N7: length 5.4
  TOP w0.152: JNGFF2.47 v2(199.04,95.23)
  IN2 w0.084: v4(196.62,92.16) 196.79,92.34 197.03,92.34 197.34,92.64 197.34,94.18 198.56,95.4 198.87,95.4 v2(199.04,95.23)
  GND4 w0.089: v9(197,92.11) 196.95,92.16 v4(196.62,92.16)
PCIE_PTX_DRX_N7_C: length 83.3
  IN2 w0.06: v2(128.36,99.07) 128.36,99.07 128.36,98.01 130.83,95.54 131.41,95.54 131.83,95.13 131.83,94.83 131.43,94.42 131.43,94.3 131.4,94.28 131.4,94.27
  IN2 w0.084: v4(131.17,93.64) 131.4,93.87 131.4,94.27
  IN3 w0.084: v6(191.52,95) 191.38,95.15 190.31,95.15 184.06,101.39 183.4,101.39 180.42,104.38 167.75,104.38 166.66,103.28 165.64,103.28 164.64,102.28 163.45,102.28 161.96,100.8 160.66,100.8 158.78,98.92 156.8,98.92 155.96,98.08 151.29,98.08 149.87,96.66 147.95,96.66 146.09,94.79 144.37,94.79 143.26,93.68 142.3,93.68 142.22,93.61 139.43,93.61 138.86,93.04 133.55,93.04 133.15,93.43 132.28,93.43 131.92,93.07 131.65,93.07 131.47,93.26 131.47,93.34 131.34,93.47 131.17,93.63 v4(131.17,93.64)
  BOTTOM w0.152: v6(191.52,95) 191.55,95.03 191.76,95.03 192.34,94.45 192.34,94.14 192.71,93.77 193.85,92.63 194.07,92.41 196.11,92.41 CH23.2
PCIE_PTX_DRX_N8: length 4.5
  TOP w0.152: JNGFF2.35 v2(199.04,92.23)
  IN2 w0.084: v4(197.38,89.64) 197.55,89.82 197.85,89.82 198.05,90.03 198.05,90.98 198.69,91.61 198.69,92.34 198.75,92.4 198.86,92.4 v2(199.04,92.23)
  GND4 w0.089: v9(197,89.57) 197.3,89.57 v4(197.38,89.64)
PCIE_PTX_DRX_N8_C: length 86
  IN2 w0.06: v2(128.68,98.83) 128.64,98.83 128.6,98.8 128.6,98.61 128.65,98.56 128.73,98.56 128.76,98.52 128.76,97.95 130.9,95.81 131.54,95.81 132.14,95.21 132.14,94.71 132.03,94.6 132.03,94.44 132.02,94.42 132.02,94.27
  IN2 w0.084: 132.02,94.27 132.02,93.8 132.04,93.78 132.04,93.42 131.9,93.28 131.9,92.73 132.04,92.59 132.04,92.38 131.84,92.18 v4(131.84,92.15)
  IN3 w0.084: v6(189.13,94.01) 189.22,94.1 189.22,94.33 183.52,100.03 182.68,100.03 179.48,103.23 168.26,103.23 167.19,102.17 166.1,102.17 165.08,101.15 163.89,101.15 162.36,99.63 161.17,99.63 159.24,97.7 157.28,97.7 156.48,96.9 152.98,96.9 152.17,96.09 150.87,96.09 149.93,95.15 148.03,95.15 146.4,93.52 144.9,93.52 143.9,92.51 142.93,92.51 142.91,92.49 139.88,92.49 139.32,91.92 132.95,91.92 132.65,91.62 132.27,91.62 132.04,91.85 132.04,91.95 v4(131.84,92.15)
  BOTTOM w0.152: CH25.2 191.06,89.57 189.14,91.49 189.14,94.01 v6(189.13,94.01)
PCIE_PTX_DRX_N9: length 155.6
  GND1 w0.089: v10(246.39,117.37) 245.99,117.37 v4(245.97,117.39)
  IN2 w0.084: v2(130.54,92.58) 130.82,92.3 130.82,91.45 v4(130.62,91.26)
  IN3 w0.084: v4(245.97,117.39) 246.12,117.24 246.77,117.24 247.24,117.71 247.24,120.4 243.76,123.88 240.44,123.88 237.33,120.77 237.33,118.89 233.8,115.36 218.49,115.36 212.34,109.22 205.01,109.22 204.06,108.26 196.73,108.26 193.76,105.29 193.76,103.16 192.67,102.07 192.67,98.86 192.31,98.51 192.31,94.5 192.69,94.11 192.69,92.97 191.5,91.78 188.25,91.78 186.33,93.7 186.33,95.27 183.61,97.99 182.31,97.99 178.73,101.57 168.86,101.57 165.32,98.04 162.53,98.04 159.98,95.49 157.49,95.49 157.28,95.28 155,95.28 154.66,94.94 154.11,94.94 153.82,94.65 153.14,94.65 152.51,94.01 148.85,94.01 145.79,90.96 140.1,90.96 139.94,90.8 138.91,90.8 138.56,90.44 132.31,90.44 132.12,90.64 131.1,90.64 130.86,90.88 130.86,91.11 130.71,91.26 v4(130.62,91.26)
PCIE_PTX_DRX_N9_C: length 7.9
  IN2 w0.06: v2(127.72,99.07) 127.65,99.07 127.59,99.02 127.59,98.88 127.64,98.83 127.69,98.83 127.72,98.8 127.72,97.95 130.68,94.98 130.68,94.15 130.7,94.14 130.7,93.47 130.86,93.31 130.86,93.08 130.79,93.01 130.69,93.01 v2(130.54,93.16)
PCIE_PTX_DRX_N10: length 124.5
  TOP w0.152: UR1.4 30.32,79.37 30.35,79.34 v2(30.66,79.34)
  IN1 w0.089: v1(131.03,94.34) 131.14,94.46 131.25,94.46 131.31,94.4 131.31,94.11 131.08,93.89 130.56,93.89 130.04,93.37 130.04,92.26 130.94,91.36 130.94,89.92 v3(130.86,89.83)
  IN2 w0.084: v2(30.66,79.34) 30.79,79.22 31.13,79.22 31.44,79.52 31.44,86.61 34.59,89.76 35.82,89.76 37.8,91.74 41.14,91.74 41.55,92.14 48.28,92.14 48.88,91.55 48.88,88.93 49.61,88.2 60.17,88.2 63.61,84.76 70.18,84.76 70.59,85.17 75.34,85.17 75.61,84.9 102.11,84.9 102.98,84.03 108.47,84.03 109.13,84.69 124.96,84.69 129.9,89.63 130.8,89.63 130.86,89.68 v3(130.86,89.83)
PCIE_PTX_DRX_N10_C: length 6
  IN2 w0.06: v2(128.04,98.83) 128.11,98.76 128.11,97.91 130.78,95.24 131.17,95.24 131.34,95.08 131.34,94.86 131.24,94.75 131.13,94.75 131.03,94.85 v2(131.03,94.93)
PCIE_PTX_DRX_P5: length 137.2
  TOP w0.152: v2(20.8,101.76) JNGFF1.41
  IN2 w0.084: v2(133.03,93.96) 132.96,93.9 132.96,92.05 132.47,91.55 132.2,91.55 131.39,90.75 130.95,90.75 130.31,90.12 129.55,90.12 127.76,88.33 126.95,88.33 123.81,85.18 108.93,85.18 108.26,84.52 103.27,84.52 101.8,85.98 99.59,85.98 99.11,86.46 97.9,86.46 97.66,86.22 87.2,86.22 86.95,85.97 83.49,85.97 82.93,86.53 75.36,86.53 75.14,86.75 63.78,86.75 61.12,89.42 50.81,89.42 50.36,89.86 50.36,91.13 48.54,92.95 40.89,92.95 40.58,92.64 37.37,92.64 35.64,90.91 34.88,90.91 34,90.04 33.47,90.04 v4(33.37,89.94) ; v2(20.8,101.76) 20.95,101.62 20.95,100.84 v4(20.78,100.68)
  IN3 w0.084: v4(20.78,100.68) 20.9,100.56 20.9,100.05 17.73,96.87 17.73,94.96 18.14,94.55 23.98,94.55 26.73,91.8 30.19,91.8 31.98,90.01 33.3,90.01 v4(33.37,89.94)
PCIE_PTX_DRX_P5_C: length 7.3
  IN2 w0.06: v2(129.01,99.57) 129.01,99.36 129.21,99.16 129.21,98.99 129.12,98.91 129.12,98.1 131.05,96.17 131.9,96.17 133.03,95.05 v2(133.03,94.55)
PCIE_PTX_DRX_P7: length 5.4
  TOP w0.152: JNGFF2.49 v2(199.04,95.73)
  IN2 w0.084: v4(196.62,92.69) 196.81,92.5 196.97,92.5 197.18,92.71 197.18,94.25 198.49,95.56 198.87,95.56 v2(199.04,95.73)
  GND4 w0.089: v4(196.62,92.69) 196.64,92.67 196.92,92.67 v9(197,92.74)
PCIE_PTX_DRX_P7_C: length 83.3
  IN2 w0.06: 131.57,94.27 131.57,94.28 131.55,94.3 131.55,94.37 131.95,94.78 131.95,95.18 131.46,95.66 130.88,95.66 128.48,98.06 128.48,98.91 128.56,98.99 128.56,99.16 128.36,99.36 v2(128.36,99.57)
  IN2 w0.084: v4(131.68,93.63) 131.57,93.75 131.57,94.27
  IN3 w0.084: v6(191.54,95.37) 191.47,95.31 190.38,95.31 184.13,101.56 183.47,101.56 180.49,104.54 167.68,104.54 166.59,103.45 165.57,103.45 164.57,102.45 163.38,102.45 161.89,100.96 160.6,100.96 158.72,99.08 156.73,99.08 155.9,98.24 151.22,98.24 149.8,96.82 147.88,96.82 146.02,94.95 144.3,94.95 143.19,93.85 142.23,93.85 142.15,93.77 139.36,93.77 138.79,93.2 133.61,93.2 133.22,93.59 132.21,93.59 131.85,93.24 131.72,93.24 131.63,93.33 131.63,93.58 v4(131.68,93.63)
  BOTTOM w0.152: CH24.2 194.21,92.74 194.09,92.87 192.95,94.01 192.68,94.28 192.68,94.59 191.9,95.37 191.54,95.37 v6(191.54,95.37)
PCIE_PTX_DRX_P8: length 4.5
  TOP w0.152: JNGFF2.37 v2(199.04,92.73)
  IN2 w0.084: v2(199.04,92.73) 198.87,92.57 198.68,92.57 198.52,92.4 198.52,91.68 197.89,91.05 197.89,90.09 197.78,89.99 197.54,89.99 v4(197.38,90.15)
  GND4 w0.089: v9(197,90.2) 197.33,90.2 v4(197.38,90.15)
PCIE_PTX_DRX_P8_C: length 85.9
  IN2 w0.06: v2(128.68,99.32) 128.68,99.11 128.83,98.96 128.83,98.96 128.88,98.91 128.88,98 130.95,95.93 131.59,95.93 132.26,95.26 132.26,94.66 132.15,94.55 132.15,94.44 132.18,94.41 132.18,94.27
  IN2 w0.084: v4(132.35,92.17) 132.2,92.32 132.2,92.65 132.06,92.79 132.06,93.21 132.2,93.35 132.2,93.85 132.18,93.86 132.18,94.27
  IN3 w0.084: v6(189.49,94.01) 189.38,94.12 189.38,94.4 183.59,100.2 182.75,100.2 179.55,103.4 168.19,103.4 167.12,102.33 166.03,102.33 165.01,101.31 163.82,101.31 162.3,99.79 161.1,99.79 159.17,97.86 157.21,97.86 156.41,97.06 152.91,97.06 152.1,96.25 150.81,96.25 149.87,95.31 147.96,95.31 146.34,93.68 144.84,93.68 143.83,92.68 142.87,92.68 142.84,92.65 139.82,92.65 139.25,92.08 132.88,92.08 132.58,91.78 132.34,91.78 132.2,91.92 132.2,92.02 v4(132.35,92.17)
  BOTTOM w0.152: CH26.2 196.11,89.91 191.2,89.91 189.48,91.63 189.48,94 v6(189.49,94.01)
PCIE_PTX_DRX_P9: length 155.7
  GND1 w0.089: v10(246.39,116.87) v4(245.99,116.87)
  IN2 w0.084: v4(131.18,91.26) 130.98,91.46 130.98,92.41 v2(131.15,92.58)
  IN3 w0.084: v4(245.99,116.87) 246.2,117.08 246.83,117.08 247.4,117.64 247.4,120.47 243.83,124.05 240.38,124.05 237.17,120.84 237.17,118.96 233.74,115.53 218.42,115.53 212.27,109.38 204.94,109.38 203.99,108.43 196.66,108.43 193.59,105.36 193.59,103.23 192.5,102.13 192.5,98.93 192.15,98.58 192.15,94.43 192.53,94.05 192.53,93.04 191.43,91.94 188.32,91.94 186.49,93.77 186.49,95.33 183.67,98.15 182.38,98.15 178.8,101.74 168.79,101.74 165.26,98.2 162.46,98.2 159.91,95.65 157.42,95.65 157.21,95.44 154.93,95.44 154.59,95.11 154.05,95.11 153.75,94.81 153.08,94.81 152.44,94.18 148.78,94.18 145.72,91.12 140.04,91.12 139.88,90.96 138.85,90.96 138.49,90.61 132.37,90.61 132.18,90.8 131.17,90.8 131.02,90.94 131.02,91.1 v4(131.18,91.26)
PCIE_PTX_DRX_P9_C: length 7.9
  IN2 w0.06: v2(127.72,99.57) 127.72,99.5 127.84,99.38 127.84,99.24 127.92,99.16 127.92,98.99 127.84,98.91 127.84,98 130.8,95.03 130.8,94.2 130.82,94.19 130.82,93.52 130.98,93.36 130.98,93.33 v2(131.15,93.16)
PCIE_PTX_DRX_P10: length 124.4
  TOP w0.152: UR1.3 30.65,78.97 v2(30.66,78.96)
  IN1 w0.089: v1(131.6,94.34) 131.52,94.26 131.52,94.02 131.17,93.67 130.65,93.67 130.26,93.28 130.26,92.35 131.16,91.45 131.16,89.92 v3(131.24,89.83)
  IN2 w0.084: v2(30.66,78.96) 30.76,79.06 31.2,79.06 31.6,79.45 31.6,86.54 34.65,89.59 35.88,89.59 37.87,91.58 41.21,91.58 41.61,91.98 48.22,91.98 48.71,91.48 48.71,88.87 49.54,88.03 60.11,88.03 63.54,84.6 70.25,84.6 70.66,85.01 75.28,85.01 75.54,84.74 102.04,84.74 102.92,83.86 108.54,83.86 109.2,84.53 125.03,84.53 129.97,89.47 130.87,89.47 131.24,89.83 v3(131.24,89.83)
PCIE_PTX_DRX_P10_C: length 6.1
  IN2 w0.06: v2(131.6,94.93) 131.46,95.07 131.46,95.13 131.22,95.37 130.83,95.37 128.24,97.96 128.24,98.74 128.24,98.75 128.24,98.91 128.24,98.91 128.16,98.99 128.16,99.01 128.04,99.13 128.04,99.21 128.04,99.21 v2(128.04,99.32)
PCIE_RBIAS: length 5.5
  IN1 w0.089: v1(25.9,37.29) 25.9,37.87 25.99,37.96 25.99,38.42 25.84,38.58 25.84,39.32 25.76,39.4 25.76,41.12 26.16,41.52 26.16,41.89 v1(25.74,42.31)
PCIE_RCOMPN: length 3.1
  TOP w0.203: UC1.A9 133.51,97.56 133.51,97.25 133.72,97.04 133.72,96.96
  TOP w0.305: RC88.2 133.09,95.51 133.72,96.15 133.72,96.96
PCIE_RCOMPP: length 3.5
  TOP w0.203: 133.25,96.94 133.25,97.13 133.19,97.19 UC1.B10
  TOP w0.305: 133.25,96.94 133.25,96.3 132.91,95.96 132,95.96 131.82,95.78 RC88.1
PCIE_WAKE_I#: length 317.5
  TOP w0.06: 233.05,120.51 233.06,120.51 233.06,121.5 U27.G11
  TOP w0.119: v2(247.76,119.27) 247.76,121.43 247.32,121.87 JNGFF3.47 ; 233.05,120.51 232.76,120.22 232.76,119.99 232.39,119.62 v1(232.39,119.03) ; R107.2 207.88,110.88 v1(207.44,111.32)
  IN1 w0.089: v1(232.39,119.03) 232.39,118.94 231.7,118.25 231.7,118.14 231.16,117.61 230.64,117.61 230.06,117.03 225.78,117.03 224.99,117.81 223.04,117.81 222.31,118.55 v3(221.18,118.55) 221.08,118.65 217.65,118.65 217.34,118.35 217.34,118.06 216.7,117.42 215.74,117.42 215.18,116.86 213.41,116.86 210.38,113.82 v5(210.11,113.82) 210.06,113.78 209.94,113.78 208,111.84 207.95,111.84 v1(207.44,111.32) ; v5(89.26,133.93) 89.04,133.93 88.3,133.19 87.68,133.19 87.24,133.63 86.37,133.63 86.16,133.85 83.07,133.85 82.56,134.36 79.66,134.36 75.06,129.76 74.31,129.76 73.84,129.29 72.25,129.29 71.76,128.79 70.73,128.79 69.75,127.81 66.12,127.81 64.66,126.36 64.66,125.15 62.69,123.18 62.69,122.48 60.93,120.71 59.78,120.71 59.17,120.1 53.88,120.1 51.71,117.93 50.26,117.93 48.82,116.49 48.82,113.98 48.44,113.6 48.44,112.81 46.88,111.24 46.88,108.03 45.09,106.23 44.78,106.23 44.17,105.62 44.17,102.84 42.73,101.4 40.19,101.4 38.82,100.03 35.24,100.03 34.65,100.62 30.43,100.62 29.73,101.32 27.41,101.32 26.89,100.8 25.73,100.8 25.27,100.34 21.9,100.34 21.72,100.52 21.72,101.11 21.85,101.24 21.85,101.91 21.52,102.24 21.52,103.26 21.44,103.34 20.17,103.34 19.55,103.96 JNGFF1.46 ; v5(148.95,119.6) 148.95,119.32 150.01,118.27 153.55,118.27 153.99,118.72 160.3,118.72 161.53,119.94 162.95,119.94 163.32,119.57 163.32,118.98 163.85,118.45 163.85,114.98 164.17,114.66 164.34,114.66 166.42,112.58 166.92,112.58 169.68,109.83 170.28,109.83 171.69,108.42 173.12,108.42 173.64,107.9 175.61,107.9 175.82,107.69 177.65,107.69 178.74,108.78 185.19,108.78 187.12,110.71 187.12,115.07 190.29,118.25 190.29,119.45 191.09,120.25 v5(191.42,120.25)
  GND1 w0.119: v5(210.11,113.82) 209.99,113.95 v4(209.99,114.41) ; v4(89.48,133.57) 89.48,133.71 v5(89.26,133.93) ; v5(191.42,120.25) 191.5,120.25 v4(191.8,119.95) ; v4(148.93,120.1) 148.93,119.92 148.95,119.9 v5(148.95,119.6)
  IN2 w0.084: v3(221.18,118.55) 221.3,118.43 225.98,118.43 227.4,117.01 231.57,117.01 231.79,116.79 232.29,116.79 233.37,115.72 235.55,115.72 236.17,116.34 236.17,117.01 237.41,118.26 239.59,118.26 240.58,119.25 246.23,119.25 246.48,119.01 247.53,119.01 247.76,119.24 v2(247.76,119.27)
  GND3 w0.119: v4(148.93,120.1) 148.57,120.45 146.82,120.45 146.41,120.86 145.67,120.86 141.5,116.7 139.55,116.7 139.43,116.82 137.99,116.82 137.51,117.3 128.54,117.3 127.98,116.74 123.5,116.74 121.16,119.07 121.16,120.35 119.59,121.92 116.54,121.92 115.5,122.96 112.95,122.96 111.72,124.2 102.65,124.2 96.82,130.03 95.47,130.03 93.84,131.66 91.16,131.66 89.48,133.35 v4(89.48,133.57)
  IN3 w0.084: v4(209.99,114.41) 209.88,114.52 206.44,114.52 206.17,114.78 205.13,114.78 204.74,114.39 197.86,114.39 192.31,119.95 v4(191.8,119.95)
PCIE_WAKE_O#: length 427
  TOP w0.119: v1(139.5,113.06) 139.5,112.35 T32.1 ; R1138.1 232.73,117.53 232.73,119.3 233.01,119.58 233.01,119.85 233.04,119.88 v2(233.03,119.88)
  IN1 w0.06: v1(139.5,113.06) 139.81,113.37
  IN1 w0.089: v3(221.68,124.4) 220.83,125.25 218.67,125.25 218.4,124.98 216.84,124.98 216.17,124.31 213.5,124.31 210.67,121.48 208.6,121.48 205.65,118.52 204.29,118.52 203.82,118.06 200.63,118.06 199.44,116.88 199.44,116.44 195.45,112.45 195.45,110.96 194.51,110.02 193.63,110.02 192.9,109.28 192.9,107.53 191.97,106.61 191.97,105.22 191.38,104.62 191.38,104.46 189.1,102.18 188.17,102.18 187.98,101.99 185.18,101.99 184.7,101.5 183.5,101.5 183.23,101.23 181.63,101.23 180.78,102.08 167.47,102.08 167.06,102.5 165.77,102.5 165.36,102.09 163.13,102.09 162.87,101.84 161.69,101.84 161.31,102.22 159.98,102.22 159.85,102.09 158.93,102.09 158.8,101.96 156.54,101.96 156.32,102.19 154.16,102.19 152.3,104.04 152.3,104.96 151.91,105.35 151.91,106.44 151.5,106.84 151.5,107.68 151.25,107.93 150.75,107.93 150.3,108.38 150.3,109 147.3,112 147.3,112.31 146.79,112.82 146.25,112.82 145.66,113.42 144.57,113.42 144.13,113.85 v3(143.59,113.85) 143.32,114.12 142.42,114.12 141.76,113.46 140.53,113.46 140.44,113.37 139.81,113.37 139.81,113.37 ; v1(232.81,121.25) 232.82,121.25 232.85,121.22 232.85,120.06 v2(233.03,119.88)
  GND1 w0.119: v10(28.95,26.88) 28.82,26.75 v4(28.2,26.75)
  IN2 w0.084: v3(221.68,124.4) 221.89,124.19 222.4,124.19 224.76,121.83 226.56,121.83 226.86,122.13 227.67,122.13 228.69,121.12 228.81,121.12 229.1,120.82 229.77,120.82 230.1,120.49 232.36,120.49 232.98,119.88 v2(233.03,119.88) ; v4(75.95,132.36) 75.94,132.35 75.75,132.54 75.75,141.14 71.76,145.12 68.02,145.12 67.77,145.37 66.89,145.37 66.55,145.03 63.41,145.03 62.26,146.17 61.55,146.17 60.46,145.08 59.39,145.08 58.99,144.67 58.3,144.67 56.05,146.92 49.31,146.92 40.77,138.39 40.77,127.97 41.3,127.44 41.3,126.5 40.78,125.98 40.78,124.84 41.3,124.32 41.3,121.56 40.65,120.91 40.65,112.43 36.52,108.29 36.52,106.33 37.37,105.48 37.37,101.79 38.14,101.01 v4(38.14,100.58) ; v4(15.22,90.17) 15.18,90.13 15.18,88.77 14.61,88.2 14.61,79.44 13.12,77.95 13.12,73.14 7.14,67.17 v4(7.14,60.82) ; v3(143.59,113.85) v4(143.11,113.85)
  IN3 w0.084: v4(28.2,26.75) 25.72,26.75 23.31,24.34 22.74,24.34 22.26,23.86 22.26,22.48 22.04,22.26 21.47,22.26 20.78,22.94 17.5,22.94 15.68,24.77 15.68,30.5 14.96,31.22 14.96,37.66 16.15,38.86 16.15,41.38 18.07,43.29 18.07,49.36 16.74,50.69 16.74,55.17 15.34,56.57 15.34,59.75 14.27,60.82 v4(7.14,60.82) ; v4(75.95,132.36) 77.57,133.99 85.58,133.99 86.08,134.48 89.21,134.48 89.97,135.24 95.13,135.24 95.32,135.05 97.51,135.05 98.07,135.61 100.09,135.61 100.57,135.14 100.85,135.14 101.33,135.61 102.69,135.61 103.49,136.42 110.81,136.42 112.98,134.25 114.67,134.25 115.66,133.26 117.46,133.26 118.13,132.58 120.57,132.58 121.54,131.61 122.26,131.61 125.2,128.67 132.71,128.67 133.34,129.29 137.11,129.29 137.96,130.14 139.07,130.14 141.04,128.17 142.11,128.17 142.6,127.67 142.6,126.82 143.07,126.36 143.07,122.75 142.71,122.39 142.71,117.2 143.28,116.63 143.28,114.87 143.11,114.7 v4(143.11,113.85)
  GND4 w0.119: v6(37.87,100.27) 37.87,100.31 v4(38.14,100.58) ; v9(15.58,90.36) 15.41,90.36 v4(15.22,90.17)
  BOTTOM w0.119: v6(37.87,100.27) 35.66,98.05 31.6,98.05 30.06,96.51 24.25,96.51 19.42,91.68 17.1,91.68 15.83,90.41 15.63,90.41 v9(15.58,90.36)
PD_EE_CLK: length 67.9
  TOP w0.119: R5706.2 39.21,38.88 39.37,38.72 39.37,29.77 39.14,29.54 39.14,28.53 v2(38.83,28.22) ; U718.6 15.18,40.48 15.7,41 v2(16.26,41)
  IN2 w0.084: v2(38.83,28.22) 38.84,28.22 38.84,28.22 38.84,28.21 38.33,27.7 34.83,27.7 33.84,28.69 33.84,29.34 32.26,30.92 31.79,30.92 31.37,30.5 30.6,30.5 29.17,29.07 25.21,29.07 24.59,28.45 20.51,28.45 19.75,29.21 18.23,29.21 16.38,31.05 16.38,32.36 15.57,33.18 15.57,37.32 16.1,37.84 16.1,40.33 16.11,40.34 16.11,40.85 v2(16.26,41) 16.26,42.44 13.54,45.17 13.54,45.43 11.68,47.29 10.72,47.29 9.73,48.27 9.73,50.18 10.27,50.72 10.27,50.99 10.62,51.34 10.62,51.9 11.17,52.45 11.17,54.37 11.07,54.48 10.67,54.48 v2(10.42,54.73)
PD_EE_CS#: length 57.6
  TOP w0.119: v2(17.73,47.14) 17.72,47.13 U718.1 ; v10(38.54,38.36) 38.29,38.36 37.82,38.83 R5709.2
  GND1 w0.119: v10(38.54,38.36) v4(38.54,38.82)
  IN2 w0.084: v4(20.12,47.3) 19.89,47.3 18.52,45.93 18.01,45.93 17.76,46.18 17.76,47.1 v2(17.73,47.14) 17.67,47.19 16.6,47.19 15.91,47.89 15.91,48.37 17.28,49.75 17.28,54.35 15.43,56.2 12.1,56.2 11.76,55.86 11.13,55.86 10.16,54.89 10.16,54.49 v2(10.42,54.23)
  IN3 w0.084: v6(29.75,51.09) 29.47,51.37 25.9,51.37 25.51,50.98 25.51,50.15 25.38,50.02 24.52,50.02 22.89,48.4 21.34,48.4 20.65,47.7 20.65,47.42 v6(20.55,47.32) 20.14,47.32 v4(20.12,47.3)
  GND4 w0.119: v4(38.54,38.82) v9(37.92,38.82)
  BOTTOM w0.119: v9(37.92,38.82) 37.07,39.67 37.07,50.77 36.75,51.09 v6(29.75,51.09)
PD_EE_DI: length 52.1
  TOP w0.119: v2(13.27,45.27) 13.42,45.12 13.42,41.23 13.91,40.74 U718.5 ; v2(31.14,30.23) 31.77,29.6 32.02,29.6 R5707.2
  IN2 w0.084: v2(31.14,30.23) 30.64,30.23 29.29,28.89 25.29,28.89 24.66,28.26 20.43,28.26 19.67,29.02 18.15,29.02 16.2,30.98 16.2,32.29 15.38,33.1 15.38,37.39 15.91,37.92 15.91,42.53 13.27,45.18 v2(13.27,45.27) 13.27,45.44 11.6,47.1 10.64,47.1 9.55,48.19 9.55,50.24 9.93,50.62 9.93,52.64 10.92,53.63 v2(10.92,54.23)
PD_EE_DO: length 67.2
  TOP w0.119: v2(16.3,47.06) 16.45,46.91 U718.2 ; v10(32.92,29.22) 32.82,29.33 R5708.2
  GND1 w0.119: v10(32.92,29.22) 32.92,29.47 v4(32.73,29.66)
  IN2 w0.084: v2(10.92,54.73) 12.2,56.01 15.33,56.01 17.08,54.26 17.08,49.8 15.7,48.43 15.7,47.66 v2(16.3,47.06) 17.66,45.7 18.59,45.7 19.64,46.74 v4(20.12,46.74)
  IN3 w0.084: v4(20.12,46.74) 20.13,46.75 v6(20.55,46.75) 20.86,47.06 20.86,47.65 21.36,48.15 22.89,48.15 24.59,49.85 25.45,49.85 25.68,50.08 25.68,50.9 25.92,51.14 29.27,51.14 v6(29.32,51.09)
  GND4 w0.119: v4(32.73,29.66) v9(33.24,29.66)
  BOTTOM w0.119: v6(29.32,51.09) 29.67,51.44 36.7,51.44 37.29,50.86 37.29,40.12 38.24,39.17 38.24,37.07 37.08,35.91 37.08,33.11 33.63,29.66 v9(33.24,29.66)
PD_EE_HOLD#: length 1.8
  TOP w0.119: U718.7 v10(16.45,39.96)
  GND1 w0.119: v10(16.45,39.96) 16.45,40.29 v4(16.52,40.36)
  IN3 w0.084: v6(16.63,40.91) 16.63,40.47 v4(16.52,40.36)
  BOTTOM w0.119: R215.2 16.81,41.1 v6(16.63,40.91)
PD_EE_WP#: length 7.6
  TOP w0.119: U718.3 15.18,47.11 v2(15.17,47.12)
  IN2 w0.084: v4(20.09,46.23) 19.17,45.31 17.61,45.31 15.8,47.12 v2(15.17,47.12)
  IN3 w0.084: v4(20.09,46.23) 20.14,46.19 v6(20.55,46.19)
PD_MRESET_A: length 18.2
  TOP w0.119: v1(16.02,53.26) 15.83,53.26 15.3,52.73 U717.E11 ; R5734.1 v1(23.36,63.02)
  IN1 w0.084: v1(16.02,53.26) 16.28,53.26 16.42,53.4 v3(17.76,53.4)
  IN1 w0.089: v1(23.36,63.02) 23.36,62.59 22.29,61.52 20.93,61.52 20.58,61.17 20.38,61.17 18.5,59.28 v3(18.5,58.84)
  IN2 w0.079: v3(18.5,58.84) 18.9,58.84 19.57,58.17 19.57,57.04 17.76,55.23 v3(17.76,53.4)
PD_MRESET_B: length 14.4
  TOP w0.119: U719.E11 28.24,52.48 28.77,53.01 v1(29.41,53.01) ; R5736.1 v1(26.98,63.06)
  IN1 w0.089: v1(29.41,53.01) 29.74,53.01 30.21,53.47 30.21,57.78 29.78,58.21 29.78,58.96 29.06,59.68 29.06,60.12 26.98,62.2 v1(26.98,63.06)
PDLDO: length 15.9
  TOP w0.254: PU102.1 30.59,66.84 PC133.1 PD108.1 PD107.1 33.44,64.8 PD105.1 PD106.1 34.68,65.95 35.57,66.84 35.57,69.2 35.08,69.68 35.08,72.17 34.78,72.47 PR155.2
PECI_EC: length 1.7
  TOP w0.119: R172.1 237.15,120.82 236.87,120.82 236.45,121.25 U27.A12
PEDET: length 82.2
  TOP w0.119: R1136.1 137.81,93.39 138.09,93.67 v1(138.09,93.98) ; JNGFF2.69 198.25,100.73 v1(198.2,100.77)
  IN1 w0.06: v1(132.87,99.07) 132.87,98.87 132.67,98.67 132.67,98.5 132.79,98.38 132.86,98.38 133.09,98.15 133.12,98.15 134.75,96.52 134.92,96.52 135.87,95.57 136.03,95.57
  IN1 w0.089: v1(198.2,100.77) 198.17,100.74 198.17,98.63 197.82,98.28 197.82,95.17 196.8,94.15 194.13,94.15 191.94,96.34 191.32,96.34 187.14,92.16 183.52,92.16 183.04,92.64 181.59,92.64 178.64,89.7 167.82,89.7 166.4,91.12 165.87,91.12 164.68,92.3 162.94,92.3 162.27,92.97 157.89,92.97 157.78,92.85 154.89,92.85 154.54,93.2 153.88,93.2 153.75,93.33 151.36,93.33 150.91,92.87 146.96,92.87 146.68,93.15 146.11,93.15 146.04,93.08 139.04,93.08 138.92,93.2 138.62,93.2 138.18,93.64 138.18,93.89 v1(138.09,93.98) 137.98,93.98 136.39,95.57 136.03,95.57
PEQ: length 2.4
  TOP w0.102: U23.8 55.43,94.95 v7(55.46,94.98)
  BOTTOM w0.089: R197.2 55.33,95.11 v7(55.46,94.98) 55.58,95.11 R196.2
PET0_N: length 3.1
  TOP w0.076: 28.24,40.61 28.24,40.17 UT1.V22
  TOP w0.119: 28.42,40.81 28.24,40.63 28.24,40.61
  TOP w0.152: C1255.2 28.77,42.63 28.77,41.99 28.42,41.65 28.42,40.81
PET0_P: length 3
  TOP w0.119: 28.09,40.81 28.09,40.78 28.05,40.81 27.98,40.73 27.98,40.44 UT1.V23
  TOP w0.152: C1254.2 28.08,42.75 28.32,42.75 28.43,42.64 28.43,42.13 28.09,41.79 28.09,40.81
PET1_N: length 3.2
  TOP w0.076: 25.95,41.01 25.95,40.2 26.17,39.97 UT1.P22
  TOP w0.152: C1252.2 26.62,42.55 26.62,42.39 26.22,41.99 26.22,41.36 25.95,41.08 25.95,41.01
PET1_P: length 3.3
  TOP w0.076: 26.21,40.87 26.21,40.77 26.41,40.58 26.41,40.25 26.34,40.19 26.24,40.19 26.17,40.26 UT1.P23
  TOP w0.152: C1251.2 26.96,42.59 26.96,42.25 26.56,41.85 26.56,41.22 26.21,40.87
PET2_N: length 3.1
  TOP w0.076: 24.48,41.39 24.48,40.69 24.56,40.61 24.56,40.17 UT1.K22
  TOP w0.152: 24.48,41.39 24.58,41.49 24.58,41.83 24.9,42.15 24.9,42.57 C1257.2
PET2_P: length 3.1
  TOP w0.076: 24.22,41.61 24.22,40.74 24.1,40.62 24.1,40.26 24.18,40.19 24.27,40.19 24.33,40.25 UT1.K23
  TOP w0.152: C1256.2 24.56,42.47 24.56,42.29 24.24,41.97 24.24,41.63 24.22,41.61
PET3_N: length 3.5
  TOP w0.076: 22.15,40.81 22.18,40.78 22.18,40.7 22.26,40.62 22.26,40.22 22.49,39.99 UT1.F22
  TOP w0.081: 22.15,40.82 22.15,40.81
  TOP w0.152: 22.15,40.82 22.15,41.64 22.72,42.21 23.01,42.21 23.14,42.34 23.14,42.56 C1258.2
PET3_P: length 3.6
  TOP w0.076: UT1.F23 22.49,40.26 22.55,40.2 22.63,40.2 22.73,40.3 22.73,40.58 22.49,40.82
  TOP w0.152: C1253.2 23.48,42.5 23.48,42.2 23.15,41.87 22.86,41.87 22.49,41.5 22.49,40.82
PEWAKE#: length 20
  TOP w0.119: v2(207.55,106.92) 207.88,107.25 R1377.1 R107.1
  IN2 w0.084: v2(207.55,106.92) 207.05,106.42 203.49,106.42 202.75,105.68 200.75,105.68 199.69,104.62 199.69,103.3 200.82,102.17 200.82,99.78 201.02,99.58 201.02,98.13 200.82,97.92 200.82,97.24 201.08,96.98 JNGFF2.54
PI0: length 2.7
  TOP w0.089: R198.2 58.92,93.25 U23.60
PI1: length 2.9
  TOP w0.119: U23.1 58.23,94.25 58.65,94.67 58.65,95.75 R199.2 R203.2
PLT_RST#: length 537.7
  TOP w0.14: v1(196.16,108.31) 196.31,108.31 196.78,107.84 196.78,104.85 196.22,104.28 U712.1 ; v7(19.75,100.25) 19.77,100.24 19.77,98.22 v2(19.69,98.14) ; RT1.2 25.28,27.02 25.49,26.81 26.54,26.81 27.2,26.14 28.75,26.14 29.1,26.5 29.97,26.5 30.78,27.31 33.69,27.31 34.37,26.64 35.95,26.64 36.1,26.5 38.34,26.5 v1(38.93,27.09) ; v1(215.89,114.35) 215.89,115.11 214.56,116.44 v2(214.56,121.46) ; U13.1 241.44,126.7 241.69,126.94 243.11,126.94 243.27,127.11 v1(243.27,127.87) ; v1(35.73,74.46) 34.51,74.46 34.13,74.84 30.46,74.84 29.8,75.5 29.8,76.66 v2(29.93,76.78) 29.83,76.88 UR1.1 ; v7(202.85,131.52) 202.7,131.37 U15.17 ; v1(113.01,87.07) 112.55,87.52 RC28.1 ; RH40.1 145.05,108.03 144.51,108.58 144.51,110.02 144.24,110.28 UH1.4 143.64,110.55 143.84,110.75 145.97,110.75 v1(146.12,110.6) 146.41,110.89 RH46.1 146.54,110.92 T24.1 ; v1(125.11,82.63) 125.11,84.35 124.83,84.63 124.83,86.4 v1(125.1,86.67)
  IN1 w0.06: 231.19,126.78 231.31,126.66 v1(231.31,125.75)
  IN1 w0.084: v7(19.75,100.25) 19.75,98.59 20.64,97.7 26.23,97.7 v1(26.47,97.94) ; v1(125.1,86.67) 125.08,86.7 123.58,86.7 123.27,86.39 122.68,86.39 122.06,85.77 114.27,85.77 113.64,86.39 113.39,86.39 113.01,86.77 v1(113.01,87.07) ; v1(146.12,110.6) 146.72,110 146.72,109.89 147.55,109.06 147.97,109.06 148.39,108.63 148.39,107.6 148.9,107.09 148.9,104.99 151.01,102.88 151.18,102.88 152.91,101.15 152.91,101.07 154.29,99.7 158.8,99.7 159.1,99.99 164.18,99.99 164.37,100.18 165.73,100.18 v7(166.1,99.8) 166.45,100.16 168.08,100.16 168.39,100.47 174.82,100.47 174.92,100.37 176.13,100.37 176.23,100.47 179.06,100.47 179.5,100.03 180.56,100.03 181.21,99.38 183.79,99.38 183.98,99.18 185.27,99.18 185.95,99.85 187.35,99.85 187.7,100.2 188.47,100.2 188.84,100.57 189.89,100.57 190.86,101.55 191.62,101.55 192.78,102.72 192.78,102.97 193.06,103.25 193.06,104.03 193.58,104.55 193.58,105.41 194.28,106.11 194.44,106.11 195.61,107.28 195.61,107.8 196.12,108.31 v1(196.16,108.31) 196.16,109.24 199.01,112.1 200.66,112.1 203.29,114.72 205,114.72 205.64,115.36 205.64,116.12 208.13,118.61 208.58,118.61 209.84,119.87 211.34,119.87 212.12,120.65 213.01,120.65 213.56,121.19 214.29,121.19 v2(214.56,121.46) ; 231.19,126.78 230.88,127.08 v8(230.28,127.08) ; v3(246.3,125.75) 246.07,125.75 243.95,127.87 v1(243.27,127.87) ; v1(214.26,111.33) 214.26,111.55 215.89,113.18 v1(215.89,114.35) ; v5(162.49,89.8) 161.81,89.8 161.17,90.43 159.26,90.43 158.68,91.02 154.68,91.02 154.45,91.24 150.63,91.24 150.54,91.33 148.18,91.33 147.91,91.06 142.58,91.06 138.24,86.72 138.24,85.45 134.49,81.69 126.03,81.69 125.43,82.28 125.43,82.31 v1(125.11,82.63) 125.11,82.64 123.47,81 119.56,81 118.94,81.62 118.07,81.62 116.93,82.75 110.33,82.75 110,82.42 110,82.02 108.6,80.62 74.09,80.62 73.58,81.13 51.39,81.13 48.05,84.46 48.05,84.63 47.42,85.26 46.65,85.26 44.74,83.36 39.98,83.36 39.59,83.36 39.56,83.36 36.86,80.66 36.86,75.59 v1(35.73,74.46) 35.73,74.45 35.73,67.11 36.42,66.43 36.81,66.43 37.03,66.21 37.03,57.01 37.58,56.46 38.68,56.46 38.93,56.21 38.93,36.73 38.32,36.12 38.32,35.49 38.59,35.22 38.59,30.95 38.32,30.67 38.32,27.7 v1(38.93,27.09)
  GND1 w0.084: v4(229.95,127.64) 230.28,127.31 v8(230.28,127.08) ; v5(162.49,89.8) v4(162.96,89.8)
  IN2 w0.079: v2(19.69,98.14) 19.3,97.75 19.3,96.64 19.54,96.4 19.54,89.86 v4(19.63,89.77) ; v4(223.63,144.89) 226.12,144.89 226.35,144.66 229.01,144.66 230.96,142.71 233.33,142.71 233.34,142.7 250.14,142.7 251.25,141.59 251.25,138.53 247.42,134.69 247.42,129.94 246.3,128.83 v3(246.3,125.75) ; v4(214.36,121.12) 214.56,121.32 v2(214.56,121.46) ; v7(202.85,131.52) 203.02,131.52 204.52,133.02 204.52,133.42 205.02,133.92 210.42,133.92 211.64,135.14 v4(212.32,135.14) 212.38,135.19 212.38,135.9 213.68,137.21 215.49,137.21 216.64,138.35 219.05,138.35 219.39,138.02 222.82,138.02 223.06,138.26 225.38,138.26 226.02,138.9 v4(226.02,139.15) ; v2(29.93,76.78) 29.48,76.78 v4(29.44,76.82)
  IN3 w0.079: v4(212.32,135.14) 212.32,134.92 212.97,134.28 212.97,133.45 213.65,132.77 213.65,128 213.56,127.91 213.56,126.01 214.15,125.41 214.15,124.75 214.81,124.09 214.81,121.88 214.36,121.42 v4(214.36,121.12) 214.43,121.04 v6(214.81,121.04) ; v4(226.02,139.15) 224.66,140.51 224.66,143.49 223.63,144.52 v4(223.63,144.89) ; v4(29.44,76.82) 29.23,77.03 29.23,83.29 30.54,84.6 30.54,86.32 28.53,88.32 21.08,88.32 v4(19.63,89.77)
  GND4 w0.084: v9(229.62,127.08) 229.62,127.31 v4(229.95,127.64) ; v4(162.96,89.8) v9(163.38,89.8)
  BOTTOM w0.076: JNGFF1.42 20.55,103.99 20.48,103.92
  BOTTOM w0.14: v6(214.81,121.04) 215.32,121.04 216.26,121.97 v13(219.18,121.97) 220.55,123.35 225.82,123.35 226.55,124.08 226.55,125.58 228.05,127.08 v9(229.62,127.08) ; v7(19.75,100.25) 19.75,103.2 20.48,103.92 ; v7(166.1,99.8) 166.1,98.99 165.46,98.36 165.46,90.61 164.65,89.8 v9(163.38,89.8)
PM_SYS_RESET#: length 220.9
  TOP w0.119: RH52.1 140.14,96.81 v1(140.32,96.81) ; v7(103.04,89.75) 103.04,90.43 103.36,90.75 116.84,90.75 117.13,90.46 117.13,90.1 117.33,89.9 117.74,89.9 118.04,89.59 118.04,89.19 RC36.1 ; JAPS2.13 v2(218.77,144.45)
  IN1 w0.089: v7(223.51,119.72) 215.46,119.72 214.18,118.44 214.1,118.44 213.91,118.24 213.06,118.24 211.36,116.54 210.33,116.54 210.06,116.28 210.06,115.54 208.63,114.11 208.41,114.11 207.86,113.56 207.86,113.34 203.83,109.32 201.95,109.32 200.96,108.33 200.22,108.33 199.83,107.94 199.83,107.48 196.53,104.17 196.53,103.42 195.94,102.83 195.94,101.81 196.91,100.84 196.91,99.08 196.37,98.54 194.13,98.54 192.92,97.33 190.96,97.33 187,93.37 184.12,93.37 183.26,94.23 180.03,94.23 179.87,94.07 179.87,93.55 178.12,91.8 168.14,91.8 165.4,94.53 162.13,94.53 161.72,94.95 159.88,94.95 159.67,95.15 156.49,95.15 156.22,95.42 155.74,95.42 155,96.16 152.55,96.16 152.19,95.8 150.98,95.8 v5(150.96,95.78) 150.65,95.47 149.93,95.47 149.55,95.09 144.47,95.09 144.4,95.17 143.72,95.17 143.42,95.47 142.41,95.47 141.31,96.57 140.72,96.57 140.48,96.81 v1(140.32,96.81)
  GND1 w0.119: v5(150.96,95.78) 151.19,95.55 v4(151.19,95.25)
  IN2 w0.084: v2(218.77,144.45) 219.15,144.45 v4(219.31,144.61)
  IN3 w0.084: v4(219.31,144.61) 220.3,145.6 222.59,145.6 222.82,145.37 223.68,145.37 225.44,143.61 225.44,142.18 225.83,141.8 225.83,140.89 227.27,139.45 227.27,139.02 230.31,135.98 230.31,132.71 230.52,132.49 230.52,130.96 229.94,130.37 229.94,129.46 230.51,128.89 230.51,126.93 227.87,124.29 227.87,121.45 226.42,120 223.79,120 v7(223.51,119.72)
  GND4 w0.119: v4(151.19,95.25) 150.93,95.25 v9(150.74,95.05)
  BOTTOM w0.119: v9(150.74,95.05) 150.74,94.62 148.08,91.96 148.08,91.73 143.39,87.04 139.12,87.04 138.09,86.01 136.32,86.01 134.06,83.75 130.22,83.75 129.48,83.02 128.15,83.02 127.75,82.62 123.74,82.62 123.05,81.93 116.51,81.93 115.59,82.84 106.98,82.84 105.62,84.21 105.62,85.02 103.92,86.72 103.92,88.67 103.04,89.54 v7(103.04,89.75)
PMIC_INT#: length 88
  TOP w0.06: U27.L3 230.56,126 230.56,127.03 230.55,127.03
  TOP w0.119: v2(230.13,129.68) 229.86,129.68 229.44,129.26 229.44,128.61 229.66,128.39 R167.1 230.1,128.14 230.1,127.54 230.55,127.09 230.55,127.03
  IN1 w0.06: 171.81,125.84 171.35,125.84 170.51,125 169.39,125 v1(169.19,125.2)
  IN1 w0.089: 171.81,125.84 172.93,125.84 v3(173.11,126.02)
  IN2 w0.084: v2(230.13,129.68) 229.12,130.68 229.12,134.04 228.24,134.92 228.24,138.23 226.21,140.27 223.26,140.27 222.56,139.56 216.51,139.56 216.35,139.72 214.37,139.72 213.39,138.74 207.07,138.74 206.52,139.29 205.36,139.29 201.55,135.47 197.73,135.47 196.71,134.46 196.71,132.95 195.71,131.95 195.03,131.95 194.1,131.03 193.71,131.03 193.26,130.58 193.26,129.75 192.75,129.24 192.29,129.24 191.72,128.67 191.72,126.26 189.18,123.73 185.84,123.73 185.06,122.94 183.27,122.94 182.46,122.14 178.36,122.14 178.06,122.44 178.06,123.74 175.95,125.85 173.44,125.85 173.27,126.02 v3(173.11,126.02)
PROXIMITY_OUT#: length 220.5
  TOP w0.119: U21.13 67.68,146.72 67.5,146.9 67.5,147.05 66.85,147.7 C1392.1 v2(66.71,148.28)
  IN1 w0.089: v1(234.31,125.25) 234.54,125.48 235.93,125.48 236.07,125.62 236.07,125.87 236.2,125.99 236.2,127.11 237.45,128.36 237.45,130.35 237.22,130.59 237.22,131.16 236.75,131.63 v3(236.63,131.63)
  IN2 w0.084: v4(67.3,148.13) 67.15,148.28 v2(66.71,148.28) ; v4(162.78,135.66) 163.28,135.66 163.37,135.74 172.82,135.74 173.46,135.1 179.65,135.1 180.32,135.77 182.99,135.77 183.67,136.45 188.82,136.45 189.27,136.9 189.27,138.68 188.94,139.01 188.94,142.05 192.25,145.36 200.85,145.36 201,145.5 204.39,145.5 205.27,144.61 209.68,144.61 210.62,145.55 210.62,148.12 211.45,148.94 217.19,148.94 221.43,144.7 222.31,144.7 222.6,144.41 224.53,144.41 225.96,142.98 228.07,142.98 228.33,142.72 228.73,142.72 230.73,140.72 231.76,140.72 232.21,140.27 232.21,134.9 233.75,133.36 234.73,133.36 235.5,132.59 235.94,132.59 236.63,131.89 v3(236.63,131.63)
  GND3 w0.119: v4(126.73,135.21) 127.02,135.21 127.3,134.93 127.3,134.2 130.6,130.9 140.06,130.9 144.99,135.82 149.33,135.82 149.85,136.34 150.4,136.34 151.44,135.3 154.1,135.3 155.51,136.71 158.31,136.71 158.8,136.23 159.42,136.23 159.96,135.69 160.76,135.69 161.16,136.09 162.35,136.09 v4(162.78,135.66)
  IN3 w0.084: v6(95.92,137.11) 95.93,137.13 102.04,137.13 102.83,137.91 121.17,137.91 123.69,135.39 126.55,135.39 v4(126.73,135.21) ; v4(67.3,148.13) 67.3,148.25 68.08,149.03 v6(68.21,149.03)
  BOTTOM w0.119: v6(95.92,137.11) 93.79,137.11 93.32,137.58 79.7,137.58 78.77,138.51 78.77,140.91 78.19,141.5 77.5,141.5 75.02,143.98 75.02,148.03 74.21,148.85 68.39,148.85 v6(68.21,149.03)
PS_SMBCLK: length 15.5
  TOP w0.119: Q345.4 58.1,144.52 58.2,144.62 58.2,145.7 58.02,145.88 v2(58.02,146.31) ; U21.14 66.95,146.32 C1393.1 v2(66.72,147.12)
  IN2 w0.084: v2(58.02,146.31) 58.41,145.92 59.32,145.92 60.14,146.74 62.49,146.74 63.61,145.61 66.29,145.61 66.48,145.8 66.48,146.5 66.72,146.74 v2(66.72,147.12)
PS_SMBDAT: length 17.9
  TOP w0.119: v2(66.77,145.97) R85.2 C1394.1 67.13,145.37 67.67,145.92 U21.15 ; v2(58.67,145.13) 58.82,144.98 58.82,144.72 59.14,144.4 59.14,143.94 58.83,143.63 58.83,143.21 58.59,142.97 58.59,141.89 58.16,141.46 57.04,141.46 56.8,141.7 Q345.1
  IN2 w0.084: v2(66.77,145.97) 66.77,145.83 66.37,145.43 63.54,145.43 62.41,146.55 60.21,146.55 58.79,145.13 v2(58.67,145.13)
PWR1_ON: length 18.5
  TOP w0.254: PC128.1 48.22,128.02 PR111.1 48.27,128.07 v1(49.16,128.07)
  IN1 w0.254: v1(50.89,143.34) 50.89,141.97 49.21,140.28 49.21,137.19 48.22,136.2 48.22,134.15 48.51,133.85 48.51,131.52 48.75,131.28 48.75,128.48 v1(49.16,128.07)
PWR2_ON: length 20.3
  TOP w0.254: PC127.1 49.14,124.56 PR105.1 49.14,125.44 v1(49.14,126.33)
  IN1 w0.254: v1(49.74,143.34) 49.13,142.72 49.13,141.69 48.85,141.41 48.85,139.2 48.19,138.53 48.19,136.84 47.83,136.48 47.83,134.02 48.15,133.71 48.15,130.75 47.89,130.49 47.89,128.53 48.7,127.72 48.7,126.77 v1(49.14,126.33)
PWR_BTN_DOCK1#: length 29.5
  TOP w0.119: v2(18.01,50.78) 18.48,50.78 R1434.2 ; QT19.1 6.36,56.71 6.99,57.33 9.11,57.33 9.26,57.49 v2(9.26,57.55)
  IN2 w0.084: v2(9.26,57.55) 9.26,59.36 10.52,60.61 20.07,60.61 21.69,59 v2(21.69,58.5) 18.24,55.06 18.24,51.01 v2(18.01,50.78)
PWR_BTN_DOCK2#: length 40.2
  TOP w0.119: v2(18.78,59.14) 19.02,58.9 R1461.2 ; R1439.2 30.47,51.98 v1(30.89,51.98) ; v2(9.61,55.65) 8.23,55.65 8.1,55.78 7.29,55.78 QT19.4
  IN1 w0.089: v1(30.89,51.98) 30.75,52.12 30.75,53.55 30.49,53.82 30.49,59.1 27.25,62.35 27.25,63.17 27.09,63.33 26.62,63.33 25.61,62.32 25.61,61.05 25.48,60.92 20.45,60.92 18.78,59.24 v2(18.78,59.14)
  IN2 w0.084: v2(9.61,55.65) 10.29,56.33 10.29,58.83 11.1,59.64 18.28,59.64 v2(18.78,59.14)
PWR_LED#: length 30.4
  TOP w0.119: Q342.2 216.95,138.46 R22.2 217.21,138.2 217.21,137.71 218.91,136.02 224.22,136.02 225.6,134.64 231,134.64 v2(231.08,134.56)
  IN1 w0.089: v3(236.95,130.36) 237.22,130.09 237.22,128.4 235.97,127.15 235.97,126.87 235.57,126.46 235.57,125.93 235.38,125.75 v1(235.31,125.75)
  IN2 w0.084: v3(236.95,130.36) 235.64,130.36 234.55,131.45 234.55,131.77 232.3,134.03 231.27,134.03 231.08,134.21 v2(231.08,134.56)
PWR_LED#_R: length 36.2
  TOP w0.119: v10(219.94,141.36) 220.5,141.36 220.81,141.66 224.48,141.66 225.43,142.62 v14(225.49,142.62) 227.04,142.62 228.12,141.54 241.97,141.54 242.35,141.92 248.22,141.92 248.29,141.85 248.32,141.85 248.51,141.66 249.29,141.66 249.47,141.49 C1428.1 250.02,141.12 250.25,141.35 JPB1.6 ; R1107.2 219.31,139.23 220.02,139.94 v10(220.02,139.96)
  GND1 w0.119: v10(220.02,139.96) 219.89,140.09 219.89,141.31 v10(219.94,141.36)
