# Allegro board LAC321PR10-0907B.brd (continued)
## Nets (continued)
Pads without a net: D6 4; FD1 1; FD2 1; FD3 1; FD4 1; H1 1; JAPS2 16 17 18; JCR1 14; JLVDS1 6 11 15 34 50; JNGFF1 10 12 14 16 20 30 48 50; JNGFF2 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JNGFF3 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 24 26 28 50 51 52 53 54 56 57 58 59 60 62 63 65; JP1 19; JSER 3 4 8 9 11 12 13 14 15 16; JSIM1 5; JSPI1 1 2 17; JVOL1 5; MD4 2 8; PD101 3; PU102 3; PU200 3; PU202 3; PU207 1 2 3; PU400 4 13 14; PU500 G4 H4 J4 K4; PU800 A7 B6 B7 D6 G2; Q86 3 4 5; U3 A1 A17 C11 D8 D11 E3 E4 H4 J12 M9 U1 U17; U4 A1 A17 C11 D8 D11 E3 E4 H4 J12 M9 U1 U17; U15 2 4 5 6 7 10 11 12 15 25 26 28 30 31; U16 C2 C3 D3 D4 E1 E2 E3 E5 E6 F1 F2 F3 G1 G2 G3 H1 H3; U18 9; U21 2 3 4 7 8 9 10; U23 4 14 22 23 58; U24 1 3 5; U713 3 6 7; U717 A9 B9; U719 A9 B9; UA1 8 47 48 49 50; UA2 1 27 29 31 32 33 34 35 36 37 48; UC1 A30 A32 A38 AB7 AE12 AF11 AH7 AL10 AM3 AM5 AM9 AN8 AP5 AT7 AU6 AW6 AY18 AY22 B23 B29 B31 B33 B37 B39 BA17 BA19 BA21 BA23 BB18 BB63 BC3 BC19 BD4 BD6 BD8 BD18 BD30 BD34 BE19 BF18 BG47 BG57 BJ1 BJ3 BJ6 BJ15 BJ17 BJ31 BK14 BK34 BL12 BL17 BL57 BM56 BN47 BP11 C30 C32 C38 D23 D29 D31 D33 D37 D39 F23 H23 L8 L20 L22 L24 L38 M25 P11 U4 U6; UR1 31; UT1 A23 AB23 AC23 B23 E18 J1 J2 L1 L2 N1 N2 R1 R2 V18 W19 Y19

## Via types
v1: diameter 0.254, hole 0.102, TOP to IN1, 1596 vias
v2: diameter 0.254, hole 0.102, TOP to IN2, 1244 vias
v3: diameter 0.254, hole 0.102, IN1 to IN2, 322 vias
v4: diameter 0.406, hole 0.203, GND1 to GND4, 1713 vias
v5: diameter 0.254, hole 0.102, IN1 to GND1, 336 vias
v6: diameter 0.254, hole 0.102, IN3 to BOTTOM, 493 vias
v7: diameter 0.457, hole 0.203, TOP to BOTTOM, 1997 vias
v8: diameter 0.22, hole 0.102, IN1 to GND1, 56 vias
v9: diameter 0.254, hole 0.102, GND4 to BOTTOM, 781 vias
v10: diameter 0.254, hole 0.102, TOP to GND1, 3352 vias
v11: diameter 0.508, hole 0.254, TOP to BOTTOM, 16 vias
v12: diameter 0.254, hole 0.102, GND1 to IN2, 583 vias
v13: diameter 0.305, hole 0.152, TOP to BOTTOM, 33 vias
v14: diameter 0.406, hole 0.203, TOP to BOTTOM, 96 vias
v15: diameter 0.305, hole 0.102, GND4 to BOTTOM, 24 vias
v16: diameter 0.254, hole 0.102, GND4 to VCC, 97 vias
v17: diameter 0.254, hole 0.102, VCC to BOTTOM, 104 vias
v18: diameter 0.22, hole 0.102, IN1 to IN2, 78 vias
v19: diameter 0.305, hole 0.102, TOP to GND1, 1 via
v20: diameter 0.22, hole 0.102, IN3 to GND4, 145 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3.3V_NGFF1_EN: length 272
  TOP w0.119: v10(43.71,84.77) 42.72,84.77 42.56,84.92 41.34,84.92 40.84,85.43 40.84,86.76 39.88,87.71 37.83,87.71 37.08,88.46 37.08,92.68 37.75,93.36 D11.3
  IN1 w0.089: v5(99.35,118.8) 98.71,118.17 98.71,111.06 98.24,110.59 98.24,105.55 97.42,104.72 97.42,100.08 95.08,97.75 95.08,96.53 94.7,96.14 94.7,92.47 95.3,91.87 95.3,87.96 v7(92.89,85.56) ; v1(232.81,125.25) 232.81,125.1 232.61,124.9 232.29,124.9 232.06,125.13 232.06,125.84 231.91,125.99 231.66,125.99 231.55,125.88 231.55,125.64 231.4,125.48 229.73,125.48 229.25,125.96 228.83,125.96 228.5,126.3 227.74,126.3 227.41,126.63 227.41,128.41 227.86,128.85 227.86,130.13 227.2,130.79 227.2,133.18 226.17,134.2 223.95,134.2 221.99,132.24 215.44,132.24 208.29,125.1 207,125.1 206.32,124.42 204.99,124.42 204.26,123.69 203.81,123.69 203.47,123.35 203.47,122.88 203.27,122.68 202.63,122.68 201.88,121.93 200.59,121.93 200.26,121.6 197.79,121.6 195.7,119.5 195.7,116.51 190.18,110.99 190.18,109.59 188.8,108.21 188.8,106.79 188.31,106.29 187.84,106.29 186.34,104.79 178.93,104.79 178.74,104.59 169.72,104.59 168.93,105.38 168.93,106.03 168.43,106.53 167.14,106.53 166.12,107.55 163.44,107.55 163.16,107.83 163.16,109.89 162.34,110.72 153.3,110.72 150.29,113.72 v5(149.1,113.72)
  GND1 w0.119: v4(148.72,113.72) v5(149.1,113.72) ; v5(99.35,118.8) 99.35,119.26 v4(99.37,119.29) ; v10(43.71,84.77) 44.25,84.77 v4(44.3,84.72)
  GND3 w0.119: v4(148.72,113.72) 148.72,113.01 146.77,111.06 143.19,111.06 142.9,111.35 141.36,111.35 141.25,111.46 132.24,111.46 131.71,112 116.99,112 111.85,117.13 101.53,117.13 v4(99.37,119.29)
  IN3 w0.084: v4(44.3,84.72) 44.91,84.11 54.77,84.11 54.95,84.28 57.98,84.28 58.16,84.11 60.63,84.11 62.23,82.5 90.14,82.5 92.89,85.25 v7(92.89,85.56)
+0.85V_PRIM: length 0.9
  TOP w0.508: RC162.1 151.81,100.5 151.64,100.34 v7(151.64,100.13)
  vias: v7(164.09,110.67) v7(164.24,110.13)
+1.0V_APLL: length 27.6
  TOP w0.381: CC163.1 145.42,95.3 CC21.1 ; v1(130.96,103.24) v2(130.47,103.24)
  TOP w0.457: CC22.1 143.82,95.3 143.43,94.9 143.11,94.9 v7(143.11,94.9)
  TOP w0.508: CC22.1 CC21.1 145.06,95.21 RC199.2
  IN3 w0.508: v6(133.64,99.83) 133.43,100.03 133.43,101.51 131.67,103.26 v4(131.05,103.26)
  BOTTOM w0.508: v7(143.11,94.9) 143.11,94.9 143.1,94.9 141.52,93.32 138.96,93.32 137.71,92.07 134.92,92.07 133.64,93.35 v6(133.64,99.83)
  vias: v3(130.7,103.36)
+1.0V_MPHYGT: length 10.6
  TOP w0.381: v1(129.48,107.71) v10(129.48,107.15) v1(129.48,106.59) v10(129.48,106.04) ; v2(129.97,103.24) v1(129.48,103.24)
  IN1 w0.254: v1(129.48,103.24) 129.66,103.24 129.67,103.23 129.96,103.23 v2(129.97,103.24) ; v1(131.95,101.57) v10(131.46,101.57)
  IN1 w0.381: v1(129.48,107.71) v10(129.48,107.15) v1(129.48,106.59) v10(129.48,106.04)
  GND1 w0.254: v4(135.59,102.01) 135.6,102 v10(136.01,102) ; v10(131.46,101.57) 131.82,101.57 v4(131.96,101.71)
  GND2 w0.457: v4(129.48,106.53) v4(129.54,107.52)
  GND4 w0.254: v16(129.86,103.29) 129.43,103.29 v4(129.38,103.34) 129.4,103.36 129.4,103.42 129.77,103.79 v9(129.8,103.79) ; v9(135.67,102.42) 135.67,102.09 v4(135.59,102.01) ; v16(129.48,106.13) v4(129.48,106.53)
  GND4 w0.381: v4(131.96,101.71) 132.02,101.76 133.41,101.76 v16(133.64,101.53)
  vias: v7(140.71,94.7) v7(141.28,94.7) v7(141.84,94.7) v12(129.72,103.23) v17(134.37,100.54)
+1.0V_MPHYPLL: length 2.8
  TOP w0.229: UC1.V15 v1(131.46,102.12)
  IN1 w0.254: v1(131.95,101.01) v10(131.46,101.01)
  GND1 w0.254: v10(131.46,101.01) 131.81,101.15 131.81,101.14 v4(131.8,101.13)
  GND4 w0.254: v4(131.35,102.02) 131.4,102.07 v9(131.73,102.07) ; v9(131.88,100.69) 131.88,101.05 v4(131.8,101.13) 131.84,101.18 132.33,101.18 v16(132.34,101.17)
  vias: v7(140.06,92.08) v7(141.08,92.08) v8(131.69,102.15) v10(131.95,102.12)
+1.0V_PRIM: length 97.8
  TOP w0.381: v7(104.53,89.67) 110.8,89.67 111.54,88.93 114.14,88.93 114.17,88.96 116.15,88.96 RC154.1
  TOP w0.508: v10(146.35,92.87) 146.26,92.96 RC199.1
  GND1 w0.254: v4(101.07,95.23) 100.88,95.04 v10(100.5,95.04)
  GND1 w0.508: v10(146.35,92.87) 146.21,92.73 146.21,92.29 146.18,92.26 v4(146.17,92.26)
  IN3 w0.508: v6(154.54,99.5) 154.18,99.14 151.67,99.14 v6(151.34,99.47)
  GND4 w0.254: v9(101.19,95.79) 101.19,95.35 v4(101.07,95.23)
  GND4 w0.508: v4(156.43,93.09) 155.86,93.09 155.82,93.12 v16(155.81,93.12) ; v4(146.17,92.26) 146.17,92.14 v9(145.91,91.88)
  BOTTOM w0.508: v9(101.19,95.79) 101.19,96.54 102.2,97.56 106.42,97.56 106.7,97.28 106.7,96.77 103.51,93.58 103.51,90.69 v7(104.53,89.67) 104.53,86.7 106.04,85.19 106.04,84.38 107.08,83.34 115.69,83.34 116.68,82.35 122.88,82.35 123.56,83.03 125.28,83.03 127.87,85.62 133.45,85.62 135.5,87.68 137.45,87.68 138.45,88.68 139.59,88.68 140.02,89.11 143.14,89.11 v9(145.91,91.88) 146.28,92.25 146.28,92.7 148.78,95.19 v14(148.78,96.05) 148.78,98.17 149.03,98.42 150.87,98.42 151.34,98.89 v6(151.34,99.47)
  vias: v7(153.84,103.07) v7(154.26,102.67) v7(154.67,103.08) v7(154.88,102.56) v7(155.23,103.08) v7(155.49,102.56) v7(155.82,103.02) v7(156.17,102.57) v7(156.43,103.08) v7(158.02,96.68) v10(156.01,93.13) v10(156.83,93.14)
+1.0V_VCCSFR: length 8.1
  TOP w0.229: v10(127.99,101.57) v1(127.99,101.01)
  TOP w0.381: v10(128.77,96.21) 129.04,96.21 129.71,95.54 RC106.2
  GND1 w0.254: v10(128.77,96.21) 128.76,96.21 128.56,96.01 v4(128.56,95.93)
  GND4 w0.254: v4(128.56,95.93) 128.56,96.05 v9(128.87,96.36) ; v9(129.14,101.07) 129.14,101.3 v4(128.94,101.51)
  BOTTOM w0.508: 129.44,100.45 129.44,100.11 129.89,99.67 129.89,97.37 128.87,96.35 v9(128.87,96.36)
  vias: v5(127.99,101.27)
+1.0V_VCCST: length 344.9
  TOP w0.254: R90.1 120.9,94.45 v2(121.26,94.08) ; v7(192.79,118.6) 191.88,117.69 186.86,117.69 PR746.2 ; v10(127.82,96.05) 128.4,96.63 129.75,96.63 130.22,96.16 130.22,94.79 129.87,94.45 RC106.1
  TOP w0.305: v10(116.35,92.13) RC144.2 116.38,92.64 116.62,92.64 116.72,92.54 RC142.1 ; RH66.1 111.26,95.6 v10(111.26,96.45)
  TOP w0.381: v1(128.49,102.12) v10(128.49,102.68)
  TOP w0.762: 150.02,92.69 149.95,92.69 148.92,91.66 148.92,90.1 ; 144.08,90.1 142.02,90.1 140.74,88.83 137.93,88.83 137.92,88.84
  IN1 w0.254: v3(117.91,92.24) 117.81,92.13 v10(116.35,92.13) ; v7(171.81,85.45) 170.22,87.05 163.27,87.05 160.79,89.52 154.51,89.52 153.75,90.28 149.88,90.28 v1(149.07,89.47) ; v10(235.31,121.75) 236.17,120.89 237.26,120.89 v3(237.61,121.24)
  IN1 w0.381: v1(128.49,102.12) v10(128.49,102.68)
  IN1 w0.762: 145.71,89.85 146.97,89.85 147.49,89.33 148.08,89.33
  GND1 w0.254: v10(68.1,110.02) 68.27,110.02 v4(68.46,110.21) ; v10(128.49,102.68) 128.49,102.2 128.52,102.17 v4(128.52,102.12) ; v4(68.27,112.33) 68.1,112.49 v10(68.1,112.68) ; v10(235.31,121.75) 235.33,121.75 235.67,122.08 v4(235.67,122.17)
  GND1 w0.305: v4(110.85,96.58) 110.98,96.45 v10(111.26,96.45) ; v4(127.7,96.43) 127.7,96.16 v10(127.82,96.05)
  GND1 w0.381: v4(115.93,92.03) 116.03,92.13 v10(116.35,92.13)
  IN2 w0.254: v4(74.75,121.27) 74.77,121.29 75.6,121.29 76.74,122.44 76.74,123.02 80.27,126.55 88.98,126.55 89.72,125.81 92.4,125.81 93.25,124.97 94.89,124.97 95.2,124.66 95.2,124.29 96.45,123.04 96.45,121.24 v4(96.7,120.99) ; v3(117.91,92.24) 118.22,92.54 118.85,92.54 118.9,92.59 120.55,92.59 121.26,93.3 v2(121.26,94.08) ; v4(233.76,139.66) 233.6,139.49 233.6,137.65 237.41,133.84 237.41,133.8 238.61,132.6 239.33,132.6 241.35,130.57 241.35,125.69 240.58,124.93 239.03,124.93 237.44,123.34 237.44,121.41 v3(237.61,121.24)
  IN2 w0.381: v4(129.04,92.59) 129.04,90.87 127.74,89.57 126.99,89.57 124.45,87.03 123.27,87.03 122.37,86.13 119.09,86.13 118.86,85.89 108.31,85.89 107.86,85.44 105.96,85.44 v4(105.82,85.3)
  GND3 w0.254: v4(108.88,96.52) 109.81,96.52 110.13,96.83 110.6,96.83 v4(110.85,96.58)
  IN3 w0.254: v6(68.28,112.91) 68.27,112.9 v4(68.27,112.33) 68.29,112.33 68.47,112.15 68.47,110.22 v4(68.46,110.21) ; v6(234.08,139.44) 233.86,139.66 v4(233.76,139.66)
  IN3 w0.305: v6(127.84,95.51) 127.7,95.65 v4(127.7,96.43)
  IN3 w0.381: v6(105.21,84.87) 105.64,85.3 v4(105.82,85.3) ; v4(115.93,92.03) 114.92,93.05 114.64,93.05 113.93,93.76 113.93,94.77 114.08,94.92 114.08,95.79 113.54,96.34 111.24,96.34 111,96.58 v4(110.85,96.58)
  GND4 w0.254: v9(74.35,121.27) v4(74.75,121.27) ; v9(108.99,96.99) 108.99,96.62 v4(108.88,96.52) ; v6(97.11,120.99) v4(96.7,120.99) ; v4(235.67,122.17) v9(235.25,121.75)
  GND4 w0.381: v9(128.91,93.07) 128.94,93.07 129.04,92.97 v4(129.04,92.59)
  BOTTOM w0.254: v6(68.28,112.91) 68.36,112.91 71.56,116.11 71.56,116.87 72.55,117.86 72.55,119.95 73.88,121.27 v9(74.35,121.27) ; v7(171.81,85.45) 170.64,86.62 170.64,88.3 171.99,89.64 174.45,89.64 176.68,91.87 177.02,91.87 182.75,97.6 182.75,103.32 183.6,104.17 187,104.17 189.57,106.74 189.57,108.92 192.64,112 192.64,118.45 v7(192.79,118.6) 192.79,120.81 195.64,123.66 196.6,123.66 199.16,126.21 201.03,126.21 201.76,126.93 208.4,126.93 209.9,128.43 211.47,128.43 212.13,129.09 215.41,129.09 219.96,133.64 219.96,138.91 220.72,139.67 228.39,139.67 228.58,139.86 229.41,139.86 230.64,138.63 232.91,138.63 233.72,139.44 v6(234.08,139.44) ; v6(97.11,120.99) 97.67,120.43 97.67,106.84 97.26,106.43 97.26,95.13 96.22,94.09 96.22,92.07 96.19,92.03
  BOTTOM w0.381: v9(108.99,96.99) 108.67,96.99 107.14,98.51 102.75,98.51 101.99,99.26 101.04,99.26 100.48,99.83 99.68,99.83 99.37,99.53 99.37,98.71 99.99,98.09 99.99,97.45 99.37,96.83 99.37,94.37 99.12,94.12 99.12,91.47 98.48,90.84 97.38,90.84 96.19,92.03 95.38,92.03 94.84,91.49 94.84,90.19 98.23,86.8 98.5,86.8 99.18,86.13 103.96,86.13 v6(105.21,84.87)
  vias: v1(144.7,90.05) v1(144.88,89.76) v1(145.04,90.05) v1(148.69,89.45) v4(136.45,89.05) v4(136.78,89.36) v6(130.51,100.12) v6(130.82,100.12) v6(135.88,89.44) v6(136.19,89.43) v10(137,89.05) v10(137,88.74) v14(131.1,92.21)
+1.0V_XDP: length 8.2
  TOP w0.381: v7(117.1,87.89) 117,87.79 RC154.2
  BOTTOM w0.279: JXDP2.44 118.55,87.27 117.93,87.89 v7(117.1,87.89) 117.1,88.96 118.55,90.41 JXDP2.43
+1.0VA_GATE: length 29.7
  TOP w0.254: R5753.2 154.45,97.13 154.22,97.35 153.18,97.35
  TOP w0.508: v7(141.84,92.11) 142.54,92.81 RC163.1 142.35,93.06 RC157.1
  IN1 w0.508: v3(138.61,88.81) 138.72,88.81 141.84,91.93 v7(141.84,92.11)
  GND1 w0.508: v10(152.25,96.93) 152.02,96.93 v4(151.89,96.81)
  IN2 w0.508: v3(138.61,88.81) 138.61,87.1 v4(139.15,86.57)
  GND4 w0.508: v9(151.9,96.38) 151.9,96.8 v4(151.89,96.81) ; v4(139.15,86.57) 139.34,86.38 v9(139.68,86.38)
  BOTTOM w0.508: v9(151.9,96.38) 151.9,94.88 149.02,92 149.02,91.81 v14(148.73,91.52) 148.73,91.49 143.63,86.38 v9(139.68,86.38)
+1.0VA_S: length 32.8
  IN1 w0.06: v1(167.59,122) 167.39,121.8 167.39,121.49 167.24,121.34 167.24,121.14 166.58,120.48 166.58,119.92 166.83,119.67 166.83,119.52
  IN1 w0.102: 166.83,119.52 166.83,117.76 v5(166.68,117.61)
  GND1 w0.102: v4(166.38,117.37) 166.62,117.61 v5(166.68,117.61) ; v10(151.81,107.03) 151.81,107.23 v4(151.62,107.42)
  IN3 w0.102: v6(161.88,113.85) 161.66,113.63 161.66,107.03 v6(161.09,106.46)
  GND4 w0.102: v4(151.62,107.42) 151.42,107.22 v9(151.42,107.02) ; v9(166.15,117.05) 166.15,117.14 v4(166.38,117.37)
  BOTTOM w0.102: v9(151.42,107.02) 151.42,106.68 154.1,104 155.23,104 156.42,105.19 158.91,105.19 159.42,105.7 159.42,106.41 159.67,106.66 160.89,106.66 v6(161.09,106.46) ; v9(166.15,117.05) 165.08,117.05 v6(161.88,113.85)
+1.0VS_VCCIO: length 43.1
  TOP w0.229: v1(128.49,107.71) v10(128.49,108.27)
  TOP w0.254: v2(122.28,94.72) 122,94.45 RC4.2
  TOP w0.381: v1(128.49,105.48) v10(128.49,106.04) v1(128.49,106.59) v10(128.49,107.15) v1(128.49,107.71)
  GND1 w0.254: v10(126.75,108.93) 127.02,108.93 v4(127.11,108.85) 127.27,108.69 v10(127.72,108.69) 127.75,108.65 128.42,108.65 v4(128.48,108.71) ; v4(128.49,106.76) v10(128.49,107.15) ; v10(128.49,108.27) 128.49,107.73 128.47,107.71 v4(128.47,107.7)
  IN2 w0.254: v4(123.42,98.06) 123.44,98.06 123.38,97.99 123.38,95.82 v2(122.28,94.72)
  IN3 w0.254: v4(123.42,98.06) 123.44,98.06 122.49,99.02 122.1,99.02 121.89,99.23 120.12,99.23 118.94,100.41 116.55,100.41 115.79,101.18 113.33,101.18 111.39,103.12 110.92,103.12 109.94,104.1 109.94,104.61 108.69,105.85 v6(108.69,106.13)
  GND4 w0.254: v9(129.69,104.66) v4(129.02,104.78) v4(128.69,105.11) v4(128.43,105.67) ; v9(128,109.05) 128.33,108.71 v4(128.48,108.71) 128.66,108.89 v9(128.66,109.04) ; v4(123.04,108.85) 123.06,108.83
  BOTTOM w0.06: v9(123.76,109) 123.73,109.02 CC124.2
  BOTTOM w0.254: CC106.2 111.27,109.06 v14(110.64,108.43) 108.69,106.48 v6(108.69,106.13)
  vias: v1(120.31,108.93) v1(120.63,108.69) v1(121.6,108.93) v1(121.92,108.69) v1(122.24,108.93) v1(122.89,108.93) v1(123.21,108.69) v1(124.17,108.93) v1(124.82,108.93) v1(125.14,108.69) v1(125.46,108.93) v1(126.11,108.93) v1(127.07,108.69) v1(127.4,108.93) v1(128.04,108.93) v1(128.36,108.69) v1(128.49,104.92) v1(128.49,104.36) v1(128.98,104.92) v2(117.88,115.75) v2(118.08,115.5) v4(117.54,115.55) v4(117.58,116.06) v4(120.53,108.84) v4(121.63,108.77) v4(122.19,108.89) v4(124.17,108.84) v4(125.02,108.85) v4(126.1,108.85) v5(123.46,108.85) v5(128.35,105.25) v5(128.66,104.73) v5(128.78,104.16) v5(129.04,104.07) v5(129.23,104.25) v5(129.23,103.89) v5(129.42,104.07) v7(149.89,112.99) v7(150.07,112.17) v7(150.11,111.36) v7(150.45,112.99) v7(150.63,112.17) v7(150.68,111.36) v9(121.29,109.02) v9(121.88,109.02) v9(122.54,109.02) v9(126.78,109.02) v9(129.62,106.92) v9(129.67,108.06) v10(120.95,108.93) v10(121.28,108.69) v10(122.56,108.69) v10(123.85,108.69) v10(124.5,108.69) v10(125.78,108.69) v10(126.43,108.69) v10(128.98,104.36) v10(128.98,103.8) v10(129.48,104.36) v10(129.48,103.8) v17(120.68,109.02) v17(123.12,109.02) v17(124.34,109.02) v17(124.95,109.02) v17(125.56,109.02) v17(126.17,109.02) v17(129.67,107.42)
+1.0VS_VCCIO_S: length 10
  TOP w0.381: PR505.1 160.28,120.84 v7(160.81,120.84)
  BOTTOM w0.508: v7(153.3,117.53) 153.3,118.52 153.75,118.98 158.09,118.98 159.94,120.84 v7(160.81,120.84)
+1.0VS_VCCSTG: length 256.9
  TOP w0.229: v1(128.49,101.01) v1(128.49,101.57)
  TOP w0.305: RC19.2 109.56,94.17 110.94,94.17 111.04,94.27 112.11,94.27 112.63,93.75 RC40.1 ; PR714.2 184.64,118.84 184.64,118.78 v7(184.51,118.65) 184.51,118.27 PR747.2
  TOP w0.508: RC18.2 120.16,89.45 119.56,89.45 v7(119.51,89.4) ; RC40.1 112.73,93.63 112.95,93.42 112.95,93.41 112.96,93.4 112.96,92.72 113.29,92.39 v10(113.29,92.36) ; RC38.2 122.24,89.52 122.24,90.11 v7(122.36,90.23) 122.68,90.55 124.35,90.55 124.81,90.1 v10(124.81,89.66) RC34.2 ; RC140.2 128.82,93.58 RC37.2
  IN1 w0.508: v2(120.12,93.58) 120.1,93.61 118.71,93.61 117.95,92.85 117.53,92.85 117.35,92.67 115.63,92.67 114.99,92.03 113.62,92.03 v10(113.29,92.36) ; v7(94.9,126.48) 94.05,125.64 88.4,125.64 88.2,125.43 82.12,125.43 81.26,124.57 v7(81.26,124.44) ; v10(126.84,92.11) 124.83,90.1 124.83,89.64 v10(124.81,89.66)
  GND1 w0.254: v10(126.84,92.11) 126.84,92 v4(126.51,91.68)
  GND1 w0.381: v4(128.73,100.94) 128.48,101.19 v5(128.48,101.28)
  GND1 w0.457: v4(124.63,88.98) 124.81,89.16 v10(124.81,89.66)
  GND1 w0.508: v4(113.57,92.06) 113.29,92.34 v10(113.29,92.36) ; v10(99.63,92.01) v4(98.91,92.01)
  IN2 w0.254: v2(67,112.66) 67,112.52 v4(67.19,112.33)
  IN2 w0.381: v7(119.51,89.4) 119.67,89.56 121.69,89.56 v7(122.36,90.23)
  IN2 w0.508: v4(166.08,87.43) 165.8,87.43 165.02,88.22 161.55,88.22 160.97,88.81 154.51,88.81 153.37,89.95 150.76,89.95 148.25,87.43 144.47,87.43 142.88,89.02 141.29,89.02 139.73,87.46 v4(139.33,87.46)
  IN3 w0.508: v4(166.08,87.43) 166.47,87.05 168.28,87.05 v6(168.33,87) ; v7(119.51,89.4) 119.02,88.91 118.35,88.91 117.77,89.49 116.27,89.49 115.93,89.84 115.93,90.82 115.17,91.58 115.17,92.02 114.69,92.5 114.41,92.5 114.11,92.81 ; v6(129.65,87.23) 130.09,86.79 138.35,86.79 139.02,87.46 v4(139.33,87.46) ; v4(67.19,112.33) 67.19,113.34 67.93,114.08 v6(67.93,116.37) ; 114.11,92.81 113.38,93.53 113.38,94.73 113.08,95.03 111.46,95.03 111.26,95.23 110.8,95.23 110.19,95.84 109.94,95.84 109.51,96.27 109.51,97 109.55,97.04 v6(109.54,97.04) ; 114.11,92.81 114.11,92.8 113.57,92.26 v4(113.57,92.06)
  GND4 w0.254: v9(128.38,100.92) 128.72,100.92 v4(128.73,100.94)
  GND4 w0.305: v4(98.91,92.01) v9(98.46,92.01)
  GND4 w0.406: v9(126.96,91.42) 126.77,91.42 v4(126.51,91.68)
  GND4 w0.508: v9(124.96,88.65) v4(124.63,88.98)
  BOTTOM w0.305: 128.76,100.23 128.76,100.39 128.38,100.77 v9(128.38,100.92)
  BOTTOM w0.508: v7(81.26,124.44) 81.26,124.53 81.04,124.75 79.68,124.75 78.44,125.99 76.75,125.99 76.03,125.27 76.03,122.66 75.5,122.13 73.92,122.13 71.89,120.1 71.89,118.04 70.21,116.37 v6(67.93,116.37) ; v9(126.96,91.42) 127.72,91.42 128.28,91.98 128.28,94.39 127.34,95.33 127.34,96.27 128.76,97.7 CC18.1 128.76,100.23 ; v6(168.33,87) 168.51,87.18 168.51,99.09 173.67,104.25 174.35,104.25 175.42,105.32 175.42,106.41 175.88,106.87 177.43,106.87 178.82,108.26 186.57,108.26 188.07,109.76 v14(188.07,116.34) 188.07,116.9 186.32,118.65 v7(184.51,118.65) ; v6(109.54,97.04) 109.55,97.04 109.55,97.39 107.83,99.11 102.92,99.11 102.22,99.81 101.33,99.81 100.77,100.38 99.45,100.38 98.72,99.65 98.72,94.5 98.46,94.23 v9(98.46,92.01) 98.46,91.85 98.1,91.5 97.49,91.5 96.83,92.16 96.83,94.01 97.75,94.93 97.75,106.22 98.18,106.65 98.18,123.21 v7(94.9,126.48) ; v6(129.65,87.23) 128.23,88.65 v9(124.96,88.65)
+1.2V_KEYSSA: length 19.4
  TOP w0.102: v7(126.5,82.18) 126.5,81.58 v14(126.51,81.57)
  TOP w0.203: JPOGO.21 111.7,86.62 111.69,86.63 111.69,87.28 111.26,87.72 v7(111.26,88.33) ; JPOGO.23 112.1,86.65 112.02,86.72 112.02,86.72 112.02,87.41 111.94,87.49 v7(111.94,88.33)
  TOP w0.254: v7(126.5,82.18) 126.61,82.29 R5704.1
  IN3 w0.254: v7(113.35,81.83) 113.78,81.41 119.94,81.41 120.75,82.22 126.46,82.22 v7(126.5,82.18)
  vias: v7(112.8,81.83)
+1.2V_KEYSSA_DP: length 23
  BOTTOM w1.016: 99.41,85.21 100.28,85.21 102.27,83.22 104.76,83.22 105.57,82.41 105.76,82.41 ; 96.98,85.57 96.98,86.92 94.04,89.86 94.04,92.94 96.51,95.42 96.51,98.84
  vias: v4(95.82,99.87) v4(95.82,99.4) v6(96.74,99.96) v6(96.74,99.63) v7(111.54,82.05) v7(112.1,82.05) v10(94.88,99.86) v10(94.88,99.5) v10(95.23,99.86)
+1.2V_VCCSFR_OC: length 27.7
  TOP w0.381: v10(127.99,104.36) v1(127.99,104.92)
  IN1 w0.381: v10(127.99,104.36) v1(127.99,104.92) ; v1(133.79,87.36) 133.79,88.95 134.65,89.81 134.65,90.42 133.03,92.05 133.03,92.97 v10(132.95,93.05)
  GND1 w0.203: v4(128.15,104.74) 128.36,104.53 v4(128.36,104.34) 128.01,104.34 v10(127.99,104.36)
  GND1 w0.508: v10(132.95,93.05) 132.94,93.06 v4(132.42,93.06)
  IN2 w0.508: v4(128.36,104.34) 128.36,104.53 v4(128.15,104.74)
  GND2 w0.254: v4(132.42,93.06) 132.42,93.98 132.02,94.37 131.63,94.37 131.27,94.73 131.27,96.26 130.08,97.46 130.08,101.28 128.76,102.6 128.76,102.83 128.94,103.01 128.94,103.64 128.36,104.22 v4(128.36,104.34) v4(128.15,104.74)
  GND4 w0.102: v9(132.42,93.49) v4(132.42,93.06)
  GND4 w0.457: v4(128.15,104.74) v4(128.36,104.34)
  BOTTOM w0.102: v14(132.36,96.71) 132.42,96.65 v9(132.42,93.49)
+1.2V_VDDQ: length 130.5
  TOP w0.06: 106.74,113.73 106.58,113.73
  TOP w0.102: PU500.F3 PU500.E2
  TOP w0.203: PU500.E2 PU500.E1
  TOP w0.254: v10(164.64,126) 164.64,125.47 165.32,124.8 PU500.E1
  TOP w0.305: 109.91,126 109.91,126.32 109.45,126.78 108.62,126.78 107.55,125.71 R6.1 ; C34.1 124.39,116.8 v10(124.57,116.62) ; v10(122.57,123.36) 122.57,123.73 R7.1
  TOP w0.508: C29.1 123.17,121.89 122.79,121.51 122.79,121.55 ; C21.1 126.47,117.11 v10(126.23,117.35) ; C17.1 100.67,114.97 ; v1(99.73,109.1) 100.44,109.81 100.49,109.81 C23.1 ; v7(162.33,130.52) 162.33,130.83 162.62,131.11 162.62,132.04 PC621.1 162.15,132.55 163.06,133.46 PC633.1
  IN1 w0.152: v10(128.68,109.42) v1(128.04,109.42) 128.04,109.42 127.4,109.42 ; 127.4,109.42 126.75,109.42 v10(126.75,109.42) v1(126.11,109.42) v1(125.46,109.42) 125.46,109.42 124.82,109.42 v1(124.82,109.42) ; 127.4,109.42 v1(127.39,109.42) 127.4,109.42 ; v1(120.31,109.42) v2(120.95,109.42) v1(121.6,109.42) v1(122.24,109.42) v10(122.89,109.42) v1(123.53,109.42)
  IN1 w0.508: 97.26,97.87 v3(97.26,97.85) ; 97.26,97.87 95.47,96.08 95.47,92.54 95.89,92.12 v10(95.89,91.52) ; 97.26,97.87 98.63,99.25 98.63,104.24 100.08,105.69 100.08,107.58 99.83,107.83 99.83,109 99.73,109.1 v1(99.73,109.1) ; 131.08,84.45 131.08,84.25 130.49,83.66 129.13,83.66 127.5,85.29 126.08,85.29 125.79,85 123.32,85 122.71,84.39 113.62,84.39 113.34,84.67 109.26,84.67 v5(107.59,86.33)
  GND1 w0.254: v4(122.51,109.61) 122.7,109.42 v10(122.89,109.42) ; v10(126.23,117.35) 126.07,117.35 v4(125.79,117.64) ; v4(120.58,109.61) 120.76,109.42 v2(120.95,109.42) ; v4(128.3,109.46) 128.3,109.45 128.33,109.42 v10(128.68,109.42) ; v10(164.64,126) 164.62,126 164.6,126.02 164.29,126.02 v4(164.24,126.07) ; v10(126.75,109.42) 126.4,109.42 v4(126.4,109.42)
  GND1 w0.305: v10(124.57,116.62) 124.57,117.05 v4(124.52,117.1) ; v4(122.84,123.06) 122.57,123.33 v10(122.57,123.36) ; v4(122.82,120.12) 122.82,120.21 v10(122.59,120.44)
  GND1 w0.508: v5(107.59,86.33) 107.44,86.49 v4(107.44,87.09) ; v4(95.84,91.09) 95.84,91.47 v10(95.89,91.52) ; v10(122.76,121.51) v4(122.76,122.03)
  IN2 w0.508: v3(97.26,97.85) 96.36,98.75 95.67,98.75 93.72,100.7 v2(93.72,101.91)
  IN3 w0.508: v4(107.44,87.09) 106.37,87.09 105.61,87.85 104.02,87.85 103.55,88.32 v7(102.82,88.32) ; v7(162.33,130.52) 162.33,126.94 162.57,126.7 163.96,126.7 164.24,126.42 v4(164.24,126.07)
  GND4 w0.254: v9(125.56,110.28) 125.56,109.91 125.91,109.56 126.26,109.56 v4(126.4,109.42) v9(126.4,110.28) ; v9(119.61,110.33) 120.29,110.33 v9(120.31,110.32) 120.31,109.88 v4(120.58,109.61) 120.87,109.9 v9(120.87,110.32) ; 128.3,109.89 128.61,110.19 v9(128.61,110.28) ; 128.3,109.89 v4(128.3,109.46) ; 128.3,109.89 127.91,110.28 v9(127.79,110.28) ; v9(163.87,126.36) 163.95,126.36 v4(164.24,126.07) ; v9(122.27,110.32) 122.27,109.85 v4(122.51,109.61) 122.83,109.92 v9(122.83,110.32)
  GND4 w0.508: v9(96.07,90.43) 95.84,90.66 v4(95.84,91.09)
  BOTTOM w0.254: v9(128.61,110.28) v9(127.79,110.28) CC91.2 v9(126.4,110.28) v9(125.56,110.28)
  BOTTOM w0.381: 150.73,124.56 149.97,125.32 149.97,127.58 150.16,127.77 154.95,127.77 155.96,128.79 160.19,128.79 161.86,127.12 v14(162.27,127.12) 163.04,126.36 v9(163.87,126.36)
  BOTTOM w0.508: v7(102.82,88.32) 102.26,87.77 98.35,87.77 96.07,90.05 v9(96.07,90.43)
  vias: v1(131.63,84.9) v1(131.62,84.6) v7(151.36,123.92) v7(151.36,123.35) v7(151.36,122.72) v7(151.36,122.08) v7(151.94,123.92) v7(151.94,123.35) v7(151.94,122.72) v7(151.94,122.08)
+1.2V_VDDQ_S: length 14
  IN1 w0.102: v7(154.39,121.06) 157.03,121.06 158.27,122.31 v2(158.27,122.41)
  IN2 w0.102: v2(158.27,122.41) 158.93,123.07 158.93,123.66 159.34,124.06 159.98,124.06 160.18,123.86 162.36,123.86 162.54,123.68 163.28,123.68 163.51,123.45 164.19,123.45 164.34,123.6 v2(166.39,123.6)
  vias: v7(152.63,121.06) v7(153.19,121.06) v7(153.45,124.46) v7(153.78,121.06) v7(154.02,124.46) v7(154.62,124.46) v7(154.67,123.87) v7(154.69,123.27) v7(154.67,122.68) v7(154.67,122.09)
+1.8V_MEM: length 225.1
  TOP w0.203: U4.R1 U4.T1 133.75,119.76 134.32,119.18 134.32,118.91 134.83,118.4
  TOP w0.254: C12.1 113.99,120.95 U3.T1 U3.R1 ; 102.57,113.06 103.28,113.06 103.63,113.41 U3.A16 U3.A15
  TOP w0.508: C12.1 114.51,121.12 115.12,121.72 v2(115.12,122.69) ; 175.01,136.44 173.92,137.54 160.7,137.54 160.5,137.74 156.61,137.74 156.25,137.38 v1(156.25,137.04) ; 134.83,118.4 135.05,118.18 v10(135.05,117.79) 135.06,117.78 C13.1 ; U4.A15 U4.A16 125.35,127.42 125.09,127.68 C10.1 123.11,127.68 121.79,129 121.79,129.93 v7(121.72,129.99) 122.02,130.28 v1(137.19,130.28) 137.44,130.04 v2(137.44,128.8) 137.44,127.83 C14.1 138.06,127.01 137.88,127.01 137.45,126.58 v1(137.45,126.35) ; C16.1 123.07,119.13 v10(122.61,119.13) ; v7(137.5,123.53) 137.5,122.92 137.9,122.51 C9.1 ; 102.57,113.06 C15.1
  IN1 w0.508: v7(137.5,123.53) 137.45,123.58 v1(137.45,126.35) ; v1(137.19,130.28) 137.19,131.52 137.67,131.99 139.7,131.99 141.08,133.37 141.08,135.06 142.61,136.6 146.53,136.6 146.95,136.18 149.33,136.18 150.02,135.49 153.47,135.49 155.02,137.04 v1(156.25,137.04)
  GND1 w0.254: v10(126.74,120.42) 126.74,120.42 126.3,119.97 v4(126.12,119.97) ; v4(110.64,113.56) v2(110.64,113.95)
  GND1 w0.508: v4(122.76,119.57) 122.61,119.41 v10(122.61,119.13) ; v10(135.05,117.79) 135.06,117.8 135.99,117.8 v4(136.12,117.66)
  IN2 w0.508: v2(103.63,120.95) 103.07,120.95 102.71,120.59 101.92,120.59 101.28,121.24
  IN3 w0.508: v7(137.5,123.53) 136.12,122.16 v4(136.12,117.66) ; v4(115.58,122.11) 115.47,122 114.53,122 113.29,120.76 113.29,115.93 110.92,113.56 v4(110.64,113.56) ; v7(175.77,136.32) 175.77,135.86 175.46,135.54 174.3,135.54 172.74,137.1 162.49,137.1 162.39,137.01 159.18,137.01 158.61,137.57 151.6,137.57 150.93,136.9 148.06,136.9 147.86,136.7 144.48,136.7 142.17,134.39 142.08,134.39 141.41,133.72 141.41,132.96 139.74,131.29 137.48,131.29 136.64,130.44 129.63,130.44 v4(128.97,131.1)
  GND4 w0.508: v4(126.12,119.97) v9(125.51,119.97) ; v4(128.1,132.06) 128.25,132.22 v9(128.56,132.22) ; v4(122.76,119.57) v6(122.28,119.57)
  BOTTOM w0.508: 120.71,119.57 v6(122.28,119.57) 125.1,119.57 v9(125.51,119.97) ; v7(175.14,136.32) 175.13,136.3 174.71,136.3 174.25,136.76 150.53,136.76 149.38,137.9 141.92,137.9 141.41,137.4 141.41,135.81 141.79,135.43 141.79,133.31 139.92,131.45 129.33,131.45 v9(128.56,132.22)
  vias: v2(99.4,113.32) v2(99.42,112.81) v2(100.64,122.92) v2(100.95,123.15) v2(133.75,127.42) v7(119.72,119.13) v7(119.77,119.72) v14(124.25,118.88)
+1.8V_MEM_S: length 15.5
  TOP w0.102: 177.11,131.71 PC611.1 ; v7(177.73,131.68) 177.13,131.68
  IN1 w0.102: v3(169.2,126.37) 169.19,126.37 v1(169.19,125.6)
  IN2 w0.102: v3(169.2,126.37) 169.07,126.5 v4(168.71,126.5)
  IN3 w0.102: v7(177.73,131.68) 177.73,130.79 177.15,130.21 176.95,130.21 175.78,129.04 175.07,129.04 173.89,130.21 171.41,130.21 169.4,128.2 169.4,126.75 169.14,126.5 v4(168.71,126.5)
+1.8V_PCH_GPP: length 6.5
  TOP w0.229: v1(131.46,104.36) v2(131.95,104.36)
  IN2 w0.254: v2(136.08,107.06) 136.34,107.32 136.37,107.32 v4(136.37,107.31) ; v4(132.29,104.36) v2(131.95,104.36)
  IN3 w0.254: v6(136.02,107.09) 136.05,107.07 136.13,107.07 v4(136.37,107.31)
  GND4 w0.508: v4(132.29,104.36) 132.3,104.35 v6(132.82,104.35)
  BOTTOM w0.508: 133.17,104.83 133.74,105.41 134.18,105.41 134.65,105.88 134.65,106.64 135.11,107.09 v6(136.02,107.09)
  vias: v8(131.7,104.36)
+1.8V_PRIM: length 403.7
  TOP w0.254: C252.1 196.34,128.96 v7(196.34,129.6)
  TOP w0.305: v7(116.06,128.02) 115.92,127.88 RH80.1 RH81.1
  TOP w0.381: v7(30.49,88.86) 30.82,88.86 31.25,88.43 C250.1 32.84,87.77 R228.1 ; v1(22.24,94.95) 22.55,94.65 23.02,94.65 23.7,95.33 R61.1
  TOP w0.508: 172.93,134.78 v10(172.93,134.42) ; R219.1 199.85,128.02 v7(199.27,128.61) ; RH149.2 v10(161.09,101.51)
  IN1 w0.508: v3(17.42,93.71) 17.81,94.1 19.87,94.1 20.72,94.95 v1(22.24,94.95)
  GND1 w0.254: v4(140.95,108.3) 140.95,108.06 v10(140.61,107.72)
  GND1 w0.508: v4(155.61,99.91) 155.61,100.11 155.38,100.34 v10(155.38,100.49) ; v4(172.08,133.51) 172.08,133.57 v10(172.93,134.42) ; v10(161.09,101.51) 160.61,101.51 v4(160.59,101.53)
  IN2 w0.508: v4(131.2,82.27) 131.21,82.25 131.84,82.25 132.43,82.85 132.43,83.27 133.91,84.75 140.49,84.75 142.47,86.74 148.84,86.74 150.28,88.18 160.71,88.18 161.3,87.59 v4(164.76,87.59) ; v7(15.2,87.59) 15.67,88.06 15.67,89.54 17.42,91.28 v3(17.42,93.71)
  IN3 w0.508: v6(140.38,107.96) 140.72,108.3 v4(140.95,108.3) ; v6(187.59,126.4) 187.05,126.93 187.05,129.95 185.25,131.76 v6(184.78,131.76) ; v6(164.9,87.18) 164.92,87.19 164.92,87.43 v4(164.76,87.59) ; v6(192.78,131.2) 194.33,131.2 195.35,130.18 196.02,130.18 196.34,129.87 v7(196.34,129.6) ; v6(163.78,103.25) 164.6,104.07 v6(164.95,104.07)
  GND4 w0.508: v9(160.56,100.87) 160.56,101.51 v4(160.59,101.53) ; v9(155.96,99.58) 155.63,99.91 v4(155.61,99.91) ; v9(172.65,132) 172.65,132.94 v4(172.08,133.51) ; v9(131.02,81.72) 131.2,81.9 v4(131.2,82.27)
  BOTTOM w0.508: v9(131.02,81.72) 130.89,81.59 125.84,81.59 125.51,81.92 123.63,81.92 123.22,81.52 118.81,81.52 118.48,81.19 109.87,81.19 109.52,81.54 104.74,81.54 104.18,82.1 102.17,82.1 100.03,84.23 90.82,84.23 87.81,87.24 83.66,87.24 80.63,84.21 77.48,84.21 74.48,87.21 67.57,87.21 61.74,81.38 52.86,81.38 47.48,86.76 46.27,86.76 42.96,90.08 31.71,90.08 v7(30.49,88.86) 28.17,88.86 27.07,89.96 22.32,89.96 20.79,88.43 18.79,88.43 18.6,88.25 18.22,88.25 17.56,87.59 v7(15.2,87.59) ; v7(116.06,128.02) 116.11,128.07 125.6,128.07 126.72,126.96 135.69,126.96 v14(136.89,128.15) 137.19,128.46 v7(139.86,128.46) 144.23,128.46 148.16,132.39 161.21,132.39 162.13,131.46 163.03,131.46 163.26,131.22 165.12,131.22 165.35,131.45 166.95,131.45 167.53,130.87 171.52,130.87 v9(172.65,132) 172.92,132.27 177.97,132.27 178.52,131.71 184.73,131.71 v6(184.78,131.76) ; 156.27,99.27 156.27,98.59 157.39,97.46 157.39,95.15 156.83,94.59 153.93,94.59 153.64,94.3 153.64,91.65 155.52,89.77 159.18,89.77 160.55,88.4 163.48,88.4 164.7,87.18 v6(164.9,87.18) ; 156.27,99.27 158.96,99.27 v9(160.56,100.87) 162.22,100.87 163.78,102.44 v6(163.78,103.25) ; 156.27,99.27 v9(155.96,99.58) ; v7(196.34,129.6) 196.34,129.28 197.01,128.61 v7(199.27,128.61) ; 189.39,126.4 189.95,125.84 189.95,124.11 189.59,123.76 187.79,123.76 183.73,119.69 178.11,119.69 177.07,118.65 176.05,118.65 174.12,116.72 174.12,114.28 175.44,112.96 175.44,110.15 174.45,109.15 173.83,109.15 172.39,107.7 168.59,107.7 167.2,106.32 166.16,106.32 165.72,105.88 165.72,104.39 165.4,104.07 v6(164.95,104.07) 163.38,105.65 163.38,106 162.08,107.3 162,107.3 159.85,109.45 159.85,109.86 159.37,110.35 152.38,110.35 152.23,110.19 150.81,110.19 150.35,109.74 150.35,106.13 149.89,105.67 148.69,105.67 RH182.2 147.5,106.17 144.97,108.69 144.02,108.69 143.96,108.76 142.16,108.76 142.05,108.64 141.1,108.64 ; 189.39,126.4 v6(187.59,126.4) ; 189.39,126.4 191.93,128.94 191.93,130.35 v6(192.78,131.2)
+1.8VA_S: length 12.1
  GND1 w0.102: v10(169.93,134.65) v4(169.53,134.65)
  IN2 w0.102: v2(167.59,125.6) 167.59,125.62 167.07,126.13 v4(167.02,126.13)
  IN3 w0.102: v4(169.53,134.65) 169.68,134.65 170.48,133.85 170.48,132.48 166.41,128.42 166.41,126.74 v4(167.02,126.13)
+1.8VS: length 273.2
  TOP w0.381: v10(30.85,94.57) 30.85,94.97 30.03,95.79 30.03,97.3 R47.1
  TOP w0.508: R48.1 34.65,96.99 v10(34.98,96.66)
  IN1 w0.06: 164.43,126.89 164.9,126.89 165.37,126.41 165.37,125.93 165.5,125.8 166.12,125.8 166.92,125 167.42,125 167.62,124.8 v1(168.79,124.8)
  IN1 w0.508: v3(95.94,97.77) 98.01,99.84 98.01,104.47 98.84,105.3 98.84,109.07 99.37,109.61 v3(99.37,109.81) ; 164.43,126.89 163.72,126.89 163.67,126.94 163.14,126.94 162.4,127.68 v5(161.95,127.68)
  GND1 w0.254: v10(142.16,125.6) v4(142.6,125.6)
  GND1 w0.508: v10(30.85,94.57) v4(30.85,94.17) ; v4(34.63,96.35) 34.93,96.66 v10(34.98,96.66) ; v4(161.44,127.53) 161.79,127.53 v5(161.95,127.68)
  IN2 w0.254: v4(159.24,114.21) 159.8,114.21 160.33,114.74 160.33,115.6 v4(161.17,116.44)
  IN2 w0.508: v7(92.31,98.66) 93.02,98.66 93.66,98.03 94.75,98.03 95,97.77 v3(95.94,97.77) ; v4(93.22,127.95) 93.22,127.8 93.81,127.21 95.59,127.21 97.14,125.66 97.14,122.64 97.39,122.39 97.39,120.73 96.27,119.62 96.27,115.07 98.91,112.43 98.91,110.27 v3(99.37,109.81)
  IN3 w0.254: v4(161.44,127.53) 161.32,127.41 161.32,125.66 162.24,124.75 162.24,123.45 161.37,122.59 161.37,120.61 161.1,120.33 161.1,116.51 v4(161.17,116.44) ; v4(159.24,114.21) 159.24,111.77 158.81,111.34 154.97,111.34 153.78,110.14 153.78,105.36 151.97,103.55 151.97,102.98 v6(152.11,102.84)
  IN3 w0.508: v4(30.85,94.17) 30.85,93.67 32.61,91.92 34,91.92 34.4,91.52 v6(36.37,91.52) ; v6(160.81,131.42) 160.86,131.42 161.59,130.7 161.59,129.59 161.17,129.17 161.17,128.56 161.35,128.38 161.35,127.62 v4(161.44,127.53) ; v6(142.16,125.7) 142.5,125.7 v4(142.6,125.6)
  GND4 w0.508: v4(30.85,94.17) v9(31.34,94.17) ; v4(34.63,96.35) 34.68,96.35 34.87,96.16 v9(34.87,95.55) ; v4(93.22,127.95) 93.22,128.76 v9(93.35,128.89)
  BOTTOM w0.254: RH70.2 RH71.2 137.52,105.52 137.95,105.09 138.87,105.09 139.68,105.9 139.68,106.36 141.48,108.16 142.25,108.16 142.36,108.28 143.76,108.28 143.82,108.21 144.77,108.21 146.98,106 147.79,105.19 148.11,105.19 149.36,103.94 149.36,103.34 149.67,103.03 150.27,103.03 150.45,103.21 151.82,103.21 152.19,102.84 v6(152.11,102.84)
  BOTTOM w0.508: v7(92.31,98.66) 91.98,98.99 90.15,98.99 88.89,97.73 88.89,95.32 86.98,93.4 86.98,89.44 85.64,88.11 83.05,88.11 80.09,85.15 78.04,85.15 75.06,88.12 66.88,88.12 61.11,82.34 53.17,82.34 47.92,87.59 46.88,87.59 43.55,90.93 36.96,90.93 v6(36.37,91.52) ; v9(31.34,94.17) 32.72,95.55 v9(34.87,95.55) ; v6(160.81,131.42) 154.93,131.42 153.88,130.38 148.51,130.38 143.84,125.7 v6(142.16,125.7) v14(140.65,125.7) 138.96,125.7 138.59,125.33 126.12,125.33 124.97,126.47 120.5,126.47 120.28,126.25 115.61,126.25 114.07,127.79 114.07,128.77 113.32,129.52 113.32,130.48 112.59,131.2 108.49,131.2 105.39,128.1 97.57,128.1 96.63,129.04 93.5,129.04 v9(93.35,128.89)
+1.8VS_AUDIO: length 107.4
  TOP w0.203: UA1.24 25.44,17.83 25.06,17.46
  TOP w0.305: C276.1 40.11,86.14 R211.2
  TOP w0.508: 25.06,17.46 24.47,16.86 24.47,16.3 24.23,16.06 CA2.1 23.92,15.59 23.29,14.96 CA5.1 22.79,14.96 22.38,14.55 RA6.1 21.69,14.55 21.19,15.04 v7(21.19,15.67) ; R211.2 39.67,86.46 v7(39.03,86.46)
  IN3 w0.508: v7(21.19,15.67) 19.97,16.89 19.97,19.64 20.64,20.31 20.64,22.1 20.2,22.54 17.35,22.54 15.25,24.64 15.25,30.37 14.56,31.06 14.56,37.86 15.75,39.06 15.75,41.54 17.66,43.45 17.66,49.09 16.34,50.41 16.34,55 14.9,56.44 14.9,59.18 13.85,60.23 12.41,60.23
  BOTTOM w0.508: v6(11.77,60.23) 12.48,60.23 14.39,62.14 14.39,66.09 20.64,72.35 26.49,72.35 26.97,72.83 28.26,72.83 28.75,72.35 30.5,72.35 32.85,74.7 32.85,80.28 v14(38.5,85.93) v7(39.03,86.46)
  vias: v6(11.18,60.23)
+1.8VS_AUDIO_AMP: length 6.2
  TOP w0.119: 197.87,121.8 197.92,121.75 v13(198.46,121.75)
  TOP w0.203: CA115.1 200.36,124.11 200.7,123.77 UA2.13 ; 200.04,122.33 200.21,122.17 UA2.17
  TOP w0.305: CA115.1 200.17,123.77 v1(200.26,123.68) ; R206.2 199.83,122.79 200.04,122.58 CA103.1 200.04,122.33
  vias: v1(198.89,123.35)
+3.3V_PCH_GPP: length 13.1
  TOP w0.203: v10(131.95,107.15) v1(132.44,107.37)
  IN2 w0.254: v4(136.72,107.7) 136.66,107.76 136.66,107.99 v2(136.54,108.11)
  IN2 w0.381: v4(136.05,104.76) v2(136.57,104.76) 136.68,104.76 137.57,103.87 v2(137.57,103.74)
  IN3 w0.254: v6(136.33,107.98) 136.62,107.7 v4(136.72,107.7)
  IN3 w0.381: v4(136.72,107.7) 137.13,107.29 137.13,106.83 137.83,106.13 137.83,105.42 137.17,104.76 v4(136.05,104.76)
  GND4 w0.254: v9(132.42,107.27) 132.19,107.5 v4(132.09,107.5)
  BOTTOM w0.254: v6(136.33,107.98) 136.02,107.98 135.84,108.16 134.32,108.16 133.61,107.45 132.59,107.45 v9(132.42,107.27)
  vias: v5(132.24,107.12)
+3.3V_SPI: length 15
  TOP w0.305: v7(209.51,135.11) 209.62,135 RH90.1 RH91.1 CH32.1 213.33,133.74 U18.8
  TOP w0.508: RC59.1 204.34,138.91 v7(206.04,138.91)
  BOTTOM w0.254: JSPI1.15 207.28,140 206.78,139.49 206.75,139.52
  BOTTOM w0.508: v7(209.51,135.11) 209.43,135.11 208.44,136.1 206.97,136.1 v14(206.52,136.55) 206.52,138.43 v7(206.04,138.91) 206.14,138.91 206.75,139.52
+3.3V_VCCSPI: length 25
  TOP w0.305: v2(131.95,108.27) 131.99,108.31 v1(131.99,108.69)
  IN1 w0.381: v1(131.99,108.69) 131.95,108.65 v2(131.95,108.27)
  GND1 w0.254: v2(131.95,108.27) 131.98,108.3 131.98,108.61 v4(131.96,108.63)
  GND1 w0.381: v4(140.57,110.55) 140.93,110.9 v10(141.19,110.9)
  GND2 w0.381: v4(140.57,110.55) 140.19,110.93 140.19,111.11
  GND2 w0.508: 140.19,111.11 138.97,112.33 138.74,112.33 136.82,114.24 135.58,114.24 134.55,113.22 134.55,112.15 132.26,109.86 132.26,108.94 v4(131.96,108.63)
  GND4 w0.254: v4(140.57,110.55) 140.42,110.7 v9(140.04,110.7)
  GND4 w0.381: v4(131.96,108.63) 131.99,108.59 132.37,108.59 v9(132.39,108.62)
  BOTTOM w0.508: v9(140.04,110.7) 139.34,110.7 139.19,110.85 136.99,110.85 135.59,109.46 132.45,109.46
+3.3VDX_SSD: length 6.1
  TOP w0.305: U712.5 196.47,102.54 v7(196.74,102.27)
  TOP w0.508: R1378.2 208.77,110.85 207.75,111.87 206.94,111.87 206.61,111.54 206.61,110.47
  vias: v7(194.22,107.86) v7(194.28,107.21) v7(194.74,108.15) v7(194.7,107.57) v14(194.57,106.56)
+3V_1.8V_HDA: length 17.7
  TOP w0.203: v1(129.48,108.27) 129.48,108.51 v10(129.65,108.69)
  GND1 w0.305: v10(140.61,108.63) 140.61,109.04 140.44,109.2 v4(140.19,109.2)
  IN3 w0.508: v6(131.93,110.65) 129.9,110.65 129.32,110.07 v4(129.32,108.9) ; v6(139.72,112.1) 139.72,111.96 139.76,111.92 139.76,109.84 140.19,109.41 v4(140.19,109.2)
  GND4 w0.508: v4(129.32,108.9) 129.27,108.95 v9(129.27,109.23)
  BOTTOM w0.508: v6(131.93,110.65) 131.96,110.63 132.8,110.63 134.85,112.68 137.57,112.68 138.15,112.1 v6(139.72,112.1)
  vias: v5(129.44,108.52)
+3V_DD: length 82.6
  TOP w0.254: PR256.1 64.69,128.7 64.69,115.98 v2(65.03,115.64) ; PR257.2 PC203.1 ; PC203.1 95.64,96.22 PD205.1 96.07,96.65 96.07,112.28 96.5,112.71 96.5,123.5 v2(95.73,124.27) ; PC203.1 PR258.1
  IN2 w0.254: v2(95.73,124.27) 95.57,124.43 95.57,124.81 94.99,125.38 93.34,125.38 92.55,126.17 89.87,126.17 89.13,126.91 80.12,126.91 76.13,122.91 76.13,122.46 75.39,121.72 74.5,121.72 73.51,120.73 71.79,120.73 70.67,119.62 69.12,119.62 68.31,118.8 68.14,118.8 65.03,115.69 v2(65.03,115.64)
+3V_LDO: length 44.7
  TOP w0.381: PR239.1 69.87,129.64 v2(71.82,129.64)
  TOP w0.508: PQ209.1 53.07,143.87 51.98,142.79 51.03,142.79 PC201.1 50.74,142.49 PR255.1 50.74,141.29 51.05,140.97 v1(51.05,140.95) 51.02,140.92 PU200.5
  IN1 w0.381: v3(61.59,140.05) 60.75,140.05 60.04,140.76 60.04,141.65 58.84,142.85 57.58,142.85
  IN1 w0.508: 57.58,142.85 57.02,142.29 56.7,142.29 56.22,141.81 55.16,141.81 54.66,141.31 51.41,141.31 v1(51.05,140.95)
  IN2 w0.381: v2(71.82,129.64) 71.82,129.65 72.47,130.3 v4(72.47,130.5) 72.47,130.91 73.98,132.42 73.98,135.87 72,137.85 70.66,137.85 69.74,138.76 65.63,138.76 65.09,139.3 62.34,139.3 v3(61.59,140.05)
  GND4 w0.119: v4(72.47,130.5) v15(72.47,130.99)
+3V_PDLDO: length 93.4
  TOP w0.254: v7(46.21,139.81) 46.22,139.8 PR156.1
  TOP w0.508: v10(29.95,70.7) 29.52,70.7 PC134.1 29.32,71.15 29.55,71.38 30.18,71.38 30.59,70.98 PU102.5 ; v7(44.24,91.11) 43.63,90.5 PQ113.1
  GND1 w0.508: v4(29.56,69.91) 29.56,70.3 v10(29.95,70.7)
  IN3 w0.508: v6(40.32,88.21) 40.85,88.21 43.75,91.11 v7(44.24,91.11) 44.24,91.65 40.51,95.39 v6(40.27,95.39) ; v6(30.75,81.87) 31.06,81.57 31.06,71.41 v4(29.56,69.91)
  BOTTOM w0.508: v6(40.32,88.21) 37.09,88.21 v6(30.75,81.87) ; v7(46.21,139.81) 45.55,139.81 43.98,138.23 41.69,138.23 41.05,137.6 41.05,128.1 41.92,127.24 41.92,111.64 39.33,109.05 39.33,102.42 40.75,101 40.75,97.59 40.27,97.11 v6(40.27,95.39)
+3V_PDLDO_OUT: length 84
  TOP w0.508: PR149.2 PC131.2 PC132.1 42.7,87.41 PQ113.3 40.27,89.85 40.27,91.03 39.48,91.82 PR153.1 39.39,93.86 38.46,94.79 v10(38.33,94.79) ; v7(26.71,87.65) 26.66,87.65 PQ114.3
  IN1 w0.508: v7(30.96,92.54) 30.96,89.68 31.07,89.57 31.07,88.62 30.68,88.22 30.68,84.07 v8(30.45,83.84)
  GND1 w0.508: v4(29.43,84.49) 29.43,84.21 29.8,83.84 v8(30.45,83.84) ; v10(38.33,94.79) 38.06,94.51 v4(37.9,94.51)
  IN3 w0.381: v6(16.62,66.72) 16.62,65.65 16.86,65.41 16.86,60.47 15.7,59.31 15.7,56.68 17.07,55.31 v6(17.07,54.48)
  IN3 w0.508: v7(30.96,92.54) 32.2,91.3 33.76,91.3 34.22,90.84 36.85,90.84 37.9,91.89 v4(37.9,94.51) ; v7(26.71,87.65) 28.25,87.65 29.86,86.04 29.86,84.92 v4(29.43,84.49) 29.43,84.45 25.74,80.75 25.74,78.52 28.05,76.21 28.05,73.07 v6(27.17,72.19)
  BOTTOM w0.305: R5698.1 R5731.1
  BOTTOM w0.381: v6(27.17,72.19) 26.57,71.6 20.67,71.6 16.62,67.55 v6(16.62,66.72) ; v6(17.07,54.48) 17.21,54.34 R5731.1
+3V_PRIM: length 484.9
  TOP w0.254: RH123.2 RH124.2 136.89,93.72 R1136.2 137.23,93.05 v10(137.33,92.95)
  TOP w0.305: v10(163.42,97.52) 163.38,97.49 163.38,95.11 162.99,94.72 RH148.2 RH151.2 ; Q10.6 146.47,124.28 146.82,124.64 ; RH94.2 RH95.2 142.25,99.94 142.5,99.69 v10(142.5,99.5) ; RH41.2 146.95,107.39 146.95,101.85 v10(146.51,101.42) RC82.2 ; RH114.1 141.29,113.28 RC85.1
  TOP w0.381: R5711.2 201.94,147.75 v1(201.7,147.51) ; Q343.2 203.36,142.58 v10(203.37,142.56)
  TOP w0.508: v10(141.18,112.22) 141.18,113.17 RC85.1 ; v1(136.96,90.55) 136.96,90.39 137.38,89.97 RC9.1 ; v7(194.44,135.8) 193.91,136.33 R201.1 ; RH177.2 157.44,100.21 v10(157.44,100.67) 157.28,100.82 RH146.1 ; v7(146.87,130.23) 146.82,130.19 146.82,124.64 ; v7(139.81,108.75) 139.6,108.54 RC156.1
  IN1 w0.305: 136.94,90.56 136.57,90.93 136.57,91.69 137.34,92.46 137.34,92.94 v10(137.33,92.95) ; 136.94,90.56 136.99,90.56 137.41,90.99 138.36,90.99 138.75,90.6 138.75,89.81 137.66,88.72 137.66,88.19 132.55,83.08 v5(132.34,83.08) ; 136.94,90.56 v1(136.96,90.55)
  IN1 w0.508: v2(224.77,143.67) v2(221.77,143.67) ; v7(212.15,147.94) 212.15,147.96 211.4,148.71 209.11,148.71 207.5,147.1 202.75,147.1 202.34,147.51 v1(201.7,147.51) 201.3,147.51 200.46,148.34 199.23,148.34 198.82,147.94 196.49,147.94 196.44,147.99 v10(195.75,147.99)
  GND1 w0.254: v4(102.06,98.6) 102.5,99.03 v10(102.5,99.23) ; v10(141.18,112.22) 141.35,112.22 141.69,111.88 v4(141.69,111.86) ; v4(195.23,147.99) v10(195.75,147.99) ; v10(139.05,102.21) 139.05,102.62 v4(138.84,102.83) ; v4(141.4,96.41) 141.29,96.3 v10(140.99,96.3)
  GND1 w0.305: v10(163.42,97.52) 163.82,97.52 v4(163.89,97.45) ; v4(146.77,102.14) 146.77,102.13 146.74,102.1 146.74,101.99 146.51,101.76 v10(146.51,101.42) ; v10(137.33,92.95) 137.37,92.99 v4(137.37,93.56) ; v4(131.82,83.06) 131.81,83.07 132.33,83.07 v5(132.34,83.08)
  GND1 w0.508: v4(142.93,98.57) 142.93,99.17 142.5,99.6 v10(142.5,99.5) ; v4(203,142.12) 203.37,142.49 v10(203.37,142.56) ; v10(157.44,100.67) 156.88,100.67 v4(156.85,100.69)
  IN2 w0.254: v4(187.31,138.23) 187.07,138 182.89,138 182.6,137.71 180.03,137.71 179.74,138 173.74,138 173.4,137.66 159.4,137.66 158.87,138.2 144.18,138.2 144.1,138.27 142.39,138.27 141.7,137.59 141.7,135.68 142.36,135.02 142.36,134.16 140.76,132.56 132.38,132.56 131.48,133.46 131.48,133.99 131.04,134.42 v4(131.04,135.85)
  IN2 w0.508: v2(221.77,143.67) 221.11,143.67 219.61,145.17 215.93,145.17 v4(215.55,145.55) 215.55,146.55 214.17,147.94 v7(212.15,147.94)
  IN3 w0.127: v4(156.85,100.69) 156.85,100.16 156.09,99.4 155.25,99.4 154.59,100.06 v6(154.59,100.26)
  IN3 w0.254: v4(102.06,98.6) 101.82,98.6 v6(101.6,98.81) ; v7(194.44,135.8) 194.44,135.95 194.82,136.32 v6(194.82,140.06) ; v4(131.04,135.85) 130.79,135.85 129.94,136.7 v6(124.9,136.7) ; v6(141.18,109.25) 141.18,112 v6(141.38,112.2) 141.69,111.9 v4(141.69,111.86) ; v4(187.31,138.23) 187.59,138.23 188.96,139.61 188.96,141.56 190.07,142.67 190.07,145.08 192.98,147.99 v4(195.23,147.99)
  IN3 w0.305: v6(105.91,86.2) 111.16,80.95 129.12,80.95 131.21,83.04 131.8,83.04 v4(131.82,83.06)
  IN3 w0.381: v6(154.59,100.26) 154.74,100.41 156.22,100.41 156.5,100.69 v4(156.85,100.69)
  IN3 w0.508: v4(156.85,100.69) 157.38,101.23 158.86,101.23 160.78,103.14 162.82,103.14 164.38,104.71 165.41,104.71 165.83,105.13 165.83,105.49 166.24,105.9 167.38,105.9 168.68,107.2 170.97,107.2 v6(171.99,106.18) ; v6(150.3,104.66) 150.3,105.82 v6(149.74,106.38) ; 148.26,102.85 147.55,102.14 v4(146.77,102.14) 146.24,101.62 146.24,101.52 143.29,98.57 v4(142.93,98.57) 142.84,98.48 142.84,97.25 142.01,96.41 v4(141.4,96.41) ; v6(196.18,130.95) 196.18,131.4 194.82,132.76 194.82,135.14 194.44,135.52 v7(194.44,135.8) 202.81,135.8 v7(205.28,138.26) 205.28,138.78 203,141.05 v4(203,142.12) 203,142.63 204.6,144.23 207.18,144.23 208.5,145.55 v4(215.55,145.55) ; v6(105.9,134.99) 106.75,134.15 110.01,134.15 111.41,132.75 v6(113.96,132.75)
  GND4 w0.254: v9(141.32,96.83) 141.4,96.75 141.4,96.42 v4(141.4,96.41) ; v4(138.84,102.83) 138.83,102.84 v9(138.4,102.84)
  GND4 w0.305: v9(163.92,97.87) 163.92,97.47 v4(163.89,97.45) ; v9(136.86,94.29) 137.36,93.8 137.36,93.56 137.37,93.54 v4(137.37,93.56)
  GND4 w0.508: v4(156.85,100.69) 157,100.85 v9(157,101.3)
  BOTTOM w0.254: R111.1 192.35,141.24 193.54,140.06 v6(194.82,140.06) ; 139.34,108.28 v7(139.81,108.75) ; 139.34,108.28 139.34,108.35 138.69,109 RH102.2 138.36,108.8 138.07,108.5 RH128.2 ; 139.34,108.28 RC83.1 ; RC7.1 141.38,112.19 v6(141.38,112.2) ; v6(105.9,134.99) 107.6,136.7 v6(124.9,136.7)
  BOTTOM w0.305: v6(101.6,98.81) 101.87,98.54 R1224.1 102.03,98.06 106.63,98.06 107.21,97.49 107.21,96.54 104.08,93.42 104.08,90.94 105.04,89.99 105.04,86.91 105.74,86.2 v6(105.91,86.2) ; RH74.2 139.95,101.96 140.3,101.96 140.54,101.72 140.82,101.72 141.38,101.16 141.79,101.16 142,100.95 144.62,100.95 146.77,103.1 146.77,104.2 146.95,104.38 148.34,104.38 148.88,103.84 v6(148.88,103.48) ; JSPI1.16 206.78,140.3 206.39,139.91 205.9,139.91 205.28,139.29 v7(205.28,138.26) ; 137.17,95.5 136.85,95.82 RH127.2 ; 137.17,95.5 RH125.2 RC50.1 RH122.2 139.08,95.5 139.38,95.79 139.38,96.53 139.62,96.77 RH126.2 RH27.2 141.26,96.77 v9(141.32,96.83) ; 137.17,95.5 136.86,95.19 v9(136.86,94.29) ; v6(171.99,106.18) 171.94,106.23 170.9,106.23 167.89,103.22 167.89,101.93 167.04,101.07 165.59,101.07 164.64,100.12 164.64,98.6 v9(163.92,97.87)
  BOTTOM w0.508: 184.91,117.91 185.76,117.91 186.75,116.93 186.75,110.42 185.68,109.36 176.69,109.36 175.15,107.82 174.37,107.82 172.73,106.18 v6(171.99,106.18) ; v6(149.74,106.38) 149.74,107.24 149.05,107.93 146.59,107.93 145.2,109.33 144.22,109.33 144.18,109.37 141.91,109.37 141.79,109.25 v6(141.18,109.25) 140.57,109.25 140.06,108.75 v7(139.81,108.75) ; v7(146.87,130.23) 144.42,127.79 138.25,127.79 136.81,126.35 126.47,126.35 125.35,127.47 119.83,127.47 119.58,127.21 116.01,127.21 115.12,128.1 115.12,129.12 114.28,129.95 114.28,132.43 v6(113.96,132.75) ; v6(196.18,130.95) 195.12,129.88 195.12,129.31 195.43,128.99 195.69,128.99 196.15,128.53 196.15,127.9 194.95,126.7 194.95,125.89 v14(193.59,124.53) 191.71,122.65 191.71,121.81 189.16,119.26 184.16,119.26 183.73,118.83 ; v9(157,101.3) 156.37,101.94 153.93,101.94 153.14,102.73 153.14,103.44 152.63,103.94 150.81,103.94 150.3,104.45 v6(150.3,104.66)
  vias: v1(141.4,108.87) v7(182.9,117.89) v7(183.48,117.9)
+3V_SKYCAM: length 154.7
  TOP w0.127: U16.A7 v10(193.77,141.7)
  TOP w0.254: v10(194.17,141.7) v10(193.77,141.7) ; 194.14,144.69 194.17,144.66 v2(194.17,144.1) ; U16.D1 195.96,142.5 196.35,142.88 v7(196.35,143.06)
  TOP w0.508: C99.1 194.6,145.4 194.14,144.94 194.14,144.69 ; v7(191.32,139.86) 191.74,139.44 191.74,139.23 C100.1 ; v7(198.64,148.58) 198.41,148.81 194.76,148.81 194.35,148.41 194.35,147.99
  GND1 w0.254: v10(194.17,141.7) 194.17,141.54 v4(193.98,141.35) 193.93,141.35 193.77,141.51 v10(193.77,141.7)
  IN2 w0.203: v2(193.77,143.7) 193.77,144.02 v4(193.71,144.08) 193.73,144.1 v2(194.17,144.1)
  IN2 w0.508: v7(191.32,139.86) 191.46,140 191.89,140 192.04,140.15 192.78,140.15 v4(193.98,141.35)
  IN3 w0.508: v6(188.8,124.37) 189.64,125.21 189.64,131.58 189.3,131.92 189.3,135.35 191.32,137.37 v7(191.32,139.86) ; v6(121.49,117.25) 120.75,117.25 119.13,118.88 119.13,120.02 119.77,120.66 v6(119.77,121.24)
  GND4 w0.254: v4(193.98,141.35) 194.23,141.6 v9(194.23,142.15) ; v9(194.11,144.23) 193.86,144.23 v4(193.71,144.08)
  BOTTOM w0.508: v7(198.64,148.58) 198.64,147.39 196.58,145.32 196.58,144.99 ; v6(188.8,124.37) 187.54,124.37 183.47,120.3 177.86,120.3 176.82,119.26 175.8,119.26 173.36,116.82 173.36,114.1 174.81,112.65 174.81,110.93 174.26,110.38 173.62,110.38 173.25,110.02 165.46,110.02 164.9,109.46 162.77,109.46 159.97,112.25 154.49,112.25 150.98,115.76 145.04,115.76 143.41,114.13 137.34,114.13 134.22,117.25 v6(121.49,117.25) ; v7(94.09,127.82) 96.12,127.82 97.14,126.8 105.57,126.8 109.18,123.2 117.81,123.2 v6(119.77,121.24)
  vias: v14(195.43,144.84)
+3V_TBT: length 10.3
  TOP w0.203: UT1.H9 v7(22.98,34.36)
  TOP w0.305: v10(30.83,27.95) R1390.2
  GND1 w0.254: v4(31.2,28.29) 30.85,27.95 v10(30.83,27.95)
  GND1 w0.305: v10(21.77,27.94) 21.77,27.9 v4(21.42,27.54)
  GND1 w0.508: v4(33.29,31.33) 33.07,31.11 v10(32.82,31.11)
  IN3 w0.508: 20.19,30.15 21.42,28.91 v4(21.42,27.54)
  GND4 w0.508: v4(21.42,27.54) 21.42,27.95 v9(21.51,28.04)
  BOTTOM w0.356: R1407.2 22.7,29.23 v9(21.51,28.04)
  BOTTOM w0.381: v7(22.98,34.36) 23.09,34.25 R1412.2 22.56,33.63 C1287.2
  vias: v4(17.9,24.1) v4(18.31,24.33) v7(18.65,30.54) v7(18.65,29.95) v7(19.23,30.54) v7(19.23,29.95) v9(17.2,23.77) v9(17.41,24.02) v9(17.58,23.77) v10(18.74,23.57) v10(18.93,23.26) v10(19.12,23.57) v14(19.12,28.48)
