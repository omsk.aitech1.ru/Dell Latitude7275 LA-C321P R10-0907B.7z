# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DP_5: length 20.9
  IN1 w0.06: v1(123.85,111.64) 123.85,111.85 124.05,112.05 124.05,112.22 124.04,112.23 124.04,112.23 123.97,112.3 123.97,112.57 124.07,112.67 124.07,114.86 124.01,114.92 124.01,114.93 123.99,114.96 123.99,114.96 123.6,115.35
  IN1 w0.069: 123.6,115.35 123.32,115.63 123.32,115.63 123.32,117.43 123.85,117.97 123.85,119.88 123.96,119.98 123.96,125.29 124.87,126.21 124.87,126.67 125.15,126.95 125.27,126.95 v18(125.28,126.93)
  IN2 w0.091: v2(127.74,127.42) 127.74,127.29 127.97,127.07 127.97,126.82 127.84,126.69 127.61,126.69 127.52,126.78 126.98,126.78 126.43,126.22 125.56,126.22 125.43,126.35 125.33,126.46 125.33,126.89 v18(125.28,126.93)
M_B_DQS_DP_6: length 15.4
  IN1 w0.069: v18(131.95,118.79) 131.95,118.61 132.09,118.46 132.25,118.46 132.32,118.54 132.32,118.71 132.47,118.86 132.82,118.86 133.39,119.42 133.45,119.42 133.82,119.42 134.13,119.74 134.13,121.14 134.12,121.15 134.12,121.17 133.88,121.42 v1(133.74,121.42)
  IN2 w0.06: 132.78,116.02 132.63,115.87 132.63,115.87 128.36,111.6 128.36,111.05 128.36,111.05 128.36,110.79 128.36,110.79 v2(128.36,110.66)
  IN2 w0.084: 132.8,116.04 132.78,116.02
  IN2 w0.091: 132.8,116.04 132.8,118.09 132.69,118.19 132.1,118.79 v18(131.95,118.79)
M_B_DQS_DP_7: length 18.3
  IN1 w0.069: v18(134.26,123.28) 134.12,123.28 134.01,123.17 133.15,123.17 132.98,123.34 132.98,123.53 132.74,123.77 v1(132.74,123.92)
  IN2 w0.06: v2(129.65,110.16) 129.65,110.38 129.73,110.46 129.73,110.46 129.85,110.57 129.85,110.74 129.77,110.82 129.77,111.09 134.5,115.82 134.54,115.82
  IN2 w0.091: v18(134.26,123.28) 134.46,123.08 134.67,123.08 134.77,122.98 134.81,122.93 134.81,122.61 135.47,121.96 135.47,118.63 134.72,117.89 134.72,116.01 134.54,115.82
M_B_ODT0: length 28.6
  IN1 w0.06: v18(127.24,114.63) 127.26,114.64 127.26,114.82 127.12,114.96 127.12,115.93 127.48,116.3 127.48,117.86 127.4,117.93 v18(127.4,117.96)
  IN1 w0.061: v18(130.29,123.93) 130.29,123.87 129.25,122.82 v18(129.25,122.7)
  IN2 w0.06: v18(127.24,114.63) 127.21,114.59 126.68,114.59 126.4,114.32 126.4,112.79 126.33,112.71 126.33,110.84 126.18,110.69 126.18,110.27 125.99,110.08 125.82,109.92 125.8,109.92 v2(125.46,109.92)
  IN2 w0.076: v18(129.25,122.7) 129.25,123.8 129.07,123.97 127.78,123.97 127.65,123.85 127.65,123.74 127.78,123.61 128.87,123.61 128.97,123.51 128.97,123.21 128.67,122.9 127.17,122.9 126.32,122.06 126.32,121.53 127.14,120.71 127.14,120.18 126.99,120.03 126.79,120.03 126.66,119.91 126.66,118.42 127.11,117.97 127.34,117.97 127.35,117.96 v18(127.4,117.96) ; v2(132.24,123.42) 131.37,123.42 130.86,123.93 v18(130.29,123.93) 130.3,123.94 130.3,125.08 129.95,125.43 129.95,125.71 v2(129.74,125.92)
MAG_DRDY: length 7.6
  TOP w0.119: QT18.2 230.11,106.65 229.07,105.61 224.6,105.61 223.96,106.25 U20.9
MAG_I2C_ADD_SEL: length 5.4
  TOP w0.119: R104.2 R110.1 218.81,107.17 219.22,106.76 U20.6
ME_FWP#: length 139
  TOP w0.119: v7(229.6,119.65) 229.98,119.28 R174.1 R171.2 230.55,119.3 230.77,119.52 231.6,119.52 231.91,119.82 231.91,120.64 U27.J13
  IN1 w0.089: v7(231.58,134.45) 231.58,134.85 230.56,135.87 229.78,135.87 229,136.66 228.69,136.66 228.29,137.06 221.93,137.06 221.82,136.95 212.52,136.95 211.05,135.49 211.05,135.27 206.58,130.8 206.02,130.8 204.28,129.06 203.25,129.06 202.37,128.18 201.3,128.18 201.17,128.04 198.14,128.04 197.28,127.19 195.06,127.19 193.79,125.92 191.92,125.92 190.14,124.13 188.73,124.13 187.06,122.47 187.06,120.8 185.12,118.86 185.12,118.38 184.8,118.05 184.13,118.05 183.63,118.56 178.27,118.56 176.96,117.24 176.96,113.43 178.53,111.86 178.53,110.38 177.22,109.07 176.9,109.07 176.47,108.65 176.21,108.65 175.98,108.88 174.01,108.88 172.89,109.99 171.89,109.99 171.58,110.31 171.58,110.88 170.3,112.15 169,112.15 167.58,113.57 166.78,113.57 166.2,114.15 166.2,114.8 164.9,116.1 164.9,119.56 164.2,120.26 163.99,120.26 163.32,120.93 162.38,120.93 162.17,121.14 161.32,121.14 161.25,121.22 160.64,121.22 159.1,119.68 150.73,119.68 149.36,121.05 149.36,121.32 149.21,121.47 148.65,121.47 148.34,121.17 147.67,121.17 146.55,122.28 146.55,123.42 v1(146.2,123.78)
  IN3 w0.084: v7(229.6,119.65) 229.41,119.84 229.41,122.68 229.14,122.95 229.14,124.21 231.04,126.11 231.27,126.11 232.1,126.94 232.1,127.32 232.43,127.65 232.43,128.85 231.71,129.58 231.71,132.72 231.98,133 231.98,133.94 231.58,134.35 v7(231.58,134.45)
ME_SUS_PWR_ACK: length 118.4
  TOP w0.089: RH59.1 T28.1 v1(144.76,112.99)
  IN1 w0.089: v1(144.76,112.99) 144.86,113.09 145.72,113.09 146.18,112.63 146.71,112.63 147.1,112.25 147.1,111.94 150.05,108.99 150.05,108.37 150.32,108.09 150.32,107.09 150.52,106.89 151.19,106.89 151.72,106.36 151.72,105.27 152.11,104.87 152.11,103.96 154.08,102 156.24,102 156.46,101.77 158.88,101.77 159.01,101.9 159.93,101.9 160.05,102.03 161.23,102.03 161.76,101.49 163.68,101.49 163.99,101.81 165.39,101.81 165.87,102.29 166.99,102.29 167.39,101.89 180.7,101.89 181.55,101.04 183.31,101.04 183.58,101.31 184.77,101.31 185.26,101.8 188.05,101.8 188.25,101.99 189.18,101.99 191.57,104.38 191.57,104.54 192.16,105.14 192.16,106.53 193.09,107.46 193.09,108.33 195.64,110.88 195.64,112.37 199.79,116.51 199.79,116.95 200.71,117.87 203.9,117.87 204.37,118.33 205.73,118.33 208.68,121.29 210.75,121.29 212.21,122.75 213.04,122.75 213.43,123.15 213.79,123.15 214.76,124.12 216.25,124.12 216.92,124.79 218.48,124.79 218.75,125.06 220.62,125.06 221.74,123.95 222.5,123.95 222.71,123.74 222.71,123.19 224.58,121.33 225.97,121.33 226.33,120.98 226.61,120.98 v5(227.55,120.04) ; v3(231.96,127.08) 232.31,126.74 v1(232.31,126.25)
  GND1 w0.119: v4(227.88,119.62) 227.88,119.71 v5(227.55,120.04)
  IN2 w0.084: v4(231.15,127.26) 231.78,127.26 v3(231.96,127.08)
  IN3 w0.084: v4(231.15,127.26) 230.99,127.11 230.96,127.11 228.06,124.2 228.06,119.79 v4(227.88,119.62)
MEC_XTAL1: length 4.4
  TOP w0.152: U27.A1 236.06,126.75 236.28,126.53 237.06,126.53 C194.1 238.74,127.29 Y3.1
MEC_XTAL2: length 5.1
  TOP w0.152: U27.B1 235.38,126.75 236.04,127.41 237,127.41 237.74,128.15 C195.1 238.63,128.15 Y3.2
MEM_CONFIG0: length 33.4
  TOP w0.119: RH150.1 160.18,101.71 159.87,102.01 158.91,102.01 RH139.2 157.89,102.01 v2(157.89,102.5)
  IN2 w0.06: 141.23,108.72 140.87,108.72 140.11,107.96 139.91,107.96 139.27,107.32 138.62,107.32 138.51,107.43 137.57,107.43 136.17,106.03 135.85,106.03 135.4,106.48 134.19,106.48 134.08,106.37 133.74,106.37 133.29,106.82 133.12,106.82 132.89,107.04 v2(132.68,107.04)
  IN2 w0.084: 141.23,108.72 144.8,108.72 148.81,104.71 149.88,104.71 150.87,103.72 152.53,103.72 152.78,103.48 156.75,103.48 157.16,103.07 157.16,102.62 157.38,102.4 157.79,102.4 v2(157.89,102.5)
MEM_CONFIG1: length 33.9
  TOP w0.119: RH149.1 159.72,100.95 158.86,100.95 RH145.2 157.88,101.01 157.88,101.68 157.49,102.08 v2(157.49,102.73)
  IN2 w0.06: v2(133.42,107.37) 133.42,107.36 133.61,107.17 133.75,107.17 134.08,106.84 136.53,106.84 137.37,107.68 138.41,107.68 138.94,108.21 139.99,108.21 140.86,109.09 141.2,109.09
  IN2 w0.084: 141.2,109.09 141.74,109.09 142.25,109.6 143.83,109.6 143.97,109.73 144.7,109.73 145.03,109.4 145.03,109.01 145.74,108.31 146.59,108.31 146.97,107.92 146.97,107.65 147.15,107.48 147.66,107.48 150.31,104.83 150.31,104.54 150.95,103.91 152.61,103.91 152.86,103.66 156.95,103.66 157.49,103.13 v2(157.49,102.73)
MEM_CONFIG2: length 123.8
  TOP w0.119: v7(153.42,99.98) 153.93,100.49 RH144.1
  IN1 w0.089: v3(208.63,113.4) 208.74,113.4 209.91,114.57 210.01,114.57 212.88,117.45 214.95,117.45 216.57,119.06 222.4,119.06 223.26,118.19 225.15,118.19 225.45,117.89 228.85,117.89 v1(229.13,118.17)
  IN2 w0.06: 141.2,108.9 140.85,108.9 140.04,108.09 138.99,108.09 138.45,107.55 137.52,107.55 136.12,106.15 135.9,106.15 135.45,106.6 134.14,106.6 134.03,106.48 133.79,106.48 133.23,107.04 v2(133.17,107.04)
  IN2 w0.084: 141.2,108.9 144.88,108.9 145.66,108.12 146.51,108.12 146.79,107.85 146.79,107 148.59,105.19 148.98,105.19 v4(149.05,105.11) ; v3(208.63,113.4) 207.99,112.76 203.46,112.76 202.79,112.09 200.03,112.09 193.39,105.45 193.39,105.15 190.08,101.84 188.98,101.84 186.82,99.68 186.82,96.4 182.11,91.69 177.57,91.69 175.88,93.38 163.25,93.38 162.87,93.77 160.19,93.77 159.85,94.1 157.81,94.1 157.34,94.57 155.91,94.57 v4(155.56,94.93)
  GND4 w0.119: v4(149.05,105.11) 149.26,104.91 v9(149.43,104.91) ; v9(155.56,95.52) v4(155.56,94.93)
  BOTTOM w0.119: v9(149.43,104.91) 149.43,104.73 150.63,103.53 152.46,103.53 152.73,103.26 152.73,102.55 153.42,101.86 v7(153.42,99.98) 153.42,99.35 155.62,97.15 155.62,95.83 155.57,95.78 155.57,95.54 v9(155.56,95.52)
MEM_CONFIG3: length 12.3
  TOP w0.119: v1(138.54,106.69) 138.69,106.69 139.07,106.31 139.07,105.88 RH185.2 139.58,105.39 140.06,105.88 140.06,106.22 141.46,107.62 141.78,107.62 142.31,108.15 RH184.1
  IN1 w0.06: v1(133.17,105.76) 133.17,106.31 133.81,106.94 133.98,106.94 134.07,106.84 134.83,106.84 134.95,106.72 135.51,106.72 135.63,106.6 138.12,106.6 138.21,106.69 v1(138.54,106.69)
MIC1-VREFO_L: length 16.2
  TOP w0.203: UA1.38 30.51,14.69 30.87,14.33 30.87,14 v7(30.94,13.93)
  TOP w0.254: v7(20.59,14.54) 20.17,14.12 RA7.1
  IN3 w0.254: v7(20.59,14.54) 20.89,14.24 20.89,13.41 21.79,12.5 22.37,12.5 22.94,13.08 22.94,13.1 23.95,14.11 25.76,14.11 27.11,15.45 29.95,15.45 30.94,14.46 v7(30.94,13.93)
MIC1-VREFO_R: length 13.7
  TOP w0.203: v7(31.5,14.03) 31.5,14.05 31.17,14.38 31.17,14.46 30.91,14.72 UA1.39
  TOP w0.254: RA5.1 21.72,13.95 v7(21.77,13.9)
  IN3 w0.254: v7(21.77,13.9) 23.24,13.9 23.88,14.54 25.69,14.54 26.96,15.81 30.1,15.81 31.5,14.4 v7(31.5,14.03)
MIC1_L: length 7.7
  IN2 w1.016: 21.32,11.84 21.44,11.97 25.52,11.97 26.71,13.17 28.47,13.17
  vias: v7(19.56,12.68) v7(20.71,12.45) v7(29.67,14.11) v7(29.78,13.52)
MIC1_R: length 8.1
  IN2 w1.016: 22.71,13.75 23.3,14.33 25.18,14.33 26.32,15.48 30.03,15.48 30.08,15.43
  vias: v7(21.67,13.27) v7(22.18,12.96) v7(30.23,14.33) v7(30.41,13.72)
MONO_IN: length 4
  TOP w0.203: v2(25.08,18.01) 25.29,18.23 UA1.23
  IN2 w0.254: v2(25.08,18.01) 24.93,17.86 v2(22.07,17.86)
MOTOR_N1: length 2.1
  TOP w0.508: JVB1.2 29.76,6.01 R924.1
MOTOR_P1: length 322.5
  TOP w0.508: v1(117.76,80.55) 118.63,79.68 133.6,79.68 136.99,83.07 142.72,83.07 145.77,86.11 145.77,87.5 146.12,87.86 148.14,87.86 148.52,87.49 153.9,87.49 154.62,88.2 170.72,88.2 v10(173.11,85.81) ; JVB1.1 28.95,5.73 27.67,7.02 DH5.1 26.84,6.34 v7(26.85,6.33) ; v7(215.83,120.68) 216.26,120.25 220.1,120.25 Q330.1
  IN1 w0.508: v3(110.12,81.02) 110.83,81.02 111.3,80.55 v1(117.76,80.55) ; v7(215.83,120.68) 215.28,120.68 214.33,119.73 213.45,119.73 211.05,117.33 209.81,117.33 207.8,115.32 207.8,114.61 206.84,113.65 206.84,113.43 206.15,112.75 204.59,112.75 201.8,109.96 201.5,109.96 v7(200.77,109.23)
  GND1 w0.508: v4(173.11,85.43) v10(173.11,85.81)
  IN2 w0.508: v7(38.93,24.99) 38.67,24.99 35.29,21.61 27.41,21.61 26.09,20.29 26.09,17.31 24.72,15.94 23.01,15.94 22.13,15.06 20.97,15.06 20.81,15.22 18.22,15.22 16.39,13.39 v4(16.39,10.6) ; v3(110.12,81.02) v4(109,81.02)
  IN3 w0.508: v7(26.85,6.33) 26.14,5.62 18.9,5.62 16.39,8.14 v4(16.39,10.6) ; v6(44.56,82.46) 44.62,82.39 50.46,82.39 52.05,80.81 108.78,80.81 v4(109,81.02)
  GND4 w0.508: v9(173.67,85.43) v4(173.11,85.43)
  BOTTOM w0.508: v6(44.56,82.46) 44.16,82.86 44.13,82.86 42.98,84.01 39.16,84.01 34.75,79.6 34.75,71.67 39.45,66.98 39.45,48.23 39.62,48.06 39.62,25.67 v7(38.93,24.99) ; v9(173.67,85.43) 174.02,85.43 181.08,92.49 183.5,92.49 187.41,96.4 187.41,100.02 191.69,104.3 191.69,107.99 193.32,109.62 196.84,109.62 197.31,109.15 200.69,109.15 v7(200.77,109.23)
MUTI_ACIN_TAB: length 265.1
  TOP w0.119: U27.N11 229.5,121.75 v10(229.39,121.85)
  IN1 w0.089: v3(225.46,146.29) 225.08,145.91 215.89,145.91 214.02,144.04 212.41,144.04 212.21,143.84 207.74,143.84 205.82,145.76 203.16,145.76 202.45,146.47 196.79,146.47 196.52,146.74 189.58,146.74 189,146.16 189,138.22 188.42,137.65 180.9,137.65 179.7,136.46 179.7,135.93 178.93,135.16 174.44,135.16 173.59,136.01 173.08,136.01 171.81,137.27 162.67,137.27 162.39,136.99 159.66,136.99 159.37,136.7 156.58,136.7 156.46,136.57 155.12,136.57 153.64,135.09 149.85,135.09 149.16,135.78 146.78,135.78 146.39,136.16 144.12,136.16 143.61,135.65 142.23,135.65 141.48,134.9 141.48,133.21 139.87,131.59 138.29,131.59 138,131.29 138,130.53 137.36,129.88 136.98,129.88 136.79,130.08 136.79,131.21 135.48,132.52 132.24,132.52 131.3,133.46 131.3,136.94 130.12,138.12 104.34,138.12 103.19,136.97 102.75,136.97 102.37,137.35 101.18,137.35 100.6,137.93 91.22,137.93 90.84,138.32 81.45,138.32 80.89,137.76 79.47,137.76 78.6,138.63 78.6,142.35 77.98,142.98 67.5,142.98 66.55,142.03 66.55,141.82 65.4,140.67 62.03,140.67 59.08,143.63 52.98,143.63 50.56,146.05 49.27,146.05 48.79,145.57 48.79,144.77 48.55,144.53 48.23,144.53 46.63,142.93 43.45,142.93 41.55,141.04 41.14,141.04 40.54,140.44 40.54,127.09 v1(41.28,126.35)
  GND1 w0.119: v4(228.83,122.12) 229.1,121.85 v10(229.39,121.85)
  IN2 w0.084: v3(225.46,146.29) v4(225.46,145.68)
  IN3 w0.084: v4(225.46,145.68) 225.33,145.55 225.33,145.04 226.04,144.33 226.04,140.94 227.46,139.52 227.46,139.09 230.54,136.01 230.54,132.88 231.32,132.09 231.32,129.42 231.73,129.01 231.73,127.09 231.36,126.72 231.1,126.72 228.43,124.05 228.43,122.53 v4(228.83,122.12)
NB_MUTE#: length 326.6
  TOP w0.119: v1(38.93,27.6) 38.46,27.6 DA7.2
  IN1 w0.089: v7(185.38,86.18) 183.49,84.3 171.36,84.3 169.62,86.04 168.5,86.04 167.52,85.05 163.8,85.05 160.34,88.51 153.43,88.51 152.97,88.06 143.83,88.06 142.37,86.6 142.05,86.6 141.13,85.67 141.13,84.51 139.97,83.35 138.03,83.35 135.1,80.42 134.7,80.42 134.43,80.15 73.9,80.15 73.39,80.66 72.75,80.66 72.54,80.45 51.14,80.45 47.36,84.22 47.36,84.62 47.21,84.77 46.81,84.77 44.93,82.89 39.78,82.89 37.33,80.44 37.33,73.29 37.64,72.98 37.64,64.33 39.29,62.68 39.29,56.54 39.4,56.42 39.4,28.07 v1(38.93,27.6) ; v1(234.81,124.25) 235.04,124.02 235.68,124.02 235.89,124.23 236.59,124.23 237.06,124.7 237.53,124.7 237.72,124.89 237.72,125.47 237.56,125.64 237.33,125.64 236.95,126.02 236.95,126.46 237.16,126.67 238.03,126.67 238.77,125.93 240.44,125.93 241.1,126.59 243.53,126.59 245.42,124.7 245.42,117.92 244.31,116.81 242.53,116.81 240.61,114.89 240.61,112.96 240.19,112.54 236.87,112.54 236.58,112.83 234.01,112.83 232.96,113.88 218.31,113.88 218.16,113.73 218.16,111.69 217.84,111.36 217.84,110.96 216.88,110 212.05,110 211.1,110.95 210.78,110.95 206.84,107 206.84,106.17 206.56,105.89 204.24,105.89 v7(203.93,105.58)
  BOTTOM w0.119: v7(185.38,86.18) 185.38,93.44 188.55,96.62 188.55,100.47 192.1,104.02 192.1,107.82 193.49,109.21 196.5,109.21 197.08,108.62 198.74,108.62 200.84,106.51 202.59,106.51 202.85,106.26 203.26,106.26 v7(203.93,105.58)
Net_247:
  vias: v7(34.42,4.54) v7(34.46,2.61) v7(35.4,1.09) v7(35.45,6.08) v7(37.51,6.82) v7(39.27,0.91) v7(39.39,6.14) v7(40.49,4.64) v7(40.46,2.48)
NGFF1_CONFIG_0: length 284.9
  TOP w0.089: v1(27.8,101.84) JNGFF1.13
  TOP w0.119: U27.G13 232.54,120.48 232.54,120.09 231.76,119.3 v10(231.76,119.07)
  IN1 w0.089: v5(145.93,120.28) 146.11,120.45 149.41,120.45 150.57,119.3 160.08,119.3 161.32,120.53 163.18,120.53 163.83,119.88 164.05,119.88 164.5,119.43 164.5,115.92 164.83,115.59 164.83,114.98 166.62,113.19 167.42,113.19 168.88,111.74 168.88,111.45 169.9,110.42 170.49,110.42 171.91,109 173.35,109 173.85,108.5 175.83,108.5 176.06,108.27 176.63,108.27 177.06,108.69 177.84,108.69 178.58,109.43 185.02,109.43 186.52,110.93 186.52,115.53 188.51,117.52 188.51,119.35 189.72,120.56 190.57,120.56 191.68,121.67 191.68,122.74 195.03,126.09 197.19,126.09 197.61,126.51 197.61,126.73 198.54,127.66 201.32,127.66 201.46,127.8 202.52,127.8 203.41,128.68 204.44,128.68 206.18,130.42 206.74,130.42 211.43,135.11 211.43,135.33 212.65,136.55 218.25,136.55 218.84,135.96 223.98,135.96 224.58,136.56 227.83,136.56 228.85,135.54 229.45,135.54 230.09,134.89 230.09,134.52 230.74,133.87 231.86,133.87 232.18,133.55 232.18,132.61 232.61,132.18 233.27,132.18 v7(233.29,132.15) ; v1(27.8,101.84) 28.13,101.51 29.85,101.51 30.54,100.82 34.75,100.82 35.35,100.22 38.73,100.22 40.1,101.6 42.65,101.6 43.98,102.92 43.98,105.7 44.71,106.42 45.01,106.42 46.69,108.11 46.69,111.35 47.61,112.26 47.61,113.23 48.57,114.19 48.57,116.64 50.68,118.75 52.26,118.75 53.8,120.29 59.09,120.29 59.71,120.91 60.86,120.91 62.49,122.54 62.49,123.25 63.23,123.99 63.23,124.72 63.48,124.98 64.19,124.98 64.47,125.26 64.47,126.5 65.98,128.01 69.68,128.01 71.01,129.34 72.04,129.34 72.18,129.48 73.72,129.48 74.57,130.33 75.27,130.33 79.49,134.55 82.06,134.55 82.44,134.92 82.63,134.92 83.51,134.04 86.24,134.04 86.45,133.82 87.35,133.82 87.7,133.47 88.2,133.47 v5(88.2,133.48)
  GND1 w0.119: v5(145.93,120.28) 146.11,120.28 v4(146.28,120.45) ; v10(231.76,119.07) 231.85,119.16 v4(231.85,119.44) ; v4(88.53,133.71) 88.3,133.48 v5(88.2,133.48)
  GND3 w0.119: v4(88.53,133.71) 89.47,132.77 89.74,132.77 91.08,131.44 93.75,131.44 95.41,129.78 96.75,129.78 102.57,123.96 111.64,123.96 113.51,122.09 114.28,122.09 115.4,120.97 116.4,120.97 117.14,121.7 119.5,121.7 120.94,120.25 120.94,118.98 123.4,116.52 128.07,116.52 128.63,117.08 137.42,117.08 137.9,116.6 138.99,116.6 139.12,116.47 141.6,116.47 145.58,120.45 v4(146.28,120.45)
  IN3 w0.084: v4(231.85,119.44) 231.85,119.45 231.85,123.28 232.39,123.83 232.67,123.83 233.93,125.09 233.93,128.86 233.31,129.48 233.31,132.14 v7(233.29,132.15)
NGFF1_CONFIG_1: length 295.1
  TOP w0.089: JNGFF1.61 15.8,101.31 v2(15.94,101.17)
  TOP w0.119: R1045.2 228.23,119.63 228.85,120.26 v7(228.85,120.36) 228.85,120.66 229.23,121.04 229.51,121.04 U27.N13
  IN1 w0.089: v5(86.01,133.23) 85.75,132.98 84.94,132.98 84.72,133.2 83.6,133.2 83.47,133.07 82.99,133.07 82.65,133.4 81.54,133.4 81.29,133.65 79.49,133.65 74.75,128.91 72.41,128.91 71.91,128.41 70.89,128.41 69.84,127.36 67.78,127.36 66.71,126.28 65.49,126.28 65.04,125.84 65.04,124.99 63.11,123.05 63.11,122.34 61.08,120.32 59.94,120.32 59.34,119.72 54.16,119.72 51.98,117.53 50.45,117.53 49.2,116.29 49.2,113.69 48.85,113.33 48.85,112.61 47.26,111.03 47.26,107.87 45.24,105.85 44.94,105.85 44.55,105.46 44.55,102.68 42.87,101 40.32,101 38.97,99.64 35.03,99.64 34.49,100.19 26.87,100.19 26.66,100.39 26,100.39 25.55,99.94 20.5,99.94 v3(20.45,99.89) ; v3(231.17,130.34) 231.1,130.41 231.1,131.78 230.44,132.44 230.44,133.13 227.58,135.99 224.82,135.99 224.22,135.39 218.6,135.39 218.02,135.97 213.42,135.97 210.71,133.26 210.39,133.26 206.98,129.85 206.42,129.85 205.23,128.66 205.23,128.1 204.6,127.47 203.67,127.47 202.37,126.17 198.3,126.17 197.59,125.46 195.49,125.46 192.52,122.49 192.52,121.4 192.07,120.95 192.07,120.39 191.45,119.77 190.88,119.77 190.48,119.37 190.48,118.14 187.31,114.97 187.31,110.63 185.27,108.59 178.82,108.59 177.72,107.49 175.69,107.49 175.46,107.71 173.56,107.71 173.08,108.19 171.65,108.19 170.21,109.62 169.61,109.62 166.84,112.39 166.33,112.39 164.28,114.44 164.06,114.44 163.66,114.84 163.66,118.37 163.13,118.91 163.13,119.49 162.87,119.75 161.61,119.75 160.38,118.52 154.07,118.52 153.58,118.04 149.85,118.04 148.63,119.25 v3(148.63,119.77)
  GND1 w0.119: v4(86.24,133.61) 86.24,133.62 86.01,133.38 v5(86.01,133.23)
  IN2 w0.084: v4(230.77,130.44) 230.87,130.34 v3(231.17,130.34) ; v3(148.63,119.77) 148.36,120.05 v4(148.32,120.05) ; v2(15.94,101.17) 16.24,100.87 16.95,100.87 17.59,100.22 17.59,99.86 18.01,99.44 20,99.44 v3(20.45,99.89)
  GND3 w0.119: v4(148.32,120.05) 148.32,119.55 144.44,115.67 141.47,115.67 141.33,115.81 138.84,115.81 138.72,115.93 137.62,115.93 137.14,116.41 134.58,116.41 133.85,115.68 122.45,115.68 117.84,120.3 115.13,120.3 114.04,121.39 113.19,121.39 112.01,122.57 109.18,122.57 108.9,122.85 105.39,122.85 105.07,123.17 102.37,123.17 96.91,128.63 95.57,128.63 94.51,129.69 88.82,129.69 88.09,130.41 88.09,131.76 v4(86.24,133.61)
  IN3 w0.084: v7(228.85,120.36) 228.85,121.35 228.24,121.96 228.24,124.13 231.02,126.91 231.28,126.91 231.53,127.15 231.53,127.41 230.77,128.18 v4(230.77,130.44)
NGFF1_CONFIG_2: length 294.4
  TOP w0.089: JNGFF1.67 14.3,101.48 14.4,101.38 14.89,101.38 v2(15.56,100.71)
  IN1 w0.089: v10(232.81,122.25) 233.29,122.73 233.29,124.56 233.05,124.8 233.05,125.84 232.9,125.99 232.64,125.99 232.54,126.09 232.54,127.62 231.81,128.35 v3(231.32,128.35) ; v5(230.94,132.34) 230.63,132.66 230.63,133.21 227.66,136.18 224.74,136.18 224.14,135.58 218.68,135.58 218.1,136.16 213.35,136.16 210.63,133.45 210.31,133.45 206.9,130.04 206.34,130.04 205.04,128.74 205.04,128.18 204.52,127.66 203.59,127.66 202.29,126.36 198.19,126.36 197.49,125.66 195.15,125.66 192.13,122.64 192.13,121.57 190.01,119.45 190.01,118.42 186.92,115.34 186.92,110.8 185.12,109 178.69,109 178.19,108.5 177.57,107.89 175.9,107.89 175.67,108.12 173.69,108.12 173.19,108.62 171.76,108.62 170.36,110.02 169.77,110.02 168.34,111.45 168.34,111.73 167.26,112.81 166.46,112.81 164.45,114.82 164.45,115.43 164.07,115.81 164.07,118.5 163.53,119.04 163.53,119.65 163.05,120.13 161.45,120.13 160.24,118.92 153.92,118.92 153.47,118.46 150.09,118.46 149.24,119.3 149.24,119.72 148.89,120.07 147.83,120.07 147.63,119.87 v5(147.2,119.87) ; v3(20.43,100.27) 20.56,100.15 25.42,100.15 25.87,100.6 26.96,100.6 27.46,101.1 29.67,101.1 30.38,100.39 34.59,100.39 35.15,99.83 38.89,99.83 40.26,101.2 42.8,101.2 44.36,102.76 44.36,105.54 44.86,106.04 45.16,106.04 47.07,107.95 47.07,111.1 48.65,112.68 48.65,113.44 49.01,113.81 49.01,116.38 50.37,117.74 51.91,117.74 54.08,119.91 59.26,119.91 59.86,120.51 60.99,120.51 62.91,122.42 62.91,123.12 64.85,125.07 64.85,125.92 66.56,127.62 69.83,127.62 70.81,128.6 71.84,128.6 72.33,129.1 73.92,129.1 74.39,129.57 75.14,129.57 79.74,134.16 82.48,134.16 82.99,133.66 83.48,133.66 83.74,133.39 84.8,133.39 84.93,133.26 85.4,133.26 v3(85.71,133.57)
  GND1 w0.119: v10(232.81,122.25) 232.98,122.41 v4(232.98,122.86) ; v4(146.87,119.67) 147,119.67 v5(147.2,119.87) ; v4(230.97,131.94) 230.97,132.09 230.94,132.11 v5(230.94,132.34)
  IN2 w0.084: v4(231.2,128.91) 231.2,128.48 v3(231.32,128.35) ; v2(15.56,100.71) 15.64,100.78 15.64,101.29 15.82,101.47 16.08,101.47 16.5,101.05 17.03,101.05 17.78,100.3 17.78,99.94 18.09,99.63 19.78,99.63 v3(20.43,100.27) ; v3(85.71,133.57) 86.1,133.96 86.6,133.96 v4(86.63,133.93)
  GND3 w0.119: v4(86.63,133.93) 86.63,133.79 88.12,132.3 89.58,132.3 91.03,130.86 91.03,130.36 91.48,129.91 94.65,129.91 95.68,128.88 96.99,128.88 102.44,123.43 111.51,123.43 113.29,121.65 114.1,121.65 115.22,120.52 116.58,120.52 117.32,121.26 117.81,121.26 118.74,120.33 120.12,120.33 120.5,119.95 120.5,118.79 123.39,115.91 133.76,115.91 134.49,116.63 137.24,116.63 137.72,116.15 138.81,116.15 138.93,116.03 141.42,116.03 141.56,115.89 144.35,115.89 146.87,118.41 v4(146.87,119.67)
  IN3 w0.084: v4(230.97,131.94) 230.97,130.79 231.14,130.62 231.14,129.34 231.2,129.29 v4(231.2,128.91)
  GND4 w0.119: v4(232.98,122.86) 232.87,122.75 v9(232.87,122.47)
NGFF1_CONFIG_3: length 276.9
  TOP w0.119: v1(32.8,101.99) JNGFF1.1
  IN1 w0.089: v1(32.8,101.99) 33.18,101.99 33.92,101.25 34.99,101.25 35.63,100.62 38.51,100.62 39.87,101.98 42.5,101.98 43.6,103.08 43.6,105.85 44.67,106.92 44.67,107.13 46.31,108.78 46.31,111.68 47.15,112.52 47.15,113.45 48.11,114.42 48.11,116.73 50.54,119.16 52.13,119.16 53.72,120.75 58.77,120.75 60.38,122.36 61.03,122.36 62.5,123.83 62.5,124.72 63.43,125.65 63.43,127.43 64.37,128.37 66.78,128.37 66.85,128.31 69.71,128.31 71.31,129.91 73.88,129.91 74.49,130.52 75.2,130.52 79.41,134.74 81.67,134.74 82.42,135.49 82.69,135.49 82.91,135.26 82.91,134.9 83.59,134.23 86.32,134.23 86.39,134.16 88.17,134.16 v5(88.17,134.15) ; v5(229.37,122.97) 230.54,122.97 230.76,122.75 v2(230.81,122.75) ; v5(146.49,120.05) 146.62,120.18 147.67,120.18 147.76,120.26 149.34,120.26 150.49,119.11 160.16,119.11 161.38,120.33 163.11,120.33 163.73,119.71 163.73,119.11 164.26,118.58 164.26,115.89 164.64,115.51 164.64,114.9 166.54,113 167.34,113 168.61,111.73 168.61,111.44 169.82,110.23 170.41,110.23 171.83,108.81 173.27,108.81 173.77,108.31 175.75,108.31 175.98,108.08 176.71,108.08 177.13,108.5 177.92,108.5 178.62,109.2 185.06,109.2 186.71,110.85 186.71,115.45 188.7,117.45 188.7,119.27 189.8,120.37 190.65,120.37 191.87,121.59 191.87,122.66 195.08,125.87 197.26,125.87 197.8,126.4 197.8,126.6 198.67,127.47 201.4,127.47 201.54,127.61 202.69,127.61 202.93,127.85 204.44,127.85 204.85,128.26 204.85,128.82 206.26,130.23 206.82,130.23 210.23,133.64 210.55,133.64 213.27,136.36 218.17,136.36 218.76,135.77 224.06,135.77 224.66,136.37 227.73,136.37 228.76,135.35 229.37,135.35 229.9,134.81 229.9,134.44 230.66,133.68 231.77,133.68 231.98,133.46 231.98,131.88 v3(232.26,131.61)
  GND1 w0.119: v4(146.31,119.67) 146.49,119.85 v5(146.49,120.05) ; v4(87.83,133.71) 87.83,133.79 88.12,134.08 88.12,134.1 v5(88.17,134.15) ; v4(229.75,123.1) 229.62,122.97 v5(229.37,122.97)
  IN2 w0.084: v3(232.26,131.61) v4(232.57,131.3)
  GND3 w0.119: v4(87.83,133.71) 88.99,132.55 89.65,132.55 91.25,130.95 91.25,130.45 91.52,130.18 94.7,130.18 95.32,129.55 96.65,129.55 102.55,123.66 111.61,123.66 113.4,121.87 114.19,121.87 115.31,120.74 116.49,120.74 117.23,121.48 119.41,121.48 120.72,120.16 120.72,118.89 123.31,116.3 128.16,116.3 128.72,116.85 137.33,116.85 137.81,116.38 138.9,116.38 139.02,116.25 141.51,116.25 141.66,116.11 144.25,116.11 146.31,118.17 v4(146.31,119.67)
  IN3 w0.076: 232.85,127.54 232.85,131.02 v4(232.57,131.3)
  IN3 w0.084: 232.85,127.54 232.85,127.16 231.75,126.06 231.75,124.8 230.18,123.24 229.89,123.24 v4(229.75,123.1)
  GND4 w0.119: v4(229.75,123.1) 229.95,122.89 v6(230.12,122.89)
NGFF_COEX1: length 286.8
  TOP w0.119: JNGFF1.56 17.05,104.32 17.94,103.43 22.98,103.43 23.55,104 v1(23.55,104.05)
  IN1 w0.089: v8(117.63,135.82) 116.26,137.19 106.72,137.19 106.14,136.61 105.42,136.61 104.97,136.16 102.51,136.16 102.06,136.61 100.87,136.61 100.29,137.2 90.92,137.2 90.78,137.34 89.08,137.34 88.77,137.03 85.7,137.03 85.38,137.34 81.52,137.34 81.2,137.02 78.46,137.02 77.27,135.82 77.27,135.21 74.44,132.39 73.6,132.39 73.31,132.1 70.14,132.1 69.65,131.61 66.52,131.61 66.01,131.1 66.01,130.49 65.75,130.23 63.6,130.23 60.91,127.54 60.91,125.9 60.59,125.58 60.59,125.19 59.04,123.64 56.5,123.64 55.98,124.17 55.59,124.17 55.14,123.71 52.9,123.71 52.65,123.46 50.22,123.46 46.2,119.44 46.2,115.6 45.72,115.12 44.99,115.12 43.99,114.12 43.99,112.17 43.03,111.22 41.06,111.22 38.76,108.92 38,108.92 37.34,108.26 37.34,107.96 35.74,106.35 35.74,105.44 35.08,104.78 34.19,104.78 33.22,103.82 23.78,103.82 v1(23.55,104.05) ; v5(145.26,132.35) 145.35,132.44 148.51,132.44 149.47,133.41 153.93,133.41 154.35,133.83 159.36,133.83 160.01,134.48 162.46,134.48 163.82,135.85 168.47,135.85 168.8,135.52 171.71,135.52 172.53,134.7 173.04,134.7 173.89,133.85 179.54,133.85 181.2,135.51 182.03,136.34 189.11,136.34 190.37,137.6 192.13,137.6 192.86,138.34 195.08,138.34 196.34,137.08 199.26,137.08 199.52,136.82 201.5,136.82 204.3,139.61 204.3,139.82 205.45,140.97 205.74,140.97 207.45,142.68 212.48,142.68 212.87,142.29 213.11,142.29 213.19,142.21 215.42,142.21 216.31,143.1 219.31,143.1 220.5,144.29 225.32,144.29 226.07,143.54 226.88,143.54 228.26,142.17 229.68,142.17 231.14,140.7 233.15,140.7 234.12,139.73 234.77,139.73 235.23,139.28 236.19,139.28 238.56,136.91 239.22,136.91 241.8,134.33 241.8,132.5 242.43,131.87 242.98,131.87 245.3,129.55 245.3,128.94 247.83,126.4 247.83,120.73 JNGFF3.40
  GND1 w0.119: v8(117.63,135.82) 117.66,135.8 117.66,135.54 v4(117.89,135.31) ; v4(145.01,133.03) 145.19,132.85 145.19,132.41 145.25,132.35 v5(145.26,132.35)
  GND3 w0.119: v4(145.01,133.03) 143.85,133.03 143.26,132.44 143.26,131.98 143.45,131.79 144.21,131.79 144.46,131.53 144.46,130.98 143.87,130.38 141.47,130.38 140.38,129.29 139.27,129.29 139.01,129.04 138.12,129.04 137.87,129.29 133.12,129.29 132.62,129.79 128.92,129.79 127.22,131.49 127.22,132.6 125.27,134.55 123.31,134.55 122.5,135.36 120.28,135.36 119.66,134.74 118.47,134.74 v4(117.89,135.31)
NGFF_COEX2: length 287.3
  TOP w0.076: JNGFF1.54 17.55,104.13 17.63,104.05
  TOP w0.119: v1(22.59,104) 22.24,103.65 18.03,103.65 17.63,104.05
  IN1 w0.076: JNGFF3.38 248.18,119.62
  IN1 w0.089: 248.18,119.62 247.64,120.16 247.64,126.33 245.11,128.86 245.11,129.47 242.9,131.68 242.35,131.68 241.61,132.42 241.61,134.25 239.14,136.72 238.48,136.72 236.11,139.09 235.15,139.09 234.69,139.54 234.04,139.54 233.07,140.51 231.06,140.51 230.16,141.41 228.39,141.41 227.6,142.2 227.1,142.2 225.2,144.1 221.28,144.1 220.08,142.91 216.39,142.91 215.5,142.02 213.11,142.02 213.03,142.1 212.79,142.1 212.4,142.49 207.56,142.49 205.85,140.78 205.52,140.78 204.49,139.74 204.49,139.53 201.58,136.63 199.44,136.63 199.18,136.89 196.26,136.89 195,138.15 192.94,138.15 192.21,137.41 190.49,137.41 189.11,136.03 186.52,136.03 186.26,135.77 185.65,135.77 185.27,136.15 182.11,136.15 179.62,133.66 173.3,133.66 171.63,135.33 168.72,135.33 168.39,135.66 163.93,135.66 162.46,134.2 161.69,134.2 161.31,133.82 160.15,133.82 159.97,133.64 154.43,133.64 153.98,133.18 149.55,133.18 148.62,132.25 145.74,132.25 145.55,132.06 144.99,132.06 v5(144.98,132.08) ; v8(116.73,134.88) 116.73,134.93 116.16,135.5 114.45,135.5 113.59,136.36 110.5,136.36 110.43,136.42 105.5,136.42 105.05,135.97 102.43,135.97 101.98,136.42 100.79,136.42 100.21,137.01 90.84,137.01 90.7,137.15 89.16,137.15 88.85,136.84 85.62,136.84 85.31,137.15 81.59,137.15 81.28,136.83 78.54,136.83 77.46,135.74 77.46,135.13 74.52,132.2 73.68,132.2 73.39,131.91 70.22,131.91 69.51,131.2 66.93,131.2 66.73,131 66.73,130.45 66.32,130.04 63.68,130.04 61.1,127.46 61.1,125.82 60.82,125.54 60.82,125.15 59.11,123.44 56.44,123.44 55.9,123.98 55.67,123.98 55.13,123.44 52.9,123.44 52.7,123.24 50.27,123.24 46.39,119.36 46.39,115.52 45.8,114.93 45.07,114.93 44.18,114.05 44.18,112.09 43.11,111.03 41.13,111.03 38.84,108.73 38.11,108.73 37.56,108.17 37.56,107.9 35.93,106.27 35.93,105.36 35.44,104.87 35.44,103.57 34.86,102.99 33.82,102.99 33.19,103.63 22.96,103.63 v1(22.59,104)
  GND1 w0.119: v5(144.98,132.08) 144.7,132.35 144.7,132.49 144.68,132.51 v4(144.68,132.57) ; v8(116.73,134.88) 116.9,134.88 v4(117.33,135.31)
  GND3 w0.119: v4(117.33,135.31) 118.13,134.52 119.75,134.52 120.37,135.14 122.41,135.14 123.22,134.33 125.18,134.33 127,132.5 127,131.39 128.82,129.57 132.53,129.57 133.03,129.07 137.78,129.07 138.03,128.82 139.11,128.82 139.36,129.07 140.47,129.07 141.57,130.16 143.96,130.16 144.68,130.88 v4(144.68,132.57)
NGFF_COEX3: length 283
  TOP w0.119: v1(21.44,103.94) 21.37,103.87 18.59,103.87 JNGFF1.52
  IN1 w0.089: v1(21.44,103.94) 21.72,103.94 22.23,103.44 33.11,103.44 33.74,102.8 34.94,102.8 35.63,103.49 35.63,104.79 36.28,105.44 36.99,105.44 37.75,106.21 37.75,106.79 37.98,107.02 37.98,108.29 38.23,108.54 38.91,108.54 41.21,110.83 43.19,110.83 44.37,112.01 44.37,113.97 45.15,114.74 45.88,114.74 46.58,115.44 46.58,119.28 49.29,121.99 50.35,123.05 52.78,123.05 52.98,123.25 59.19,123.25 61.03,125.09 61.03,125.47 61.96,126.41 61.96,128.04 63.76,129.85 67.91,129.85 68.23,130.16 69.42,130.16 70.38,131.13 70.38,131.23 70.87,131.72 73.47,131.72 73.76,132.01 74.6,132.01 78.8,136.21 79.99,136.21 80.42,136.64 81.36,136.64 81.67,136.96 83.59,136.96 84.62,135.93 92.05,135.93 92.93,136.82 100.13,136.82 100.71,136.23 101.91,136.23 102.35,135.78 105.13,135.78 105.58,136.23 110.35,136.23 110.42,136.16 112.97,136.16 113.82,135.31 115.58,135.31 115.74,135.15 v8(116.03,135.15) ; JNGFF3.36 248.33,119.12 247.45,120 247.45,126.25 244.91,128.79 244.91,129.4 242.82,131.49 242.27,131.49 241.42,132.34 241.42,132.6 239.29,134.73 239.29,136.25 239.01,136.53 238.4,136.53 236.04,138.9 235.07,138.9 234.61,139.35 233.96,139.35 232.99,140.32 230.99,140.32 230.08,141.22 228.31,141.22 227.53,141.99 218.95,141.99 218.46,141.5 217.38,141.5 216.8,142.08 216.2,142.08 215.94,141.83 213.03,141.83 212.95,141.91 212.72,141.91 212.32,142.3 207.68,142.3 205.96,140.59 205.6,140.59 204.68,139.66 204.68,139.46 201.66,136.44 199.37,136.44 199.11,136.7 196.18,136.7 195.45,137.42 192.54,137.42 192.34,137.22 190.57,137.22 189.19,135.83 186.67,135.83 186.39,135.56 185.6,135.56 185.19,135.96 182.19,135.96 179.7,133.47 173.22,133.47 171.55,135.14 168.64,135.14 168.31,135.47 164.13,135.47 162.22,133.56 161.5,133.56 161.44,133.63 160.23,133.63 159.51,132.91 156.2,132.91 155.97,133.14 154.22,133.14 154.01,132.94 149.61,132.94 148.63,131.96 v5(146.62,131.96)
  GND1 w0.119: v8(116.03,135.15) 116.33,135.15 v4(116.52,135.34) ; v4(146.62,132.49) v5(146.62,131.96)
  GND3 w0.119: v4(146.62,132.49) 146.11,132.49 144.91,131.29 144.91,130.79 144.06,129.94 141.66,129.94 140.56,128.85 139.45,128.85 139.2,128.6 137.94,128.6 137.69,128.85 133.23,128.85 133.03,128.65 129.42,128.65 126.78,131.29 126.78,132.41 125.09,134.1 123.13,134.1 122.33,134.91 120.45,134.91 119.84,134.29 117.83,134.29 116.79,135.34 v4(116.52,135.34)
NGFF_WWAN_PWREN: length 188
  TOP w0.119: v1(42.16,84.63) 41.26,84.63 40.6,85.29 40.6,86.69 39.85,87.43 37.7,87.43 36.86,88.28 D11.2
  IN1 w0.06: 139.81,113.81 139.69,113.81 139.54,113.66 139,113.66 137.95,112.6 135.94,112.6 135.77,112.43 135.33,112.43 135.18,112.58 134.89,112.58 134.56,112.25 v1(134.56,112.22)
  IN1 w0.089: v1(42.16,84.63) 42.32,84.79 43.28,84.79 45.56,87.07 45.56,91.67 46.24,92.36 49.53,92.36 49.99,91.9 49.99,88.8 51.49,87.31 56.5,87.31 56.7,87.1 63.43,87.1 63.88,87.56 90.1,87.56 94.48,91.94 94.48,96.2 94.89,96.61 94.89,97.84 97.22,100.17 97.22,104.8 98.04,105.61 98.04,110.77 98.48,111.21 98.48,119.04 102.48,123.04 102.48,125.37 102.96,125.85 103.09,125.85 v5(103.32,126.08) ; v5(147.22,113.08) 147.22,113.09 146.84,113.47 146.15,113.47 145.4,114.21 145.28,114.21 144.39,115.11 143.86,115.11 143.31,114.56 142.25,114.56 141.8,114.11 141.55,114.11 141.43,114.23 140.69,114.23 140.27,113.81 139.81,113.81
  GND1 w0.119: v5(147.22,113.08) 147.24,113.08 v4(147.5,112.81) ; v4(103.26,126.67) 103.26,126.14 v5(103.32,126.08)
  GND3 w0.119: v4(146.82,121.04) 146.64,121.22 145.23,121.22 144.75,120.73 140.63,120.73 139.31,119.41 135.92,119.41 135.54,119.79 127.2,119.79 126.12,118.71 125.03,118.71 123.16,120.59 122.89,120.59 119.89,123.59 118.84,123.59 117.61,124.82 113.75,124.82 111.79,126.78 107.22,126.78 106.86,126.42 103.47,126.42 103.26,126.64 v4(103.26,126.67)
  IN3 w0.084: v4(147.5,112.81) 147.68,112.99 147.68,117.49 147.4,117.77 147.4,119.06 147.24,119.22 147.24,120.19 146.79,120.63 146.79,121.01 v4(146.82,121.04)
NTC_REF: length 32.5
  TOP w0.254: v10(183.17,134.91) 183.27,135.01 183.29,135.01 PR741.1 183.95,135.67 PC718.1
  GND1 w0.254: v10(183.17,134.91) 183.21,134.86 183.21,134.74 v4(183.37,134.58)
  IN2 w0.06: 170.36,125.18 169.63,124.44 169.63,124.34 169.19,123.9 v2(169.19,123.2)
  IN2 w0.254: v4(170.49,125.33) 170.49,125.31 170.36,125.18
  IN3 w0.254: v4(183.37,134.58) 183.37,132.17 184.28,131.25 185.07,131.25 186.57,129.75 186.57,126.53 185.2,125.15 180.12,125.15 180,125.27 178.35,125.27 177.78,125.84 175.95,125.84 175.39,126.4 171.18,126.4 170.49,125.71 v4(170.49,125.33)
OSC_IN: length 5.3
  TOP w0.14: U16.B1 196.03,141.7 196.64,142.31 C113.1 R65.1 197.08,141.38 197.73,140.74 198.29,140.74 Y1.1
OSC_OUT: length 6.8
  TOP w0.14: U16.A1 196.35,141.3 R65.2 197.08,140.18 C114.1 197.75,139.67 198.57,140.5 199.87,140.5 Y1.3
OUT1_CA_DET: length 2.8
  TOP w0.119: U23.43 55.43,87.43 56.24,86.62 R67.1
OUT2_CA_DET: length 2.8
  TOP w0.119: R106.1 50.29,86.55 51.43,87.69 U23.33
P_AGND: length 76.4
  TOP w0.127: PU500.E5 166.79,125.2 v1(166.79,125.6) ; PU500.G12 v10(169.59,124.4)
  TOP w0.254: PC633.2 163.66,132.13 v7(163.66,131.81) ; PU500.E11 v10(169.59,124.4) ; PU500.E11 v10(169.19,124.8) ; PU500.E11 PU500.E12 ; v1(169.99,121.6) PU500.P12 169.99,121.08 170.23,120.83 170.97,120.83 171.1,120.96 171.1,120.98 171.14,121.03 171.14,121.42 171.33,121.61 172.68,121.61 PC710.2 ; PU500.G13 PU500.G12 ; v2(167.62,128.35) 167.14,128.84 PR515.2 ; PU500.C7 v1(168.39,125.6) v1(168.39,125.2) PU500.E8 PU500.E7 PU500.E6 PU500.E5 v1(167.19,124.4) v2(167.19,124) PU500.H5 ; PR718.2 v2(161.94,127.03) ; v10(186.47,134.6) 185.48,135.59 PC718.2 ; PU500.N3 v10(166.39,121.2)
  TOP w0.305: PC707.2 162.39,127.83 161.94,127.39 v2(161.94,127.03)
  TOP w0.508: PR608.2 162.36,128.96 PC704.2 PC707.2 ; PC717.1 175.72,118.16 v10(175.72,118.91) PR520.2 ; v7(162.35,119.34) 161.96,119.73 PC702.2 ; v10(172.6,116.48) PR518.1
  IN1 w0.06: 165.28,126.98 165.56,126.71 165.69,126.71 165.79,126.61 165.79,126.27 165.87,126.2 166.55,126.2 166.72,126.03 166.72,125.67 v1(166.79,125.6) ; 169.4,123 169.59,123.19 v1(169.59,123.2) ; 169.4,123 168.99,123 v2(168.79,123.2) ; 169.4,123 169.39,122.99 169.39,122.48 169.39,122.48 169.39,122.31 169.39,122.31 169.39,122.27 169.46,122.2 169.67,122.2 169.79,122.08 169.79,121.87 169.99,121.67 v1(169.99,121.6) ; v1(168.39,125.2) v1(168.39,125.6) ; v10(169.59,124.4) 169.39,124.2 167.49,124.2 167.29,124.4 v1(167.19,124.4)
  IN1 w0.254: 165.28,126.98 165.11,127.16 165.11,127.77 v3(164.95,127.92)
  GND1 w0.254: v10(166.39,121.2) 166.39,120.99 v4(166.54,120.84) ; v10(169.19,124.8) 169.16,124.82 168.56,124.82 v4(168.48,124.75) ; v4(166.82,123.81) 167.01,124 v2(167.19,124) ; v10(186.47,134.6) 186.77,134.6 v4(186.95,134.78)
  GND1 w0.508: v10(172.6,116.48) 172.65,116.43 173.81,116.43 v4(174.12,116.75) ; v4(160.48,124.24) 160.19,123.95 v10(159.94,123.95) ; v10(166.11,116.57) 166.06,116.52 165.67,116.52 v4(165.59,116.59) ; v10(175.72,118.91) 176.09,118.91 176.33,119.15 v4(176.33,119.16)
  IN2 w0.06: v2(168.79,123.2) 168.57,123.41 168.17,123.41 168.12,123.37 167.93,123.37 167.8,123.5 167.8,123.5 167.79,123.52 167.79,123.68 167.67,123.8 167.39,123.8 v2(167.19,124)
  IN2 w0.254: v4(166.82,123.81) 166.82,123.54 166.48,123.2 v2(166.39,123.2) ; v2(161.94,127.03) 162.33,127.41 162.52,127.41 163.23,128.13 v4(163.58,128.13) 164.75,128.13 v3(164.95,127.92) 165.29,128.26 167.53,128.26 v2(167.62,128.35)
  IN3 w0.254: v4(163.58,128.13) 163.61,128.15 163.61,131.76 v7(163.66,131.81) 163.66,133.46 164.75,134.55 168.3,134.55 168.84,135.09 171.7,135.09 173.4,133.38 176.72,133.38 176.96,133.62 178.4,133.62 180.65,135.87 184.36,135.87 185.46,134.78 v4(186.95,134.78)
  vias: v7(176.96,120.23)
P_AGND_1: length 73.5
  TOP w0.254: PC808.2 67.11,108.24 PC800.2 v10(68.1,109.13) ; PU800.K7 70.41,109.94 69.91,109.94 v2(69.7,110.14) 69.91,110.35 PU800.K6 PU800.J6
  TOP w0.305: v10(69.48,101.51) 69.46,101.51 69.09,101.14 PC1009.2
  TOP w0.508: PR818.1 66.02,113.39 PR915.2 ; PR831.2 67.05,116.92 v10(67.05,116.31) ; PR1014.2 67.62,102.01 v1(67.18,101.57) PR820.2 67.18,100.2 67.32,100.06 v7(67.32,99.93) ; PH1001.2 78.8,102.04 v7(78.8,102.75) ; PC909.2 68.94,117.11 v10(68.95,117.13) ; PC812.2 78.76,117.27 v7(78.78,117.29) ; v7(71.96,103.74) 71.99,103.77 PR1026.2 71.86,104.61 PR1025.2 ; PH1002.2 87.81,116.09 87.28,115.55 87.18,115.55 v7(86.93,115.3) ; PR1015.2 PR1027.2 v7(73.89,103.78) ; PR1019.2 69.96,103.74 PR1029.1 69.95,103.5 70.35,103.09 v7(70.64,103.09) ; v7(74.28,119.36) 72.14,119.36 71.66,118.88 PC907.2 ; PH1003.2 88.83,104.38 v7(88.8,104.35)
  IN1 w0.508: v7(78.78,117.29) 81.82,114.26 85.97,114.26 86.93,115.22 v7(86.93,115.3) ; v7(88.8,104.35) 88.8,104.88 87.81,105.88 86.32,105.88 86.14,105.7 83.62,105.7 82.28,104.35 80.4,104.35 v7(78.8,102.75) 78.77,102.75 78.01,103.51 74.16,103.51 v7(73.89,103.78) ; v1(65.31,106.72) 65.31,103.68 67.18,101.81 v1(67.18,101.57)
  GND1 w0.254: v4(72.23,112.71) 72.23,112.7 72.02,112.49 v10(72.02,112.35) ; v4(68.99,102.07) 69.02,102.04 69.02,101.96 v10(69.48,101.51) ; v10(75.23,116.82) 75.23,117.24 v4(75.24,117.25) ; v4(69.6,106.22) 69.77,106.38 v10(69.96,106.38) ; v10(68.1,109.13) 68.43,108.8 v4(68.47,108.8) ; v10(71.67,114.79) 71.38,114.79 v4(71.23,114.64) ; v10(66.2,113.44) 66.38,113.27 66.38,113.24 v4(66.52,113.1)
  GND1 w0.508: v10(67.05,116.31) 67.14,116.31 v4(67.86,117.04) ; v10(68.1,103.79) 68.1,104.2 v4(68.08,104.22) ; v10(68.95,117.13) v4(68.95,117.7)
  IN2 w0.06: v2(72.82,109.55) 72.62,109.75 72.62,110.49 72.36,110.75 v2(72.02,110.75)
  IN2 w0.254: v7(73.89,103.78) 73.89,104.25 73.36,104.78 73.36,107.48 73.11,107.73 73.11,108.77 72.82,109.06 v2(72.82,109.55) v2(73.23,109.55) ; v4(69.27,109.74) 69.32,109.74 69.7,110.12 v2(69.7,110.14)
  IN3 w0.254: v4(66.52,113.1) 66.52,112.19 67.42,111.29 68.05,111.29
P_SYS: length 277.6
  TOP w0.089: PR815.1 65.12,108.22 v2(64.67,108.67)
  TOP w0.119: U27.M1 229.09,127.97 C267.1 228.87,128.39 228.63,128.63 228.63,129.12 228.86,129.34 229.22,129.34 229.88,130.01 229.88,130.26 v2(230.22,130.6)
  IN2 w0.084: v4(160.27,134.49) 160.39,134.62 163.32,134.62 163.7,135 172.44,135 173.13,134.3 179.96,134.3 180.68,135.03 184.03,135.03 184.2,135.2 186.08,135.2 186.59,135.7 189.13,135.7 190.02,136.59 190.02,138.98 189.69,139.31 189.69,141.66 192.59,144.56 201.38,144.56 201.57,144.75 203.91,144.75 204.86,143.8 214.84,143.8 215.27,143.37 219.97,143.37 221.28,142.05 227.47,142.05 228.54,140.98 228.54,134.89 229.31,134.12 229.31,131.29 230,130.6 v2(230.22,130.6) ; v2(50.2,128.81) 50.76,129.37 v4(51.31,129.37) ; v2(64.67,108.67) 62.44,108.67 61.45,107.68 61.45,106.74 62.36,105.82 62.36,101.94 61.62,101.19 52.09,101.19 51.92,101.37 46.91,101.37 46.39,101.89 46.39,102.87 v4(45.94,103.31)
  GND3 w0.119: v4(118.4,135.33) 118.77,134.96 119.51,134.96 120.22,135.67 122.5,135.67 123.4,134.77 125.42,134.77 127.51,132.68 127.51,131.51 129.01,130.01 140.43,130.01 143.82,133.41 147.57,133.41 148.5,134.34 156.75,134.34 156.96,134.55 158.93,134.55 159.24,134.23 159.54,134.23 159.58,134.27 160.05,134.27 v4(160.27,134.49)
  IN3 w0.084: v4(118.4,135.33) 117.93,135.8 116.14,135.8 116,135.66 115.34,135.66 114.02,136.98 103.21,136.98 102.41,136.18 97.84,136.18 97.27,135.61 95.55,135.61 95.36,135.8 90.19,135.8 90.12,135.87 86.23,135.87 84.91,134.55 77.26,134.55 75.28,132.58 58.52,132.58 56.99,131.05 52.99,131.05 v4(51.31,129.37) 50.84,128.9 50.84,124.43 52.23,123.05 52.23,120.96 50.17,118.91 50.17,110.86 50.95,110.08 50.95,103.76 50.54,103.35 47.52,103.35 47.2,103.67 46.3,103.67 v4(45.94,103.31)
PA_USB2_RBIAS: length 2.1
  TOP w0.102: v7(23.62,38.92) 23.3,38.6 UT1.H19
  BOTTOM w0.127: R1392.2 23.16,39.71 23.16,39.38 v7(23.62,38.92)
PANEL_BKEN_EC: length 87.7
  TOP w0.119: D2.3 176.19,104.34 176.59,104.74 177.42,104.74 177.87,105.19 178.31,105.19 179.23,106.1 179.23,106.74 179.33,106.84 179.99,106.84 v7(180.02,106.87)
  IN1 w0.089: v1(233.31,126.25) 233.31,128.08 234.19,128.96 v3(234.37,128.96)
  IN2 w0.084: v4(231.13,119.93) 231.48,119.59 231.48,119.32 231.71,119.1 233.65,119.1 234.8,120.25 234.8,120.82 235.27,121.29 235.27,122.28 235.82,122.83 235.82,123.94 235.93,124.06 235.93,124.63 236.38,125.08 236.51,125.08 236.84,125.41 236.84,125.78 236.2,126.42 236.2,127.33 234.56,128.96 v3(234.37,128.96)
  IN3 w0.084: v7(180.02,106.87) 180.52,107.37 185.35,107.37 185.73,106.99 185.73,103.98 186.93,102.78 189.46,102.78 192.07,105.39 192.07,107.34 195.79,111.06 198.42,111.06 198.65,111.28 205.67,111.28 206,111.62 211.95,111.62 214.21,113.87 215.14,113.87 218.06,116.79 219.62,116.79 221.49,118.66 227.65,118.66 227.98,118.33 229.27,118.33 230.14,119.21 230.41,119.21 v4(231.13,119.93)
PB_USB2_RBIAS: length 1.8
  TOP w0.102: UT1.F19 v7(22.98,38.91)
  BOTTOM w0.127: R1393.2 22.78,40.09 22.78,39.12 v7(22.98,38.91)
PBAT_PRES#: length 167.9
  TOP w0.119: v10(161.5,96.58) 162.34,96.58 PR120.1
  GND1 w0.119: v10(161.5,96.58) 161.35,96.73 160.48,96.73 v4(160.23,96.48)
  IN2 w0.084: v2(50.2,125.26) 51.12,125.26 v4(51.52,125.65) ; v4(98.53,135.15) 98.53,135.4 98.11,135.82 89.97,135.82 89.04,134.89 87.92,134.89 87.52,135.29 85.16,135.29 84.88,135.56 83.43,135.56 83.11,135.25 82.25,135.25 81.42,134.41 79.61,134.41 v4(77.62,132.42)
  GND3 w0.119: v4(157.32,129.04) 157.11,128.84 154.74,128.84 152.77,130.8 151.38,130.8 151.07,131.11 150.34,131.11 150.09,130.86 150.09,129.01 149.28,128.2 147.92,128.2 145.76,126.04 143.86,126.04 143.04,125.23 141.47,125.23 140.46,126.24 138.88,126.24 138.09,127.02 136.2,127.02 135.48,126.3 128.03,126.3 123.28,131.05 120.61,131.05 119.91,131.75 117.55,131.75 117.04,132.26 110.46,132.26 109.86,132.86 106.75,132.86 106.22,133.4 101.71,133.4 101.16,133.95 100.6,133.95 99.3,135.25 98.63,135.25 v4(98.53,135.15)
  IN3 w0.084: v4(51.52,125.65) 51.52,125.7 52.2,126.39 52.2,128.47 53.71,129.97 57.26,129.97 58.93,131.64 76.84,131.64 v4(77.62,132.42) ; v6(158.65,104.3) 159.14,104.3 159.4,104.57 159.4,106.84 160.08,107.52 160.08,113.34 159.92,113.5 159.92,119.18 159.42,119.68 159.42,125.87 158.71,126.58 158.71,128.66 157.97,129.39 157.66,129.39 v4(157.32,129.04)
  GND4 w0.119: v4(160.23,96.48) 159.87,96.83 v9(159.87,96.86)
  BOTTOM w0.119: v9(159.87,96.86) 159.87,97.94 164.2,102.26 164.2,103.66 163.56,104.3 v6(158.65,104.3)
PBAT_SMBCLK: length 113.3
  TOP w0.119: v1(164.17,90.46) 163.91,90.71 163.91,93.02 163.56,93.38 162.96,93.38 162.53,93.8 162.53,94.71 163.07,95.24 163.07,97.07 162.86,97.27 159.4,97.27 PR121.2
  IN1 w0.089: v1(164.17,90.46) 164.65,90.46 165.31,89.8 166.49,88.62 166.85,88.62 167.24,88.24 171.7,88.24 171.85,88.38 187.94,88.38 189.22,89.65 194.98,89.65 195.21,89.89 199.43,89.89 199.56,90.02 199.56,102.44 199.19,102.81 199.19,104.67 202.45,107.93 205.04,107.93 210.22,113.11 210.47,113.11 213.65,116.29 215.41,116.29 215.97,116.84 216.93,116.84 217.59,117.5 222.28,117.5 222.73,117.05 224.45,117.05 225,116.51 v7(225,116.33)
  GND1 w0.119: v10(234.81,123.75) 234.81,123.84 v4(234.5,124.15)
  IN3 w0.084: v4(234.5,124.15) 234.5,123.56 235.13,122.92 235.13,120.3 232.72,117.89 232.72,117.34 232.21,116.84 225.42,116.84 225,116.42 v7(225,116.33)
  GND4 w0.119: v9(234.87,123.78) 234.86,123.78 v4(234.5,124.15)
PBAT_SMBDAT: length 111.9
  TOP w0.119: v1(164.09,90.1) 163.68,90.51 163.68,92.87 163.43,93.12 162.9,93.12 162.31,93.71 162.31,94.8 162.84,95.33 162.84,96.98 162.77,97.05 160.07,97.05 PR122.2
  IN1 w0.089: v1(164.09,90.1) 164.74,90.1 165.23,89.61 166.41,88.43 166.77,88.43 167.16,88.04 171.78,88.04 171.93,88.19 188.02,88.19 189.3,89.46 195.24,89.46 195.48,89.7 199.51,89.7 199.79,89.98 199.79,102.48 199.38,102.89 199.38,104.6 202.52,107.73 205.96,107.73 211.2,112.96 211.2,113.57 213.73,116.1 215.49,116.1 216.05,116.65 217.01,116.65 217.67,117.31 222.2,117.31 222.74,116.77 223.53,116.77 v5(224.02,116.28)
  GND1 w0.119: v10(234.31,123.75) 234.25,123.75 v4(233.96,124.04) ; v4(224.47,116.3) 224.44,116.28 v5(224.02,116.28)
  IN3 w0.084: v4(224.47,116.3) 224.47,116.45 225.1,117.09 230.91,117.09 233.39,119.57 234.14,119.57 234.95,120.38 234.95,122.84 234.28,123.51 234.28,123.72 v4(233.96,124.04)
  GND4 w0.119: v4(233.96,124.04) 233.7,123.78 v9(233.67,123.78)
PBTN_OUT#_R: length 20.3
  TOP w0.152: RH57.1 144.29,119.92 143.69,119.92 143.45,120.16 RH68.2 v2(143.02,120.3)
  IN2 w0.06: v2(132.23,110.66) 132.23,110.66 132.42,110.66 132.78,111.02 133.02,111.02 133.63,111.63 134.26,111.63 135.46,112.83 135.74,112.83 136.23,113.32
  IN2 w0.084: v2(143.02,120.3) 142.75,120.3 141.87,121.19 140.14,121.19 139.62,120.67 139.62,116.02 137.45,113.85 136.66,113.85 136.33,113.52 136.33,113.42 136.23,113.32
PC10: length 3.6
  TOP w0.089: U23.56 59.9,91.58 60.18,91.85 60.18,92.61 R185.2 R186.2
PC11: length 2.8
  TOP w0.089: U23.55 59.77,91.18 60.53,91.93 R190.2 R189.2
PC20: length 2.7
  TOP w0.089: U23.54 59.64,90.78 60.16,91.3 R188.2 R187.2
PC21: length 2.6
  TOP w0.089: U23.53 60.42,90.38 R194.2 R191.2
PCH_DDI1_AUXN: length 90.6
  TOP w0.152: C133.1 47.53,95.09 47.81,95.38 v2(47.81,97.63)
  IN2 w0.06: v2(123.53,99.32) 123.44,99.23 123.44,99.02 123.33,98.91 123.33,98.58 123,98.25 123,96.04 121.62,94.66 121.62,94.17 121.6,94.15 121.6,94.14
  IN2 w0.084: 121.6,94.14 121.6,93.13 119.75,91.28 117.67,91.28 117.41,91.03 116.88,91.03 115.94,90.09 114.28,90.09 113.87,89.68 112.96,89.68 112.68,89.96 108.83,89.96 108,90.79 101.89,90.79 101.51,90.42 89.48,90.42 88.27,91.63 75.95,91.63 74.7,92.88 65.25,92.88 60.38,97.75 49.04,97.75 48.66,98.13 47.96,98.13 47.83,98 47.83,97.65 v2(47.81,97.63)
PCH_DDI1_AUXN_R: length 3.4
  TOP w0.152: U23.25 49.45,91.58 48.92,92.11 47.84,92.11 47.53,92.42 C133.2
PCH_DDI1_AUXP: length 90.7
  TOP w0.152: C112.1 48.16,94 48.09,94.08 47.95,94.08 47.87,94.16 47.87,94.95 48.15,95.24 48.15,97.54 v2(48.24,97.63)
  IN2 w0.06: 121.76,94.14 121.76,94.16 121.74,94.18 121.74,94.61 123.12,95.99 123.12,98.2 123.44,98.52 123.44,98.54 123.51,98.61 123.57,98.61 123.61,98.65 123.61,98.8 123.57,98.84 123.54,98.84 v2(123.53,98.83)
  IN2 w0.084: 121.76,94.14 121.76,93.06 121.15,92.45 121.15,92.23 120.84,91.92 120.62,91.92 119.82,91.12 117.74,91.12 117.48,90.86 116.95,90.86 116.01,89.92 114.35,89.92 113.94,89.52 112.9,89.52 112.61,89.8 108.77,89.8 107.94,90.63 101.96,90.63 101.58,90.25 89.41,90.25 88.2,91.46 75.89,91.46 74.63,92.72 65.18,92.72 60.31,97.59 48.97,97.59 48.59,97.97 48.03,97.97 47.99,97.93 47.99,97.84 48.2,97.63 v2(48.24,97.63)
PCH_DDI1_AUXP_R: length 3.2
  TOP w0.152: U23.24 49.88,91.92 49.59,91.92 49.06,92.44 48.96,92.44 48.71,92.69 48.41,92.69 48.16,92.44 47.98,92.44 47.87,92.56 47.87,92.78 48.13,93.05 C112.2
PCH_DDI1_CLK: length 4
  IN1 w0.06: v1(134.16,99.96) 134.48,99.63 135.2,99.63 136.48,98.36 v3(136.54,98.36)
  IN2 w0.06: v3(136.54,98.36) 136.32,98.59 v4(136.32,98.71)
  GND4 w0.119: v9(136.14,99.09) 136.14,98.89 v4(136.32,98.71)
PCH_DDI1_DAT: length 2.8
  IN1 w0.06: v1(134.16,99.31) 134.37,99.31 134.57,99.11 135.08,99.11 v3(135.35,98.84)
  IN2 w0.06: v4(135.69,99.03) 135.54,99.03 v3(135.35,98.84)
  GND4 w0.119: v4(135.69,99.03) 135.82,98.9 v9(135.82,98.66)
  BOTTOM w0.119: RC16.2 136.15,98.33 v9(135.82,98.66)
PCH_DDI1_HPD: length 183.6
  TOP w0.119: U23.3 57.43,94.59 57.79,94.95 58.13,94.95 v1(58.24,94.85) ; v2(138.96,93.85) 138.66,93.85 138.23,93.42 138.23,92.63 138.03,92.43 137.14,92.43 136.76,92.81 136.76,93.44 136.5,93.7 136.5,94.78 136.12,95.16 135.59,95.16 134.83,95.92 v1(134.83,96.3)
  IN1 w0.06: v1(134.83,96.3) 134.73,96.4 134.7,96.4 133.15,97.95 133.01,97.95 v1(132.87,98.09)
  IN1 w0.089: v1(58.24,94.85) 58.41,94.67 62.36,94.67 66.04,90.99 76.12,90.99 76.86,91.73 88,91.73 91.56,95.29 91.56,97.29 92.68,98.42 92.68,99.54 95.19,102.04 95.19,105.63 95.98,106.42 95.98,111.85 96.44,112.3 96.44,122.63 97.45,123.64 97.45,124.08 v5(97.73,124.37)
  GND1 w0.119: v5(97.73,124.37) 97.76,124.34 v4(98.16,124.34)
  IN2 w0.084: v4(147.91,90.2) 147.81,90.31 144.48,90.31 143.44,91.35 139.68,91.35 138.96,92.07 v2(138.96,93.85)
  GND3 w0.119: v4(98.16,124.34) 98.55,124.34 102,120.89 111.36,120.89 112.48,119.77 113.4,119.77 114.42,118.75 117.2,118.75 121.82,114.14 134.73,114.14 135.1,114.5 137.71,114.5 138,114.21 138.99,114.21 139.18,114.02 141.39,114.02 141.41,114.04 142.74,114.04 143.25,114.55 145.69,114.55 146.35,115.21 147.31,115.21 148.38,116.28 150.79,116.28 151.62,115.46 v4(151.62,115.03)
  IN3 w0.084: v6(152.15,102.22) 152.15,102.39 152.41,102.64 152.41,103.01 152.3,103.11 152.3,103.5 153.42,104.62 v6(153.92,104.62) ; v4(151.62,115.03) 151.62,114.73 152.51,113.84 152.51,109.64 151.71,108.83 v6(151.43,108.83)
  GND4 w0.119: v4(147.91,90.2) 148.06,90.05 148.06,89.85 v9(148.24,89.67)
  BOTTOM w0.119: v6(153.92,104.62) 153.92,104.74 151.79,106.86 151.79,108.47 v6(151.43,108.83) ; v9(148.24,89.67) 148.38,89.67 151.63,92.92 151.63,93.51 152.5,94.39 152.5,98.35 152.33,98.52 152.33,101.74 152.15,101.91 v6(152.15,102.22)
