# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AMP_ASEL: length 3.8
  TOP w0.119: RA64.2 199.17,124.33 199.17,123.86 199.45,123.58 199.83,123.58 200.17,123.24 RA62.1 200.46,123.22 200.61,123.37 UA2.14
AMP_I2S_BCLK: length 293.6
  TOP w0.119: UA2.6 204.78,125.06 204.37,125.46 204.11,125.46 203.13,126.44 203.13,126.74 202.71,127.17 202.71,130.05 202.84,130.19 v1(202.84,130.34) ; v7(32.91,26.1) 32.87,26.06 32.87,25.43 RA50.1
  IN1 w0.089: v5(105.11,131.2) 104.91,131.4 104.2,131.4 104.03,131.57 101.92,131.57 100.97,130.63 100.04,130.63 96.49,127.08 94.5,127.08 93.46,126.04 87.99,126.04 87.78,125.83 81.66,125.83 75.93,120.11 72.81,120.11 70.83,118.14 70.83,117.99 70.15,117.31 69.54,117.31 66.48,114.24 66.48,113.26 65.95,112.74 65.95,110.48 64.95,109.48 64.95,108.49 64.75,108.29 64.75,101.63 59.81,96.68 57.42,96.68 56.81,97.29 51.85,97.29 51.63,97.07 51.63,95.92 51.85,95.7 51.85,95.09 51.69,94.93 50.86,94.93 50.41,95.37 47.64,95.37 46.93,94.66 43.4,94.66 41.71,92.97 41.12,92.97 36.77,88.62 36.77,87.39 35.36,85.98 35.36,83.98 33.69,82.31 33.69,77.4 32.71,76.41 32.71,75.08 32.01,74.38 32.01,66 34.57,63.43 34.57,55.61 36.3,53.88 36.3,39.03 35.37,38.1 35.37,32.77 35.48,32.66 35.48,29.17 35.27,28.96 35.27,27.74 34.2,26.67 33.94,26.67 33.56,26.3 33.11,26.3 v7(32.91,26.1) ; v3(149.46,124.32) 149.26,124.52 149.26,128.96 150.13,129.84 159.75,129.84 160.05,130.14 161.25,130.14 162.29,129.1 166.88,129.1 166.92,129.14 168.26,129.14 168.42,128.98 171.56,128.98 172.84,127.69 175,127.69 175.53,127.17 175.53,125.87 176.33,125.07 176.33,124.1 177,123.43 177,122.38 177.19,122.19 178,122.19 178.6,121.59 183.54,121.59 183.91,121.97 184.65,121.97 184.77,122.09 184.77,122.95 187.51,125.69 187.51,127.25 188.76,128.49 190.68,128.49 191.42,129.23 191.42,130.18 192.34,131.1 194.34,131.1 194.79,130.65 199.04,130.65 199.24,130.86 201.36,130.86 201.53,130.69 202.57,130.69 202.84,130.42 v1(202.84,130.34)
  GND1 w0.119: v4(105.24,131.63) 105.24,131.33 v5(105.11,131.2)
  IN2 w0.084: v3(149.46,124.32) 149.43,124.29 v4(149.43,123.91)
  GND3 w0.119: v4(149.43,123.91) 148.19,122.66 145.12,122.66 144.22,121.77 140.41,121.77 139.55,120.9 125.65,120.9 122.97,123.58 122.69,123.58 122.36,123.91 122.36,124.28 120.67,125.97 114.84,125.97 111,129.8 107.37,129.8 105.54,131.63 v4(105.24,131.63)
  BOTTOM w0.119: CA49.1 32.91,25.44 v7(32.91,26.1)
AMP_I2S_BCLK_R: length 3.1
  TOP w0.119: RA50.2 32.72,23.47 33.06,23.13 UA1.56
AMP_I2S_MCLK: length 303.6
  TOP w0.119: v1(203.27,130.4) 203.27,130.2 202.93,129.85 202.93,127.26 203.26,126.92 203.35,126.83 203.35,126.53 204.2,125.68 204.47,125.68 204.88,125.27 205.08,125.27 205.18,125.17 UA2.5 ; v7(33.89,26.09) 33.89,25.59 RA49.1
  IN1 w0.089: v5(106,131.02) 105.82,130.84 104.45,130.84 104.16,130.55 102.7,130.55 102.19,130.03 102.02,130.03 101.63,129.64 101.63,128.4 101.34,128.11 99.81,128.11 96.69,124.98 96.69,123.96 95.36,122.63 95.36,106.61 94.62,105.87 94.62,102.28 91.55,99.21 91.55,98.11 90.99,97.55 90.99,95.61 87.71,92.34 76.66,92.34 75.89,91.56 66.28,91.56 61.84,95.99 53.85,95.99 52.11,94.25 49.54,94.25 49,94.79 48.33,94.79 47.45,93.91 45.15,93.91 43.32,92.08 42.79,92.08 42.34,91.64 40.89,91.64 38.91,89.66 38.44,89.66 37.31,88.53 37.31,85.94 36.75,85.38 36.75,84.48 34.26,82 34.26,77.16 33.18,76.08 33.18,74.59 32.49,73.9 32.49,73.01 33.11,72.39 33.11,65.17 34.78,63.5 34.78,55.68 36.49,53.96 36.49,38.95 35.56,38.02 35.56,32.85 35.67,32.74 35.67,29.89 35.85,29.71 35.85,28.06 v7(33.89,26.09) ; v1(203.27,130.4) 202.79,130.88 201.61,130.88 201.44,131.05 199.16,131.05 198.96,130.84 195.89,130.84 195.76,130.97 195.76,131.43 195.48,131.71 193.99,131.71 193.67,131.39 192.27,131.39 191.23,130.35 191.23,129.31 190.6,128.68 188.68,128.68 187.32,127.33 187.32,125.77 185.06,123.51 183.8,123.51 183.64,123.35 183.64,122.75 183.55,122.66 182.67,121.78 178.68,121.78 178.25,122.21 178.25,123.08 176.73,124.61 176.73,125.24 175.72,126.25 175.72,127.24 175.04,127.92 173.53,127.92 172.99,128.47 172.33,128.47 171.64,129.17 168.5,129.17 168.33,129.33 166.84,129.33 166.81,129.29 162.37,129.29 161.33,130.33 159.97,130.33 159.67,130.03 150.03,130.03 149.05,129.05 149.05,125.31 147.38,123.63 v5(147.38,122.49)
  GND1 w0.119: v4(147.68,122.26) 147.45,122.49 v5(147.38,122.49) ; v5(106,131.02) v4(105.62,131.02)
  GND3 w0.119: v4(105.62,131.02) 105.75,131.02 107.19,129.57 110.9,129.57 114.74,125.74 120.57,125.74 122.13,124.18 122.13,123.12 122.57,122.68 123.56,122.68 125.56,120.68 139.64,120.68 140.51,121.54 144.31,121.54 145.15,122.39 147.55,122.39 v4(147.68,122.26)
  BOTTOM w0.119: CA48.1 v7(33.89,26.09)
AMP_I2S_MCLK_R: length 4
  TOP w0.119: UA1.55 33.48,21.03 33.72,21.27 33.72,24.51 RA49.2
AMP_LDO_A1.5V: length 5.2
  TOP w0.203: CA105.1 197.42,121.06 197.57,121.22 197.82,121.22 197.9,121.29 198.53,121.29 199.22,121.98 199.78,121.98 200.04,121.71 CA138.1 200.27,121.77 UA2.18
ANA2_EN: length 137
  TOP w0.119: U713.5 93.52,126.31 94.27,127.06 95.8,127.06 96.26,127.52 96.26,129.37 v2(96.39,129.49)
  IN2 w0.084: v4(193.48,134.81) 192.66,133.98 192.66,132.47 189.89,129.7 189.89,126.01 188.76,124.88 185.41,124.88 184.76,124.22 180.62,124.22 178.38,126.46 178.38,128.02 177.65,128.76 176.58,128.76 176.18,128.35 172.58,128.35 171.55,129.38 167.09,129.38 166.98,129.28 162.69,129.28 162.49,129.47 161.51,129.47 161.27,129.23 160.15,129.23 158.61,127.69 154.26,127.69 153.28,128.67 149.85,128.67 149.71,128.53 147,128.53 145.16,126.69 143.12,126.69 142.51,127.3 142.51,127.38 140.81,129.09 139.6,129.09 138.4,127.88 138.4,125.81 137.57,124.99 137.57,124.42 v4(137.55,124.4) ; v2(194.57,142.1) 194.57,142.1 194.57,141.28 v4(194.54,141.26) ; v4(96.11,131.4) 96.86,130.65 96.86,129.75 96.6,129.49 v2(96.39,129.49)
  GND3 w0.119: v4(116.37,129.44) 116.49,129.32 119.48,129.32 120.12,128.68 122.3,128.68 127.48,123.5 136.52,123.5 137.42,124.4 v4(137.55,124.4)
  IN3 w0.084: v4(96.11,131.4) 99.41,131.4 99.8,131.79 100.53,131.79 102.04,133.3 104.27,133.3 104.43,133.15 105.86,133.15 106.76,132.24 109.13,132.24 109.82,131.55 113.94,131.55 115.64,129.85 115.91,129.85 116.33,129.44 v4(116.37,129.44) ; v4(193.48,134.81) 193.05,135.24 193.05,135.93 193.88,136.77 193.88,140.59 v4(194.54,141.26)
  GND4 w0.119: v4(194.54,141.26) v15(194.54,140.8)
AUDIO_IRQ: length 2.2
  TOP w0.119: UA1.6 30.11,23.27 v7(30.11,23.27)
  BOTTOM w0.119: RA28.1 RA26.2 30.3,23.08 v7(30.11,23.27)
AUDIO_PWR_EN: length 361.9
  TOP w0.119: U37.3 196.78,128.08 v10(196.86,128.15) ; U37.5 195.98,128 v1(196.08,128.1) ; U38.3 34.05,85.76 33.79,85.5 33.79,85.05 34.06,84.78 37.15,84.78 37.37,84.56 40.66,84.56 40.89,84.34 44.13,84.34 44.91,85.12 45.32,85.12 45.95,84.49 v1(47.1,84.49) ; 23.09,66.15 23.54,66.15 23.58,66.11 U36.3 ; 23.09,66.15 22.63,66.15 R5755.2 21.8,66.05 21.56,65.81 21.56,63.42 22.4,62.58 27.52,62.58 28.58,63.64 31.48,63.64 v7(31.62,63.77) ; 23.09,66.15 R232.2 23.32,65.31 U36.5
  IN1 w0.06: 139.81,111.75 139.64,111.75 139.07,111.19 137.72,111.19 137.54,111.37 136.88,111.37 136.57,111.06 135.93,111.06 135.46,111.54 135.24,111.54 134.99,111.78 v1(134.99,111.79)
  IN1 w0.089: v8(143.8,111.08) 142.87,112.01 141.63,112.01 141.38,111.75 139.81,111.75 ; v1(196.08,128.1) 196.81,128.1 v10(196.86,128.15) ; v7(38.3,66.15) 37.87,66.58 37.87,73.29 37.52,73.63 37.52,80.35 39.55,82.38 44.74,82.38 46.84,84.49 v1(47.1,84.49) 47.15,84.44 47.15,84.06 51.11,80.09 72.55,80.09 72.92,80.47 73.31,80.47 73.82,79.96 134.51,79.96 134.74,80.19 135.2,80.19 138.17,83.16 140.05,83.16 141.37,84.47 141.37,85.64 142.09,86.37 142.42,86.37 143.88,87.83 153.01,87.83 153.5,88.32 160.26,88.32 163.72,84.86 167.6,84.86 168.57,85.83 169.55,85.83 171.29,84.09 184.68,84.09 v7(186.75,86.16) ; v7(203.24,105.65) 204.46,106.87 206.31,106.87 v5(211.47,112.03)
  GND1 w0.119: v5(211.47,112.03) 211.74,112.3 v4(211.74,112.38) ; v8(143.8,111.08) 143.97,111.08 v4(144.41,111.51) ; v4(197.33,128.05) 197.22,128.15 v10(196.86,128.15)
  IN3 w0.084: v4(197.33,128.05) 201.63,128.05 202.25,127.43 202.25,119.67 203.2,118.72 204.44,118.72 206.69,116.47 v6(206.69,115.96) ; v6(189.75,101.23) 189.75,101.22 188.98,101.99 186.32,101.99 183.02,105.29 177.64,105.29 176.8,106.13 176.8,106.94 174.78,108.96 v6(174.78,110.19)
  GND4 w0.119: v4(144.41,111.51) v9(144.41,110.8) ; v4(211.74,112.38) 211.72,112.38 v9(211.28,112.81)
  BOTTOM w0.119: v9(144.41,110.8) 144.41,110.95 144.79,111.33 146.6,111.33 147.24,110.7 151.77,110.7 151.87,110.8 159.5,110.8 160.26,110.04 160.26,109.62 162.07,107.82 162.19,107.82 163.25,106.76 167.01,106.76 168.44,108.19 172.28,108.19 174.05,109.95 174.54,109.95 v6(174.78,110.19) ; v7(186.75,86.16) 186.75,94.41 188.77,96.43 188.77,100.25 v6(189.75,101.23) 192.32,103.8 192.32,107.73 193.58,108.99 196.34,108.99 196.96,108.36 198.29,108.36 200.39,106.27 202.44,106.27 203.07,105.65 v7(203.24,105.65) ; v9(211.28,112.81) 211.28,113.7 209.03,115.96 v6(206.69,115.96) ; v7(38.3,66.15) 38.68,65.77 38.68,64.11 38.4,63.83 31.67,63.83 v7(31.62,63.77)
AUX_EN_WLAN: length 20.5
  TOP w0.119: D10.3 231.12,135.83 v10(231.35,136.06) ; U27.L13 230.81,120.73 v10(230.36,120.28)
  GND1 w0.119: v4(231.63,135.69) 231.63,135.78 v10(231.35,136.06) ; v4(229.8,120.3) 229.83,120.28 v10(230.36,120.28)
  IN3 w0.084: v4(231.63,135.69) 231.63,134.93 232.17,134.39 232.17,132.86 231.9,132.58 231.9,129.66 232.66,128.9 232.66,127.61 232.38,127.34 232.38,126.96 231.55,126.12 231.55,125.48 229.33,123.26 229.33,123.03 229.6,122.76 229.6,120.5 v4(229.8,120.3)
B4_SLP_S0#: length 125.2
  TOP w0.119: v1(226.27,119.05) 226.27,118.37 226.73,117.91 228.29,117.91 229.45,116.75 230.28,116.75 R166.1
  IN1 w0.06: v3(136.38,112.07) 136.53,112.23 138.2,112.23 138.5,112.53 138.7,112.53 138.84,112.38 139.22,112.38 139.79,112.95 139.81,112.95
  IN1 w0.089: 139.81,112.95 140.29,112.95 140.61,113.27 143.52,113.27 144.11,112.67 144.77,112.67 144.99,112.45 146.08,112.45 146.1,112.44 146.63,112.44 146.87,112.2 146.87,111.9 149.85,108.91 149.85,108.29 150.13,108.01 150.13,106.53 150.65,106 151.28,106 151.52,105.76 151.52,105.19 151.83,104.87 151.83,103.97 154,101.8 156.12,101.8 156.34,101.58 158.96,101.58 159.09,101.71 160.01,101.71 160.13,101.84 161.15,101.84 161.68,101.3 163.75,101.3 164.06,101.61 165.45,101.61 165.93,102.09 166.92,102.09 167.31,101.7 179.6,101.7 180.05,101.26 181.07,101.26 181.5,100.82 183.36,100.82 183.66,101.12 184.85,101.12 185.34,101.61 188.13,101.61 188.33,101.8 189.35,101.8 191.83,104.28 191.83,104.53 192.35,105.06 192.35,106.45 193.28,107.38 193.28,108.25 195.83,110.8 195.83,112.29 199.98,116.43 199.98,116.87 200.79,117.68 203.98,117.68 204.45,118.14 205.81,118.14 208.76,121.1 210.83,121.1 211.61,121.88 212.44,121.88 213.44,122.88 213.8,122.88 214.84,123.93 216.33,123.93 217,124.6 218.56,124.6 218.83,124.87 220.55,124.87 221.67,123.74 222.44,123.74 222.52,123.66 222.52,123.12 224.5,121.14 225.89,121.14 226.12,120.91 226.12,119.2 v1(226.27,119.05)
  IN2 w0.06: v3(136.38,112.07) 136.38,112.02 135.97,111.61 135.38,111.61 134.79,111.01 133.86,111.01 132.94,110.09 v2(132.8,110.09)
B+: length 15.5
  TOP w0.119: 172.07,123.37 v10(172.08,123.37) ; v10(176.38,127.82) v10(176.6,127.61) 176.66,127.54
  TOP w0.254: v2(170.79,123.6) 170.81,123.58 171.64,123.58 171.85,123.37 172.07,123.37 ; v7(170.85,111.01) 170.85,110.27 170.44,109.86 168.51,109.86 168.24,109.6 PR300.1
  GND1 w0.119: v4(176.97,127.85) 176.69,128.13 v10(176.61,128.13) v10(176.3,128.13) ; v4(177.4,127.52) 177.35,127.47 176.74,127.47 v10(176.6,127.61) v10(176.38,127.82)
  GND1 w0.254: v4(172.42,123.58) 172.22,123.37 v10(172.08,123.37)
  IN2 w0.06: v2(170.79,123.6) 170.79,123.57 170.59,123.38 170.21,123.38 v2(169.99,123.6)
  IN2 w0.254: v2(176.54,122.97) 175.94,123.56 172.44,123.56 v4(172.42,123.58)
  GND4 w0.254: v4(177.4,127.52) v16(177.74,127.18) ; v16(177.27,128.38) 176.97,128.07 v4(176.97,127.85)
  GND4 w0.381: v4(178.42,122.59) 178.39,122.56 v16(178.39,122.18) ; v16(177.91,121.98) 177.78,121.98 v4(177.5,122.26)
  vias: v4(156.27,113.62) v4(156.76,113.61) v4(174.22,112.05) v4(174.28,111.54) v6(168.67,133.72) v6(168.98,133.71) v6(169.28,133.73) v6(169.58,133.71) v7(53.42,104.43) v7(54.21,104.43) v7(55.48,104.43) v7(56.69,104.43) v7(57.88,107.35) v7(57.89,104.36) v7(58.49,107.35) v7(58.82,106.13) v7(58.78,104.94) v7(58.78,103.73) v7(66.95,89.57) v7(67.51,89.57) v7(68.07,89.54) v7(69.73,99.65) v7(69.75,98.99) v7(70.15,89.58) v7(70.36,100.92) v7(70.36,100.29) v7(70.39,99.65) v7(70.39,99.02) v7(70.73,89.57) v7(71.29,89.57) v7(71.8,133.35) v7(72.46,133.24) v7(72.75,134.64) v7(72.76,133.82) v7(73.18,133.24) v7(73.27,134.95) v7(73.41,134.31) v7(73.49,89.56) v7(74.07,89.54) v7(74.63,89.54) v7(160,127.36) v7(160.56,127.36) v7(166.05,130.87) v7(166.71,130.87) v7(167.06,114.36) v7(167.62,114.36) v7(175.18,137.52) v7(175.74,137.52) v7(176.29,137.52) v7(176.85,137.52) v7(177.41,137.52) v7(177.97,137.52) v7(179.53,113.42) v7(180.17,113.43) v7(180.83,114.44) v7(180.83,113.85) v7(180.84,113.27) v7(188.27,104.06) v7(188.59,104.58) v7(188.83,104.06) v7(189.16,104.58) v9(156.08,113.2) v9(156.41,113.2) v9(156.72,113.19) v9(157.03,113.18) v9(173.51,112.05) v9(173.64,111.46) v9(173.82,112) v9(173.84,111.69) v10(156.09,112.96) v10(156.39,112.96) v10(156.7,112.96) v10(157.08,112.96) v10(177.27,122.94) v10(177.27,122.59) v10(177.95,122.91) v10(177.96,122.55) v14(67.04,122.77)
B+_PMIC: length 0.6
  BOTTOM w0.102: v14(160.81,114.99) 160.66,114.84 v7(160.66,114.41)
BASE_DDI_AUX_DEV_DN: length 77.4
  TOP w0.152: v1(103.33,85.38) 103.41,85.45 103.41,86.07 103.05,86.44 102.61,86.44 102.34,86.71 102.34,87.15 102.61,87.43 102.99,87.43 103.11,87.55 MD4.4 MD4.7 104.71,87.55 105.8,88.64 109.81,88.64 110.9,87.55 JPOGO.17
  IN1 w0.089: v1(46.21,90.76) 46.21,90.88 46.29,90.97 46.93,90.97 47.19,90.71 47.19,89.66 46.36,88.83 46.36,88.12 46.74,87.74 50.07,87.74 51.19,86.62 56.06,86.62 56.43,86.25 61.36,86.25 61.61,86 64.92,86 65.36,86.44 80.73,86.44 82.65,84.53 95.3,84.53 96.77,86 98.06,86 98.74,85.33 103.28,85.33 v1(103.33,85.38)
BASE_DDI_AUX_DEV_DN_L: length 3.4
  TOP w0.152: U23.27 49.46,90.78 49.32,90.92 49.07,90.92 48.83,90.68 R127.1 48.57,90.9 48.42,91.05 47.42,91.05 R119.1
BASE_DDI_AUX_DEV_DP: length 77.3
  TOP w0.152: v1(103.73,85.38) 103.67,85.44 103.67,86.18 103.16,86.7 102.72,86.7 102.6,86.82 102.6,87.05 102.72,87.16 102.99,87.16 103.11,87.05 MD4.5 MD4.6 104.58,87.05 104.75,87.21 104.85,87.21 105.94,88.3 109.67,88.3 110.56,87.41 110.56,86.72 110.5,86.66 110.5,86.66 JPOGO.15
  IN1 w0.089: v1(103.73,85.38) 103.73,85.46 103.54,85.66 103.23,85.66 103.12,85.54 98.83,85.54 98.15,86.22 96.68,86.22 95.21,84.74 82.73,84.74 80.82,86.66 65.27,86.66 64.83,86.22 61.7,86.22 61.45,86.47 56.52,86.47 56.15,86.84 51.28,86.84 50.16,87.96 46.83,87.96 46.58,88.21 46.58,88.74 47.41,89.57 47.41,90.8 47.02,91.18 46.29,91.18 46.21,91.27 v1(46.21,91.65)
BASE_DDI_AUX_DEV_DP_L: length 3.4
  TOP w0.152: R120.1 47.37,91.39 48.31,91.39 48.57,91.65 R137.1 49.14,91.18 U23.26
BASE_DDI_LANE0_DEV_DN: length 60
  TOP w0.152: v1(105.52,84.34) 105.57,84.39 105.57,86.59 106.23,87.25 108.22,87.25 108.5,86.97 JPOGO.5 ; C206.2 v1(59.52,85.72)
  IN1 w0.089: v1(59.52,85.72) 59.54,85.7 59.54,85.25 60.47,84.32 70.25,84.32 70.53,84.6 74.95,84.6 75.23,84.32 75.87,84.32 76.09,84.54 76.09,85.34 76.26,85.52 76.51,85.52 76.68,85.34 76.68,84.54 76.9,84.32 77.5,84.32 77.71,84.54 77.71,85.32 77.89,85.5 78.13,85.5 78.31,85.32 78.31,84.54 78.52,84.32 79.12,84.32 79.34,84.54 79.34,85.32 79.51,85.49 79.76,85.49 79.93,85.32 79.93,84.54 80.15,84.32 81.53,84.32 81.98,83.88 96.02,83.88 96.78,84.64 104.04,84.64 104.13,84.73 105.35,84.73 105.55,84.53 105.55,84.37 v1(105.52,84.34)
BASE_DDI_LANE0_DEV_DN_L: length 3.6
  TOP w0.152: C206.1 59.65,86.41 59.65,86.67 58.77,87.54 58.31,87.54 57.84,88.01 57.84,88.4 57.83,88.41 U23.49
BASE_DDI_LANE0_DEV_DP: length 59.9
  TOP w0.152: v1(105.97,84.33) 105.91,84.39 105.91,86.45 106.37,86.91 108.08,86.91 108.16,86.83 108.16,86.64 108.1,86.58 JPOGO.3 ; C258.2 v1(60.15,85.72)
  IN1 w0.089: v1(60.15,85.72) 60.22,85.78 60.31,85.78 60.38,85.71 60.38,85.5 60.33,85.45 59.8,85.45 59.76,85.42 59.76,85.34 60.56,84.54 70.16,84.54 70.44,84.82 75.04,84.82 75.32,84.54 75.78,84.54 75.87,84.63 75.87,85.43 76.17,85.73 76.6,85.73 76.9,85.43 76.9,84.63 76.99,84.54 77.41,84.54 77.5,84.63 77.5,85.41 77.8,85.71 78.22,85.71 78.52,85.41 78.52,84.63 78.61,84.54 79.03,84.54 79.12,84.63 79.12,85.41 79.42,85.71 79.85,85.71 80.15,85.41 80.15,84.63 80.24,84.54 81.62,84.54 82.07,84.09 95.93,84.09 96.69,84.86 103.96,84.86 104.04,84.95 105.44,84.95 105.77,84.62 105.77,84.4 105.83,84.33 v1(105.97,84.33)
BASE_DDI_LANE0_DEV_DP_L: length 3.7
  TOP w0.152: C258.1 59.98,86.5 59.98,86.81 58.91,87.88 58.45,87.88 58.18,88.15 58.18,88.38 58.23,88.43 U23.50
BASE_DDI_LANE1_DEV_DN: length 59.8
  TOP w0.152: JPOGO.6 v1(108.5,82.24) ; C260.2 58.43,85.57 58.43,85.23 58.2,85 v1(58.2,84.51)
  IN1 w0.089: v1(108.5,82.24) 108.5,82.24 108.5,81.94 108.3,81.73 107.54,81.73 107.32,81.95 107.32,82.53 107.21,82.65 107.04,82.65 106.93,82.53 106.93,81.95 106.71,81.73 106.32,81.73 106.1,81.95 106.1,82.49 105.99,82.61 105.82,82.61 105.71,82.49 105.71,81.95 105.49,81.73 104.58,81.73 103.57,82.74 102.7,82.74 102.62,82.65 102.62,82.19 102.41,81.99 101.99,81.99 101.79,82.19 101.79,82.65 101.7,82.74 99.89,82.74 99.24,82.09 91.74,82.09 91.36,82.47 80.92,82.47 80.33,83.05 74.38,83.05 74.07,83.36 71.77,83.36 71.33,82.91 63.66,82.91 63.51,83.07 62.96,83.07 62.81,82.91 61.91,82.91 61.75,83.07 61.13,83.07 60.98,82.91 60.24,82.91 60.08,83.08 59.57,83.08 59.41,82.91 58.71,82.91 58.24,83.38 58.24,84.47 v1(58.2,84.51)
BASE_DDI_LANE1_DEV_DN_L: length 3.7
  TOP w0.152: U23.46 56.63,88.37 56.64,88.36 56.64,88.35 56.66,88.32 56.66,87.94 57.75,86.84 58.28,86.84 58.38,86.74 58.38,86.41 C260.1
BASE_DDI_LANE1_DEV_DP: length 59.7
  TOP w0.152: v1(58.73,84.51) 58.63,84.51 58.54,84.61 58.54,84.86 58.76,85.09 58.76,85.58 C259.2 ; JPOGO.4 108.1,82.26 v1(108.08,82.24)
  IN1 w0.089: v1(58.73,84.51) 58.73,84.53 58.64,84.63 58.54,84.63 58.45,84.54 58.45,83.47 58.8,83.13 59.32,83.13 59.48,83.29 60.17,83.29 60.33,83.13 60.89,83.13 61.04,83.28 61.84,83.28 62,83.13 62.72,83.13 62.87,83.28 63.6,83.28 63.75,83.13 71.24,83.13 71.69,83.57 74.16,83.57 74.47,83.27 80.42,83.27 81.01,82.69 91.45,82.69 91.83,82.3 99.16,82.3 99.8,82.95 101.79,82.95 102.01,82.74 102.01,82.28 102.08,82.2 102.32,82.2 102.4,82.28 102.4,82.74 102.61,82.95 103.66,82.95 104.67,81.95 105.4,81.95 105.49,82.04 105.49,82.58 105.74,82.82 106.08,82.82 106.32,82.58 106.32,82.04 106.41,81.95 106.62,81.95 106.71,82.04 106.71,82.62 106.95,82.87 107.3,82.87 107.54,82.62 107.54,82.04 107.63,81.95 108.21,81.95 108.29,82.03 108.29,82.09 108.13,82.24 v1(108.08,82.24)
BASE_DDI_LANE1_DEV_DP_L: length 3.7
  TOP w0.152: U23.47 57.03,88.4 57,88.37 57,88.08 57.89,87.18 58.42,87.18 58.71,86.88 58.71,86.5 C259.1
BASE_DDI_LANE2_DEV_DN: length 60.3
  TOP w0.152: C264.2 57,84.64 v1(57.13,84.51) ; JPOGO.11 109.7,87.38 109.14,87.94 106.01,87.94 104.67,86.59 104.67,84.39 v1(104.6,84.32)
  IN1 w0.089: v1(104.6,84.32) 104.6,84.08 104.49,83.97 101.54,83.97 101.26,84.25 97.19,84.25 96.39,83.45 81.31,83.45 80.84,83.92 74.77,83.92 74.48,84.21 71.14,84.21 70.82,83.89 60.34,83.89 58.97,85.26 57.45,85.26 57.18,85 57.18,84.56 v1(57.13,84.51)
BASE_DDI_LANE2_DEV_DN_L: length 3.2
  TOP w0.152: U23.44 55.83,88.36 55.84,88.34 55.84,87.78 57.11,86.51 57.11,86.41 C264.1
BASE_DDI_LANE2_DEV_DP: length 60.2
  TOP w0.152: C262.2 57.64,85.36 57.57,85.29 57.42,85.29 57.34,85.22 57.34,84.78 57.61,84.51 v1(57.66,84.51) ; JPOGO.9 109.3,86.7 109.3,86.7 109.36,86.76 109.36,87.24 109,87.6 106.15,87.6 105,86.45 105,84.38 v1(105.07,84.32)
  IN1 w0.089: v1(105.07,84.32) 104.94,84.32 104.83,84.21 104.83,84.01 104.58,83.75 101.45,83.75 101.17,84.03 97.28,84.03 96.48,83.23 81.22,83.23 80.75,83.7 74.68,83.7 74.39,83.99 71.23,83.99 70.91,83.68 60.25,83.68 58.88,85.05 57.54,85.05 57.4,84.91 57.4,84.41 57.47,84.34 57.6,84.34 57.66,84.4 v1(57.66,84.51)
BASE_DDI_LANE2_DEV_DP_L: length 3.2
  TOP w0.152: C262.1 57.44,86.5 57.44,86.65 56.18,87.92 56.18,88.32 56.23,88.37 U23.45
BASE_DDI_LANE3_DEV_DN: length 60.8
  TOP w0.152: JPOGO.12 v1(109.7,82.23)
  IN1 w0.089: v1(109.7,82.23) 109.63,82.16 109.63,82.01 108.73,81.11 81.26,81.11 80.08,82.29 55.34,82.29 54.97,82.66 54.97,83.18 55.31,83.52 55.31,83.68 54.9,84.1 54.9,84.54 55.11,84.76 55.34,84.76 55.43,84.85 55.43,85.11 55.34,85.2 55.11,85.2 54.9,85.42 54.9,85.67 v1(54.84,85.72)
BASE_DDI_LANE3_DEV_DN_L: length 2.8
  TOP w0.152: C266.1 54.97,86.43 54.97,86.82 54.67,87.12 54.67,88.35 54.63,88.39 U23.41
BASE_DDI_LANE3_DEV_DP: length 60.7
  TOP w0.152: v1(109.34,82.23) 109.3,82.27 JPOGO.10
  IN1 w0.089: v1(55.48,85.72) 55.48,85.83 55.4,85.91 55.2,85.91 55.11,85.82 55.11,85.51 55.2,85.42 55.43,85.42 55.65,85.2 55.65,84.76 55.43,84.54 55.2,84.54 55.11,84.45 55.11,84.19 55.53,83.77 55.53,83.43 55.19,83.09 55.19,82.75 55.43,82.51 80.17,82.51 81.35,81.33 108.64,81.33 109.42,82.1 109.42,82.15 v1(109.34,82.23)
BASE_DDI_LANE3_DEV_DP_L: length 2.8
  TOP w0.152: C265.1 55.31,86.48 55.31,86.96 55,87.26 55,88.33 55.03,88.36 U23.42
BASE_DDSP_HPD: length 304.9
  TOP w0.119: v1(231.48,120.18) 231.31,120.34 231.31,120.74 U27.K13 ; R138.1 116.84,88.92 116.84,89.06 116.58,89.33 114,89.33 113.95,89.28 111.82,89.28 110.86,90.24 103.85,90.24 v10(103.83,90.22) ; U23.48 v1(57.43,88.15)
  IN1 w0.089: v7(92.94,91.24) 91.78,90.08 64.83,90.08 63.18,88.43 61.3,88.43 61.14,88.58 60.13,88.58 59.7,88.15 v1(57.43,88.15) ; v3(234.51,117.14) 234.2,116.83 233.14,116.83 232.86,117.11 232.86,119.27 232.24,119.9 231.92,119.9 231.64,120.18 v1(231.48,120.18)
  GND1 w0.119: v4(104.02,89.86) 104.02,90.03 v10(103.83,90.22)
  IN2 w0.084: v3(234.51,117.14) 234.42,117.05 232.82,117.05 232.53,117.34 232.02,117.34 231.79,117.58 227.62,117.58 226.21,118.99 225.48,118.99 223.25,121.22 220.52,121.22 v4(218.9,122.83) ; v4(214.43,143.42) 214.24,143.61 204.79,143.61 204.56,143.84 201.01,143.84 200.64,143.46 197.51,143.46 194.22,140.17 193.45,140.17 192.84,139.56 v4(192.24,139.56)
  IN3 w0.084: v7(92.94,91.24) v6(95.26,91.24) ; v6(133.53,81.47) 132.73,80.66 110.85,80.66 107.17,84.34 104.65,84.34 103.38,85.61 v6(103.38,87.46) 104.31,86.53 107.74,86.53 108.18,86.98 108.18,89.37 107.27,90.28 104.44,90.28 v4(104.02,89.86) ; v4(214.43,143.42) 214.38,143.37 214.38,138.77 216.18,136.97 216.18,132.56 217.98,130.76 217.98,125.82 218.9,124.9 v4(218.9,122.83) ; v4(192.24,139.56) 192.24,137.18 190.08,135.02 190.08,132.31 190.42,131.96 190.42,125.53 191.18,124.77 191.18,116.4 191.42,116.16 191.42,112.96 193.71,110.68 193.71,109.51 191.7,107.5 191.7,105.54 189.37,103.22 187.84,103.22 186.1,104.95 186.1,107.15 185.47,107.78 177.81,107.78 v6(177.65,107.93)
  BOTTOM w0.119: v6(177.65,107.93) 177.1,107.37 175.8,107.37 175,106.58 175,105.49 174.18,104.67 173.45,104.67 168.09,99.31 168.09,87.43 167.82,87.15 167.82,85.95 167.11,85.25 164.83,85.25 162.79,87.28 156.56,87.28 155.95,87.89 148.5,87.89 145.5,84.89 143.4,84.89 142.07,83.56 141.73,83.56 140.96,84.34 137.06,84.34 134.19,81.47 v6(133.53,81.47) ; v6(95.26,91.24) 95.26,90.27 98.37,87.16 103.08,87.16 v6(103.38,87.46)
BASE_DDSP_HPD_L: length 22.3
  TOP w0.119: MD4.9 MD4.1 103.43,89.26 103.45,89.28 103.45,90.32 103.63,90.5 110.91,90.5 111.92,89.5 113.75,89.5 113.8,89.56 117.13,89.56 R138.2 117.74,88.95 117.74,87.69 117.94,87.49 118.55,87.49 118.81,87.22 120.34,87.22 120.5,87.06 JPOGO.65
BASE_DET#: length 234
  TOP w0.119: v1(221.56,116.64) 221.56,117.22 221.68,117.34 Q347.5 ; v1(214.1,115.63) 213.77,115.3 210.76,115.3 210.36,114.89 v2(208.49,114.89) ; PU201.2 63.18,139.25 63.4,139.47 v2(63.4,139.73) ; v2(69.82,124.14) 69.83,124.13 PR226.2
  IN1 w0.089: v3(191.88,133.43) 191.79,133.43 188.72,130.36 v7(188.09,130.36) ; v5(222.54,116.12) 222.18,116.12 221.66,116.64 v1(221.56,116.64) 221.28,116.92 217.83,116.92 217.16,116.26 216.19,116.26 215.56,115.63 v1(214.1,115.63)
  GND1 w0.119: v5(222.54,116.12) 222.75,116.12 v4(222.98,116.35)
  IN2 w0.06: v2(231.31,122.25) 231.31,122.42 231.35,122.46
  IN2 w0.084: v2(63.4,139.73) 63.43,139.76 65.11,139.76 65.77,139.1 69.88,139.1 70.8,138.18 72.14,138.18 74.32,136.01 74.32,132.28 72.84,130.81 72.84,129.48 69.82,126.46 v2(69.82,124.14) 70.54,124.86 71.31,124.86 71.69,124.48 73.11,124.48 73.49,124.86 73.93,124.86 78.81,129.75 80.51,129.75 82.09,131.32 82.95,131.32 83.21,131.58 87.98,131.58 89.19,132.79 92.3,132.79 92.75,133.24 93.41,133.24 v4(93.67,132.98) ; v4(192.31,133.66) 192.11,133.66 v3(191.88,133.43) ; 231.35,122.46 v4(231.48,122.59) ; v4(208.08,114.92) 208.11,114.89 v2(208.49,114.89)
  GND3 w0.119: v4(93.67,132.98) 93.89,132.76 94.12,132.76 94.79,132.09 100.46,132.09 101.26,132.89 105.94,132.89 107.64,131.18 110.92,131.18 111.06,131.05 114.92,131.05 115.44,130.52 115.87,130.52 116.86,129.54 119.78,129.54 120.35,128.96 122.33,128.96 127.26,124.04 136.54,124.04 v4(136.58,124.08)
  IN3 w0.084: v4(222.98,116.35) 222.98,117.18 v6(222.36,117.8) ; v4(208.08,114.92) 206.74,114.92 206,115.66 206,116.9 204.42,118.48 203.18,118.48 201.14,120.52 201.14,122.63 199.4,124.37 195.08,124.37 191.94,127.51 191.94,131.71 192.6,132.38 192.6,133.37 v4(192.31,133.66) ; v6(230.84,122.47) 230.83,122.49 230.59,122.49 230.36,122.26 230.36,119.85 229.58,119.06 224.59,119.06 v6(224.16,119.49) ; v6(173.64,129.85) 174.66,128.84 175.85,128.84 176.87,129.85 178.26,129.85 178.56,130.15 180.84,132.43 182.35,132.43 183.02,133.09 183.02,134.75 183.26,134.99 184.43,134.99 185.01,134.41 186.9,134.41 187.74,133.57 187.74,130.72 v7(188.09,130.36)
  GND4 w0.119: v6(230.84,122.47) 230.98,122.61 231.45,122.61 v4(231.48,122.59) ; v4(136.58,124.08) 136.9,124.08 v9(137.01,124.19)
  BOTTOM w0.119: v9(137.01,124.19) 139.12,124.19 139.36,124.43 144.01,124.43 148.94,129.35 154.31,129.35 155.35,130.4 160.8,130.4 161.91,129.29 163.18,129.29 163.49,129.61 165.02,129.61 165.15,129.48 173.27,129.48 v6(173.64,129.85) ; v6(224.16,119.49) 223.48,118.8 223.36,118.8 v6(222.36,117.8)
BASE_I2C_ALERT#: length 48.5
  TOP w0.06: 236.45,125.1 236.22,125.1 236.12,125 235.56,125 U27.B5
  TOP w0.119: 236.45,125.1 236.58,125.1 237.08,125.6 238.35,125.6 238.55,125.4 v1(238.55,125.24) ; R5750.1 220.48,118.88 220.21,118.62 Q347.1 220.79,117.99 221.04,117.75 v1(221.04,114.52)
  IN1 w0.089: v1(238.55,125.24) 238.64,125.33 240.73,125.33 240.96,125.56 243.24,125.56 244.74,124.06 244.74,118.28 243.92,117.46 242.26,117.46 239.06,114.26 233.4,114.26 233.2,114.45 221.1,114.45 v1(221.04,114.52)
BASE_KEYSSA_STATE: length 1.3
  TOP w0.119: R142.2 128.35,80.77 QT20.2
BASE_KEYSSA_STATE_L: length 9.1
  TOP w0.119: R142.1 127.45,80.75 121.32,80.75 120.1,81.97 120.1,81.98 JPOGO.64
BASE_SMB_EN: length 5.9
  TOP w0.119: R5746.2 220.52,115.65 220.75,115.88 220.75,116.53 220.58,116.69 Q347.3 Q347.2 Q348.2 218.95,117.34 218.5,117.8 217.99,117.8 217.53,117.34 Q348.5
BASE_SMBCLK: length 44.1
  TOP w0.119: R5751.1 217.6,118.85 217.29,118.55 Q348.4 217.72,117.99 217.94,118.21 v1(217.94,118.33) ; v1(237.34,123.36) 236.84,123.36 236.53,123.06 236.53,122.89 236.27,122.63 235.93,122.63 U27.A9
  IN1 w0.089: v1(237.34,123.36) 239.13,123.36 239.96,124.19 241.98,124.19 242.59,124.8 242.95,124.8 243.75,124 243.75,121.74 241.74,119.73 238.48,119.73 236.58,117.84 236.58,116.67 235.35,115.44 233.85,115.44 232.45,116.84 225.7,116.84 224.91,117.62 222.96,117.62 222.37,118.21 218.06,118.21 v1(217.94,118.33)
BASE_SMBDAT: length 50.5
  TOP w0.119: v10(218.46,115.78) 218.46,116.52 218.63,116.69 Q348.1
  IN1 w0.089: v10(218.46,114.7) 218.9,114.26 233.12,114.26 233.32,114.07 239.14,114.07 242.34,117.27 244.01,117.27 244.93,118.19 244.93,124.13 243.32,125.75 240.88,125.75 240.68,125.55 238.37,125.55 237.92,125.09 237.92,124.71 237.26,124.06 237.23,124.06 237.02,123.85 236.04,123.85 235.67,123.48 234.54,123.48 v10(234.31,123.25)
  GND1 w0.119: v10(218.46,115.78) v10(218.46,114.7) ; v4(233.93,123.31) 233.94,123.33 234.23,123.33 v10(234.31,123.25)
  GND4 w0.119: v4(233.93,123.31) 233.85,123.31 233.6,123.06 v9(233.51,123.06)
BAT_B+: length 128.2
  TOP w0.254: PR703.2 172.45,106.36 171.56,105.47 v7(171.25,105.47) ; v1(73.03,80.17) v7(73.03,82.94)
  IN1 w0.254: v1(73.03,80.17) 73.51,79.69 134.63,79.69 v3(134.85,79.92)
  IN2 w0.254: v7(166.33,85.68) 161.19,85.68 160.15,86.72 150.92,86.72 149.33,85.14 144.46,85.14 142.11,82.79 137.19,82.79 134.85,80.45 v3(134.85,79.92)
  BOTTOM w0.254: v7(73.03,82.94) v14(73.03,84.36) 73.03,85.37 v7(73.39,85.73) ; v7(171.25,105.47) 168.36,102.57 168.36,101.46 167.39,100.49 167.39,87.79 166.33,86.72 v7(166.33,85.68)
BATDRV#: length 72.9
  TOP w0.381: PR420.2 54.84,122.94 54.2,122.3 v7(54.2,121.86) ; PQ401.4 74.24,85.19 73.54,84.49 65.92,84.49 64.95,85.45 64.95,98.95 64.75,99.16 v2(64.75,99.37)
  IN2 w0.381: v2(64.75,99.37) 63.3,100.81 50.88,100.81 50.67,101.02 46.7,101.02 45.79,101.93 v4(45.79,102.74)
  IN3 w0.381: v4(45.79,102.74) 46.11,102.74 46.64,103.27 47.1,103.27 47.36,103.01 50.93,103.01 51.3,103.37 51.3,113.69 52.38,114.77 52.38,119.24 54.2,121.05 v7(54.2,121.86)
BATLOW#: length 20.2
  IN2 w0.06: 134.47,112.48 133.94,111.94 133.56,111.94 132.89,111.27 132.55,111.27 132.28,110.99 132.1,110.99 131.86,110.76 131.86,110.65 131.58,110.37 v2(131.58,110.16)
  IN2 w0.084: v2(143.45,121.57) 143.04,121.57 142.71,121.9 139.81,121.9 138.87,120.96 138.87,119.29 138.54,118.96 138.54,118.24 138.87,117.91 138.87,116.77 137.75,115.65 137.75,114.9 137.23,114.37 136.37,114.37 134.47,112.48
BATT_PRS#: length 10.5
  TOP w0.119: JBAT100.6 156.05,91.54 156.52,92.01 158.2,92.01 v7(158.48,92.29) 159.72,92.29 160.15,92.72 160.68,92.72 PD101.2 161.15,94.83 161.5,95.19 PR161.2 161.48,95.69 PR123.1
BEEP: length 366.8
  IN1 w0.089: v3(11.46,81.15) 11.46,87.78 14.44,90.76 23.46,90.76 23.66,90.95 25.57,90.95 27.86,93.24 27.86,93.34 28.7,94.18 28.7,94.76 29.65,95.72 31.19,95.72 32.32,96.86 32.74,96.86 32.9,96.71 33.96,96.71 34.29,97.04 39.65,97.04 41.47,98.86 44.37,98.86 45.35,99.84 47.64,99.84 49.87,102.07 58.68,102.07 59.59,102.98 59.59,110.55 61.61,112.57 61.61,117.14 65.13,120.66 65.61,120.66 67.22,122.26 67.22,123.08 67.84,123.71 68.5,123.71 69.52,124.72 70.28,124.72 70.64,125.09 71.64,125.09 72.58,126.02 75.53,126.02 77.78,128.27 78.75,129.24 79.24,129.24 79.62,129.62 79.62,130.17 80.37,130.91 83.37,130.91 83.82,131.37 85.11,131.37 86.06,132.31 89.18,132.31 93.3,136.43 99.97,136.43 100.56,135.85 101.75,135.85 102.2,135.4 106.88,135.4 107.24,135.04 110.15,135.04 110.32,135.21 113.08,135.21 115.2,133.09 v3(115.2,133) ; v5(224.35,125.62) 224.47,125.5 224.47,123.6 224.64,123.43 225.2,123.43 225.7,123.92 226,123.92 226.31,123.62 226.76,123.62 226.84,123.53 228.53,123.53 228.8,123.27 229.73,123.27 229.75,123.25 v1(230.31,123.25) ; v3(148.72,125.94) 148.85,126.07 148.85,129.12 149.95,130.22 159.59,130.22 159.89,130.52 161.41,130.52 162.45,129.48 166.73,129.48 166.76,129.52 167.6,129.52 168,129.93 171.14,129.93 172.41,128.66 173.06,128.66 173.61,128.12 175.12,128.12 175.96,127.28 177.12,127.28 177.36,127.03 177.36,124.51 178.63,123.24 178.63,122.37 178.84,122.16 182.51,122.16 183.24,122.9 183.24,123.55 183.59,123.89 184.9,123.89 186.94,125.93 186.94,127.53 188.47,129.07 189.67,129.07 192.23,131.62 193.57,131.62 193.86,131.91 195.86,131.91 196.13,132.18 202.48,132.18 204.24,133.93 205.96,133.93 206.9,134.87 206.9,134.96 208.72,136.78 208.72,137.52 208.98,137.79 209.9,137.79 210.71,138.6 213.76,138.6 214.22,138.14 215.89,138.14 216.29,138.55 220.03,138.55 v5(220.26,138.32)
  GND1 w0.119: v4(224.35,126.03) v5(224.35,125.62) ; v5(220.26,138.32) 220.37,138.32 v4(220.59,138.54)
  IN2 w0.084: v2(20.1,19.34) 19.67,19.77 19.67,20.98 19.25,21.4 18.29,21.4 15.83,23.86 15.83,25.92 12.51,29.25 12.51,30.87 11.98,31.4 11.98,36 11.09,36.89 11.09,41.71 5.43,47.37 5.43,58.88 4.64,59.67 4.64,70.93 9.86,76.16 9.86,79.55 v3(11.46,81.15) ; v3(115.2,133) 115.2,132.92 v4(116.22,131.9) ; v4(148.77,125.53) 148.72,125.59 v3(148.72,125.94)
  GND3 w0.119: v4(148.77,125.53) 148.65,125.41 148.65,124.8 148.27,124.42 147.46,124.42 147.19,124.7 146.05,124.7 145.71,124.37 145.1,124.37 144.52,123.78 142.37,123.78 142.17,123.58 141.58,123.58 139.37,125.8 137.17,125.8 136.5,125.13 127.47,125.13 121.99,130.6 120.43,130.6 119.77,131.26 116.85,131.26 v4(116.22,131.9)
  IN3 w0.084: v4(224.35,126.03) 224.35,132.75 224.91,133.31 224.91,135.67 223.77,136.81 222.61,136.81 220.88,138.54 v4(220.59,138.54)
BIA_PWM_EC: length 71.5
  TOP w0.119: v7(179.64,106.21) 179.64,105.34 179.9,105.07 D3.2
  IN1 w0.089: v3(227.74,121.64) 227.86,121.75 228.96,121.75 229.14,121.57 229.63,121.57 v1(230.31,122.25)
  IN2 w0.084: v3(227.74,121.64) 227.74,121.62 228.07,121.29 228.07,120.56 229.38,119.25 230.98,119.25 v4(231.12,119.39)
  IN3 w0.084: v7(179.64,106.21) 179.64,106.05 180.02,105.67 183.78,105.67 186.85,102.6 189.54,102.6 192.26,105.31 192.26,107.27 194.85,109.86 197.59,109.86 198.82,111.1 205.74,111.1 206.08,111.43 212.03,111.43 214.28,113.68 215.21,113.68 218.13,116.6 219.7,116.6 221.57,118.48 227.58,118.48 227.95,118.11 229.72,118.11 231.01,119.39 v4(231.12,119.39)
BOARD_ID: length 4.2
  TOP w0.119: U27.G1 232.69,126.87 232.69,128.34 C189.1 232.16,128.86 232.16,130.03 R155.2
BOARD_TYPE: length 4.8
  TOP w0.06: v1(229.39,124.16) 229.81,123.75 U27.N7
  TOP w0.119: R5738.2 227.12,125.33 226.73,124.94 v1(226.73,124.46)
  IN1 w0.089: v1(226.73,124.46) 226.74,124.44 227.01,124.44 227.16,124.3 227.96,124.3 228.36,124.69 228.92,124.69 229.39,124.22 v1(229.39,124.16)
BOOT4: length 9.4
  GND1 w0.508: v10(164.13,115.24) 164.01,115.24 163.8,115.44 v4(163.57,115.44)
  IN2 w0.203: 165.54,122.47 165.87,122.8 v2(165.99,122.8)
  IN2 w0.508: v4(165.08,121.34) 165.08,122.01 165.54,122.47
  IN3 w0.508: v4(165.08,121.34) 165.06,121.32 164.95,121.32 164.62,120.99 164.62,120.43 164.93,120.12 164.93,118.79 163.57,117.43 v4(163.57,115.44)
BOOT5: length 9.6
  TOP w0.254: PU500.A9 168.79,127.22 v7(168.78,127.24)
  TOP w0.508: v7(175.37,129.68) 175.09,129.95 175.09,130.64 PR510.2
  BOTTOM w0.508: v7(175.37,129.68) 173.23,127.54 169.06,127.54 168.78,127.26 v7(168.78,127.24)
BOOT6: length 9.7
  TOP w0.508: PR516.2 176.6,119.64 v1(176.45,119.79)
  IN1 w0.203: v1(170.39,123.2) 170.85,123.2 171.3,123.66
  IN1 w0.508: v1(176.45,119.79) 175.99,120.25 175.47,120.25 175.26,120.47 174.75,120.47 173.58,121.64 173.58,121.64 173.49,121.73 173.49,122.13 173.7,122.35 173.7,122.88 173.03,123.55 172.59,123.55 172.28,123.86 171.87,123.86 171.67,123.66 171.3,123.66
BOOT7: length 3.5
  TOP w0.254: PR501.1 173.94,123.82 173.32,123.82 173.02,124.11 172.27,124.11 171.98,124.4 PU500.F14
BOOT8: length 3.5
  TOP w0.381: PR511.1 v1(166.1,128.05)
  IN1 w0.203: v2(167.19,125.6) 167.19,126.14
  IN1 w0.254: 167.19,126.14 167.19,126.35 166.4,127.14 166.32,127.14 166.1,127.36 v1(166.1,128.05)
BOOT9: length 2.7
  IN1 w0.06: v1(169.59,125.6) 169.59,126.32 170.02,126.75 170.06,126.75
  IN1 w0.254: v1(170.54,127.85) 170.54,127.24 170.06,126.75
BOOT10: length 4.2
  IN1 w0.203: 165.58,124.66 165.84,124.4 v1(165.99,124.4)
  IN1 w0.254: 165.58,124.66 164.79,125.45
  IN1 w0.508: 164.79,125.45 164.68,125.55 162.52,125.55 v1(162.35,125.38)
BOOT11: length 16.3
  TOP w0.508: PR609.2 164.7,107.42 165.46,108.19 v7(165.46,109.05)
  IN1 w0.203: v5(168.34,120.76) 168.36,120.77 168.36,120.89 167.99,121.26 v1(167.99,121.6)
  GND1 w0.305: v5(168.34,120.76) 168.34,120.67 v4(167.98,120.3)
  IN3 w0.508: v4(167.98,120.3) 167.65,119.97 167.65,117.52 166.58,116.45 166.58,115.98 165.87,115.27 165.87,113.82 166.08,113.6 166.08,109.67 v7(165.46,109.05)
BOOT12: length 5
  IN1 w0.203: v1(168.79,122) 168.79,121.03 169.12,120.7 169.12,120.49
  IN1 w0.254: v1(171.81,118.91) 171.64,118.91 170.75,119.79 169.82,119.79 169.12,120.49
BQ2477_CSIP: length 26.4
  TOP w0.254: v7(57.64,134.91) 57.82,134.73 PR401.1 ; v7(46.01,120.65) 46.08,120.57 46.08,119.61 45.43,118.96 45.43,118.04 45.26,117.86 PR400.2
  IN3 w0.254: v7(57.64,134.91) 57.84,134.7 57.84,134.35 56.1,132.6 52.35,132.6 49.19,129.45 49.19,124.05 46.09,120.95 46.09,120.73 v7(46.01,120.65)
BQ24777_CSIN: length 26.3
  TOP w0.254: PR400.3 45.98,117.86 45.79,118.05 45.79,118.82 46.46,119.49 46.46,120.57 v7(46.56,120.67) ; PR402.1 58.71,134.6 v7(58.4,134.91)
  IN3 w0.254: v7(58.4,134.91) 58.2,134.7 58.2,134.2 56.24,132.25 52.49,132.25 49.55,129.3 49.55,123.9 46.56,120.91 v7(46.56,120.67)
BQ24777_CSON: length 50.9
  TOP w0.203: PC430.2 55.99,124.82 55.99,125.13 55.37,125.74 PU400.19
  TOP w0.254: PC430.2 v10(55.78,123.71) ; PR410.3 69.39,88.04 69.16,87.82 69.16,86.96 68.72,86.52 65.89,86.52 65.46,86.95 65.46,99.22 65.26,99.42 v2(65.26,99.8)
  GND1 w0.254: v10(55.78,123.71) 56.31,123.71 v4(56.53,123.93)
  IN2 w0.254: v2(65.26,99.8) 65.08,99.8 62.91,101.98 62.91,105.74 61.83,106.82 v4(61.83,107.02)
  IN3 w0.254: v4(61.83,107.02) 61.93,107.12 61.93,107.33 61.75,107.51 61.75,110.49 58.34,113.9 58.34,117.11 56.7,118.75 56.7,123.76 v4(56.53,123.93)
BQ24777_CSOP: length 49.7
  TOP w0.203: PC430.1 56.37,124.95 56.37,125.26 55.77,125.85 PU400.20
  TOP w0.254: PR410.2 68.56,88.04 68.78,87.83 68.78,87.12 68.56,86.9 66.05,86.9 65.82,87.14 65.82,99.37 65.64,99.55 v2(65.64,99.8) ; PC430.1 v10(57.61,124.62)
  GND1 w0.254: v4(57.12,123.96) 57.61,124.46 v10(57.61,124.62)
  IN2 w0.254: v2(65.64,99.8) 65.64,99.93 65.4,100.17 65.22,100.17 63.27,102.12 63.27,105.88 62.39,106.76 v4(62.39,107.02)
  IN3 w0.254: v4(57.12,123.96) 57.05,123.9 57.05,118.89 58.69,117.25 58.69,114.05 62.11,110.63 62.11,107.65 62.29,107.48 62.29,107.12 v4(62.39,107.02)
BQ24777_REGN: length 29.9
  TOP w0.203: PU400.24 57.61,128.16 57.77,128 58.38,128 59.34,127.03 v2(59.35,127.03)
  TOP w0.254: PR409.1 53.64,134.84 v2(53.63,134.86) ; PR418.2 60.2,126.18 v2(59.35,127.03)
  IN2 w0.254: v2(59.35,127.03) 59.34,127.03 ; 59.34,127.03 59.98,127.67 59.98,131.43 56.55,134.86 v2(53.63,134.86) ; 59.34,127.03 57.31,125 51.72,125 50.12,123.4 v2(50.12,121.7)
BT_OFF#_R: length 10.8
  TOP w0.119: v2(241.78,121.76) 241.78,122.17 241.8,122.19 R42.1 240.76,123.15 D4.1
  IN2 w0.084: v2(241.78,121.76) 241.89,121.88 245.96,121.88 246.22,121.62 JNGFF3.46
BT_ON/OFF#: length 145.7
  IN1 w0.089: v1(239.61,124.5) 242.03,124.5 242.51,124.99 243.03,124.99 244.36,123.66 244.36,118.44 243.77,117.84 242.11,117.84 238.94,114.68 233.52,114.68 232.12,116.07 230.8,116.07 230.44,115.72 225.74,115.72 225.59,115.57 218.64,115.57 217.59,114.52 217.59,112.59 216.73,111.73 v3(216.44,111.73)
  IN2 w0.06: 139.55,100.06 138.83,100.06 138.65,100.25 138.65,100.54 138.82,100.71 138.82,101.62 138.61,101.82 138.24,101.82 137.07,102.99 136.23,102.99 135.79,103.44 134.85,103.44 134.7,103.29 133.84,103.29 133.75,103.38 133.74,103.38 133.58,103.38 133.49,103.28 133.28,103.28 v2(133.17,103.18)
  IN2 w0.084: v3(216.44,111.73) 214.16,111.73 212.59,113.29 209.63,113.29 208.92,112.58 203.62,112.58 202.94,111.9 200.1,111.9 193.57,105.37 193.57,105.07 190.15,101.65 189.06,101.65 187.17,99.76 187.17,96.46 182.19,91.49 177.51,91.49 175.84,93.16 163.21,93.16 162.79,93.58 160.11,93.58 159.78,93.91 158.91,93.91 158.5,93.51 157.81,93.51 157.13,94.18 155.45,94.18 154.76,94.88 153.37,94.88 152.84,94.35 150.18,94.35 147.3,97.23 146.57,97.23 145.94,97.86 145.16,97.86 143.81,99.21 142.16,99.21 141.76,99.6 141.26,99.6 141.04,99.83 139.84,99.83 139.61,100.06 139.55,100.06
BT_RADIO_DIS#: length 24.4
  TOP w0.06: U27.L11 230.81,121.75 231.06,121.5 231.06,120.06 231.05,120.05
  TOP w0.119: D4.2 v1(242.77,124.5) ; 231.05,120.05 231.05,120.03 231.27,119.81 v1(231.48,119.81)
  IN1 w0.089: v1(242.77,124.5) 242.77,121.03 241.66,119.92 238.4,119.92 236.39,117.91 236.39,116.89 235.52,116.02 234.67,116.02 234.05,116.64 233.06,116.64 232.67,117.03 232.67,119.14 232.17,119.64 231.65,119.64 v1(231.48,119.81)
BT_UART_MUX_SEL: length 6.1
  TOP w0.119: v2(138.62,105.52) 138.87,105.27 TC27.1
  IN2 w0.06: v2(138.62,105.52) 138.61,105.53 136.55,105.53 136.47,105.6 135.15,105.6 134.99,105.44 134.17,105.44 133.84,105.11 133.18,105.11 v2(133.17,105.11)
CAM_PD: length 97.8
  TOP w0.119: R92.1 203.61,148.5 C1430.1 203.63,148.76 v2(203.46,148.93) ; v1(127.88,133.09) 127.64,133.33 J3.11
  IN1 w0.089: v1(127.88,133.09) 128.51,133.73 129.36,133.73 129.75,134.12 129.75,135.45 129.93,135.63 130.77,135.63 130.89,135.5 130.89,133.33 132.08,132.14 134.19,132.14 136.82,129.5 137.52,129.5 139.22,131.21 140.04,131.21 141.71,132.88 141.98,133.15 v3(141.98,134.51)
  IN2 w0.084: v2(203.46,148.93) 203.43,148.96 193.81,148.96 190.9,146.05 190.17,146.05 187.48,143.37 187.48,139.06 186.69,138.27 182.78,138.27 182.49,137.98 180.14,137.98 179.85,138.27 173.63,138.27 173.34,137.98 159.47,137.98 158.96,138.49 144.42,138.49 144.35,138.55 142.28,138.55 141.43,137.7 141.43,135.53 141.98,134.98 v3(141.98,134.51)
CD_WAKE#: length 2
  TOP w0.089: UR1.32 29.18,77.03 29.31,76.91 RR1.1
CEXT: length 2.1
  TOP w0.102: U23.17 51.83,95.17 51.41,95.59
  TOP w0.119: 51.41,95.59 C57.1
CFD_PWRBTN#_XDP: length 6.5
  TOP w0.119: RC66.2 122.21,92.96 CC162.2 121.77,92.35 121.57,92.15 118.68,92.15 v10(118.52,92.31)
  GND1 w0.119: v10(118.52,92.31) 118.5,92.29 118.5,91.7 v4(118.45,91.65)
  GND4 w0.119: v4(118.45,91.65) 118.45,91.6 v9(118.04,91.19)
CFG0: length 22.5
  TOP w0.152: v2(118.88,96.76) 119.23,96.4 RC42.1
  IN1 w0.06: 116.96,99.11 116.97,99.1 117.76,99.1 117.85,99 118.01,99 118.41,98.61 118.42,98.61 118.52,98.5 118.71,98.5 118.81,98.6 118.81,98.91 118.93,99.03 119.1,99.03 119.27,98.86 119.42,98.86 119.63,99.07 v2(119.99,99.07)
  IN1 w0.089: v5(115.68,99.2) 116.87,99.2 116.96,99.11
  GND1 w0.089: v4(115.3,99.09) 115.4,99.2 v5(115.68,99.2)
  IN2 w0.06: v2(119.99,99.07) 119.99,98.63 119.95,98.59 119.95,98.24 119.32,97.61 119.16,97.61 119.01,97.45 119.01,96.88 v2(118.88,96.76)
  GND4 w0.089: v4(115.3,99.09) 115.12,98.92 v9(115.12,98.71)
  BOTTOM w0.152: JXDP2.9 110.05,92.93 110.95,93.84 111.42,93.84 111.69,94.1 113.35,94.1 114.27,95.03 114.27,96.65 115.12,97.5 v9(115.12,98.71)
CFG0_R: length 0.9
  GND1 w0.089: v4(119.23,92.16) v10(119.23,92.67)
  GND4 w0.089: v4(119.23,92.16) 119.05,91.97 v9(119.05,91.8)
CFG1: length 13.5
  IN2 w0.06: 115.66,95.17 115.69,95.17 116.81,96.29 116.81,97.15 116.99,97.33 118.53,97.33 119.04,97.84 119.22,97.84 119.69,98.32 119.69,98.81 v2(119.67,98.83)
  IN2 w0.084: 115.66,95.17 115.45,94.96 v4(115.45,94.9)
  GND4 w0.089: v6(115.09,94.67) 115.22,94.67 v4(115.45,94.9)
  BOTTOM w0.152: v6(115.09,94.67) 114.64,94.67 113.66,93.7 111.86,93.7 111.59,93.43 111.12,93.43 110.55,92.85 JXDP2.11
CFG2: length 15.2
  IN2 w0.06: v2(119.99,99.57) 119.99,99.36 120.19,99.16 120.19,98.99 120.11,98.91 120.11,98.58 120.08,98.55 120.08,98.2 119.18,97.3 119.18,96.69 119.03,96.54 118.43,96.54 117.86,95.97 117.51,95.97 117.26,95.73 117,95.73 116.92,95.81 116.68,95.81 116.36,95.5 116.36,94.72 116.24,94.59
  IN2 w0.084: v4(114.89,94.27) 114.95,94.21 115.86,94.21 116.24,94.59
  IN3 w0.084: v4(114.89,94.27) 115.22,94.27 v6(115.35,94.39)
  BOTTOM w0.152: JXDP2.15 111.55,92.81 112.03,93.29 113.93,93.29 114.88,94.24 115.23,94.24 115.35,94.36 v6(115.35,94.39)
CFG3: length 19.5
  TOP w0.152: v1(108.44,92.51) 108.36,92.59 108.36,93.1 107.88,93.58 RC31.1
  IN1 w0.089: v2(110.74,92.08) 110.66,92.16 108.79,92.16 v1(108.44,92.51)
  GND1 w0.089: v4(111.44,91.75) 111.11,92.08 v2(110.74,92.08)
  IN2 w0.06: v2(119.67,99.32) 119.75,99.23 119.75,99.02 119.87,98.91 119.87,98.75 119.83,98.71 119.83,98.29 119.27,97.72 119.09,97.72 118.58,97.21 117.13,97.21 116.93,97.01 116.93,96.24 115.98,95.29 115.98,94.85
  IN2 w0.084: 115.98,94.85 115.68,94.55 115.22,94.55 115.04,94.72 114.62,94.72 113.99,94.09 111.92,94.09 111.53,93.7 111.53,93.07 110.74,92.29 v2(110.74,92.08)
  GND4 w0.089: v4(111.44,91.75) 111.72,91.47 112.02,91.47 v9(112.05,91.44)
CFG4: length 13.4
  TOP w0.152: v10(114.55,95.41) 114.43,95.41 114.19,95.17 114.19,94.6 RC152.2
  GND1 w0.089: v10(114.55,95.41) 114.55,95.45 114.87,95.77 v4(114.94,95.77)
  IN2 w0.06: 114.97,95.79 114.99,95.82 115.6,95.82 116.06,96.27 116.06,96.74 116.89,97.57 118.43,97.57 118.95,98.08 119.12,98.08 119.28,98.25 119.28,98.56 119.22,98.61 119.22,98.91 119.02,99.11 v2(119.02,99.33)
  IN2 w0.084: 114.97,95.79 v4(114.94,95.77)
  IN3 w0.084: v4(114.94,95.77) 114.83,95.66 114.83,94.83 114.49,94.49 114.49,93.96 114.82,93.63 v6(114.92,93.63)
  BOTTOM w0.152: v6(114.92,93.63) 114.55,93.26 JXDP2.27
CFG5: length 10.8
  IN2 w0.06: v4(114.51,96.49) 114.99,96.97 115.95,96.97 116.79,97.81 118.33,97.81 118.95,98.42 v2(118.96,98.42)
  GND4 w0.089: v6(114.69,96.12) 114.69,96.15 114.51,96.32 v4(114.51,96.49)
  BOTTOM w0.152: v6(114.69,96.12) 114.69,95.66 115.78,94.57 115.78,93.91 115.05,93.18 JXDP2.29
CFG6: length 11.6
  IN1 w0.06: v5(115.47,97.95) 115.47,97.72 116,97.2 117.18,97.2 117.93,97.95 118.12,97.95 118.25,98.09 v1(118.7,98.09)
  GND1 w0.089: v4(115.47,97.51) v5(115.47,97.95)
  GND4 w0.089: v4(115.47,97.51) v6(116,97.51)
  BOTTOM w0.152: JXDP2.33 116.05,93.57 116.26,93.78 116.26,94.7 115.63,95.33 115.63,96.35 115.82,96.54 116.07,96.54 116.24,96.71 116.24,97.29 116,97.53 v6(116,97.51)
CFG7: length 10.5
  IN2 w0.06: v2(119.02,98.83) 119.02,98.64 119.16,98.51 119.16,98.3 119.07,98.2 118.9,98.2 118.38,97.69 116.84,97.69 115.7,96.55 v4(115.7,96.44)
  GND4 w0.089: v6(115.93,96.12) 115.7,96.35 v4(115.7,96.44)
  BOTTOM w0.152: JXDP2.35 116.55,93 117.07,93.53 117.07,95.26 116.21,96.12 v6(115.93,96.12)
CFG8: length 25
  IN1 w0.06: v1(117.66,98.43) 117.44,98.64 117.02,98.64 116.97,98.69 116.21,98.69 116.06,98.84 115.18,98.84 115.13,98.79 114.23,98.79
  IN1 w0.089: 114.23,98.79 113.98,98.79 113.85,98.66 112.34,98.66 112.25,98.57 v5(112.25,98.56)
  GND1 w0.089: v5(112.25,98.56) 112.17,98.48 v4(112.17,98.15)
  GND4 w0.089: v6(111.77,98.2) 111.82,98.15 v4(112.17,98.15)
  BOTTOM w0.152: v6(111.77,98.2) 111.77,98.06 111.89,97.94 111.89,96.87 110.75,95.73 110.29,95.73 110.21,95.64 109.37,95.64 108.84,95.11 108.18,95.11 105.84,92.76 105.84,91.22 106.51,90.55 106.51,90.06 107.36,89.21 108.83,89.21 109.59,88.46 109.59,87.81 110.05,87.35 JXDP2.10
CFG9: length 24.4
  IN2 w0.06: v2(118.29,99.02) 118.29,98.73 117.86,98.3 116.6,98.3 116.34,98.03 113.97,98.03 112.95,97.02 112.95,96.39 112.81,96.25
  IN2 w0.084: v4(112.25,95.69) 112.81,96.25
  GND4 w0.089: v6(111.89,95.51) 112.07,95.69 v4(112.25,95.69)
  BOTTOM w0.152: v6(111.89,95.51) 111.11,95.51 110.92,95.32 110.46,95.32 110.37,95.24 109.54,95.24 109,94.7 108.35,94.7 106.25,92.61 106.25,91.49 106.91,90.83 106.91,90.25 107.54,89.63 109.05,89.63 109.99,88.69 109.99,87.97 110.55,87.42 JXDP2.12
CFG10: length 24.3
  IN2 w0.06: v2(118.38,98.36) 118.07,98.05 116.69,98.05 115.86,97.21 114.51,97.21 113.54,96.24 113.54,95.79
  IN2 w0.084: v4(113.54,95.36) 113.54,95.79
  GND4 w0.089: v6(113.29,95.66) 113.54,95.41 v4(113.54,95.36)
  BOTTOM w0.152: JXDP2.16 111.55,87.2 110.48,88.26 110.48,88.83 109.28,90.04 107.75,90.04 107.32,90.47 107.32,91.02 106.66,91.69 106.66,92.44 108.52,94.29 109.17,94.29 109.71,94.83 110.54,94.83 110.62,94.92 111.09,94.92 111.28,95.11 112.73,95.11 v6(113.29,95.66)
CFG11: length 21.6
  IN2 w0.06: v2(117.63,98.86) 117.24,99.25 115.88,99.25 115.2,98.56 113.68,98.56 112.43,97.32 111.74,97.32
  IN2 w0.084: 111.74,97.32 110.16,97.32 109.62,96.77 109.62,95.87 109.25,95.5 v4(109.25,95.33)
  IN3 w0.084: v6(112.26,88.72) 112.26,88.74 110.72,90.28 110.72,93.29 110.14,93.86 110.03,93.86 109.25,94.64 v4(109.25,95.33)
  BOTTOM w0.152: v6(112.26,88.72) 112.43,88.55 112.43,87.49 112.05,87.11 JXDP2.18
CFG12: length 23.4
  IN2 w0.06: 112.05,97.01 112.4,97.01 113.78,98.39 115.2,98.39 115.93,99.13 117.03,99.13 117.5,98.66 117.71,98.66 117.83,98.78 117.83,99.1 117.78,99.15 117.78,99.36 117.81,99.39 v2(117.81,99.64)
  IN2 w0.084: v4(109.76,95.28) 109.76,95.39 110.02,95.65 110.02,96.54 110.46,96.98 112.01,96.98 112.05,97.01
  IN3 w0.084: v4(109.76,95.28) 109.89,95.16 110.1,95.16 110.57,94.68 111.03,94.68 111.41,94.3 111.41,92.27 111.79,91.89 111.79,90.17 113.29,88.67 113.29,86.66 113.92,86.03 114.51,86.03 v6(114.55,86.07)
CFG13: length 34
  IN2 w0.06: 112.57,96.49 112.57,96.8 113.92,98.15 116.29,98.15 116.55,98.42 117.81,98.42 118.09,98.69 118.09,99.1 118.3,99.31 v2(118.3,99.51)
  IN2 w0.084: 112.57,96.49 112.2,96.12 111.94,96.12 111.69,95.87 v4(111,95.87)
  GND4 w0.089: v6(110.73,96.14) 110.78,96.14 111,95.91 v4(111,95.87)
  BOTTOM w0.152: JXDP2.30 115.05,84.92 114.88,84.76 107.79,84.76 107.55,85 107.55,88.43 106.1,89.87 106.1,90.32 105.42,91 105.42,92.92 108.01,95.51 108.67,95.51 109.2,96.05 109.95,96.05 110.04,96.14 v6(110.73,96.14)
CFG14: length 35.6
  IN2 w0.06: 117.45,99.42 115.12,99.42 114.98,99.28 114.98,98.95 114.71,98.69 113.62,98.69 112.6,97.67 111.45,97.67
  IN2 w0.084: v4(109.02,95.93) 109.28,96.19 109.28,96.91 110.04,97.67 111.45,97.67 ; v2(117.56,99.31) 117.45,99.42
  GND4 w0.089: v9(108.49,95.94) 109.01,95.94 v4(109.02,95.93)
  BOTTOM w0.152: v9(108.49,95.94) 107.87,95.94 105,93.07 105,90.98 105.72,90.25 105.72,89.64 107.04,88.32 107.04,84.92 107.61,84.35 115.61,84.35 116.05,84.78 JXDP2.34
CFG15: length 37.8
  IN2 w0.06: v2(117.98,99.27) 117.95,99.25 117.95,98.73 117.76,98.54 116.5,98.54 116.24,98.27 113.87,98.27 112.15,96.55
  IN2 w0.084: v4(110.37,96.38) 110.52,96.22 111.56,96.22 111.89,96.55 112.15,96.55
  GND4 w0.089: v6(110.01,96.59) 110.15,96.59 v4(110.37,96.38)
  BOTTOM w0.152: v6(110.01,96.59) 109.92,96.59 109.79,96.46 107.8,96.46 104.59,93.24 104.59,90.9 105.37,90.12 105.37,89.38 106.64,88.11 106.64,84.67 107.36,83.94 115.83,83.94 116.55,84.66 JXDP2.36
CFG16: length 20.7
  IN2 w0.06: 115.39,95.44 115.62,95.66 116.02,95.66 116.69,96.34 116.69,97.2 116.94,97.45 118.48,97.45 119,97.96 119.17,97.96 119.47,98.26 119.47,98.83 119.46,98.83 119.46,98.91 119.47,98.91 119.54,98.99 119.54,99.16 119.45,99.25 119.45,99.25 119.34,99.36 v2(119.34,99.57)
  IN2 w0.084: 115.39,95.44 115.21,95.26 114.68,95.26 113.88,94.46 111.81,94.46 110.64,93.29 110.64,93.14 v4(110.37,92.87)
  IN3 w0.084: v6(109.05,86.07) 109.66,86.68 109.66,89.51 110.37,90.22 v4(110.37,92.87)
CFG17: length 25
  IN1 w0.06: v2(119.34,99.07) 119.34,99.28 119.65,99.59 v3(119.65,99.69)
  IN2 w0.06: v3(119.65,99.69) 119.5,99.69 119.43,99.77 118.83,99.77 118.71,99.88 117.64,99.88 117.3,99.54 115.07,99.54 114.86,99.33 114.86,99 114.67,98.81 113.42,98.81 113.06,98.46 111.61,98.46 111.21,98.05 111,98.05
  IN2 w0.084: 111,98.05 109.45,98.05 108.52,97.11 108.52,95.69 v4(108.73,95.47)
  IN3 w0.084: v4(108.73,95.47) 108.73,93.78 109.37,93.15 109.37,90.62 108.83,90.09 v6(108.83,88.74)
  BOTTOM w0.152: v6(108.83,88.74) 108.83,87.71 108.55,87.43 JXDP2.4
