# Allegro board LAC321PR10-0907B.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
ESD3V3S1B-02LS_PG-TSSLP-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD207-B1-02EL_TSLP-2-19-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G677L308A31U_ADFN6_1P5X1P5
  oval 0.254x1.092 smd: 1(0,0)
  oval 0.254x0.991 smd: 2(0.5,-0.051) 3(1,-0.051) 4(1,1.449) 5(0.5,1.449) 6(0,1.449)
H_1P2
  round 1.702 hole 1.194: 1(0,0)
H_1P3
  round 1.803 hole 1.295: 1(0,0)
H_1P3X2P3
  oval 1.803x2.819 hole 1.295x2.311: 1(0,0)
H_2P0X0P4N
  oval 2.007x0.406 hole 2.007x0.406 unplated: (0,0)
H_4P6
  round 5.105 hole 4.597: 1(0,0)
H_5P2
  round 5.715 hole 5.207: 1(0,0)
HRS_DF37NC-30DS-0P4V-51_30P-T
  oval 0.203x0.635 smd: 1(0,0) 2(0,-2.65) 3(0.4,0) 4(0.4,-2.65) 5(0.8,0) 6(0.8,-2.65) 7(1.2,0) 8(1.2,-2.65) 9(1.6,0) 10(1.6,-2.65) 11(2,0) 12(2,-2.65) 13(2.4,0) 14(2.4,-2.65) 15(2.8,0) 16(2.8,-2.65) 17(3.2,0) 18(3.2,-2.65) 19(3.6,0) 20(3.6,-2.65) 21(4,0) 22(4,-2.65) 23(4.4,0) 24(4.4,-2.65) 25(4.8,0) 26(4.8,-2.65) 27(5.2,0) 28(5.2,-2.65) 29(5.6,0) 30(5.6,-2.65)
HRS_DF40B-12DS-0P4V-51_12P-T
  oval 0.203x0.711 smd: 1(0,0) 2(0,-3.08) 3(0.4,0) 4(0.4,-3.08) 5(0.8,0) 6(0.8,-3.08) 7(1.2,0) 8(1.2,-3.08) 9(1.6,0) 10(1.6,-3.08) 11(2,0) 12(2,-3.08)
  rect 0.356x0.711 smd: 13(-1.2,0) 14(3.2,0) 15(-1.2,-3.08) 16(3.2,-3.08)
HRS_DF40C-24DS-0P4V-51_24P-T
  oval 0.203x0.711 smd: 1(0,0) 2(0,-3.08) 3(0.4,0) 4(0.4,-3.08) 5(0.8,0) 6(0.8,-3.08) 7(1.2,0) 8(1.2,-3.08) 9(1.6,0) 10(1.6,-3.08) 11(2,0) 12(2,-3.08) 13(2.4,0) 14(2.4,-3.08) 15(2.8,0) 16(2.8,-3.08) 17(3.2,0) 18(3.2,-3.08) 19(3.6,0) 20(3.6,-3.08) 21(4,0) 22(4,-3.08) 23(4.4,0) 24(4.4,-3.08)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
JAE_DX07B024XJ1_24P-T
  round 0.711 hole 0.711 unplated: (-0.85,-0.66)
  oval 0.94x0.711 hole 0.94x0.711 unplated: (6.35,-0.66)
  oval 1.092x1.956 hole 0.61x1.448: 1(-2.05,-1.535) 2(7.55,-1.535)
  oval 1.092x2.388 hole 0.61x1.6: 3(-3.05,-5.76) 4(8.55,-5.76)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.21) B2(5.15,-2.01) B3(4.35,-2.01) B4(4.1,-1.21) B5(3.55,-2.01) B6(3.15,-1.21) B7(2.35,-1.21) B8(1.95,-2.01) B9(1.4,-1.21) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.21)
JAE_SF56S006V4A_6P-T
  oval 1.194x0.787 smd: 1(0,0) 2(-2.19,0) 3(-4.38,0) 4(0,1.1) 5(-2.19,1.1) 6(-4.38,1.1)
  rect 1.194x2.362 smd: 7(-9.06,10.465)
  rect 0.991x0.66 smd: 8(-1.66,11.765)
  rect 1.753x1.295 smd: 9(0.21,11.44)
  rect 1.194x1.397 smd: 10(-9.46,-3.41)
  rect 0.991x1.092 smd: 11(4.24,-3.56)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_WCM-2012HS-900T_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,-0.8) 4(0,-0.8)
L06ESDU5V0CE2_SOD-882-2
  rect 0.559x0.787 smd: 1(0,0) 2(0.75,0)
LM393DMR2G_MICRO8
  oval 0.381x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.24) 6(1.3,4.24) 7(0.65,4.24) 8(0,4.24)
LOTES_APCI0114-P001A_67P
  round 1.143 hole 1.143 unplated: (-1.75,-1.55)
  round 1.651 hole 1.651 unplated: (20.25,-1.55)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(3,0) 15(3.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(8,0) 27(8.5,0) 29(9,0) 31(9.5,0) 33(10,0) 35(10.5,0) 37(11,0) 39(11.5,0) 41(12,0) 43(12.5,0) 45(13,0) 47(13.5,0) 49(14,0) 51(14.5,0) 53(15,0) 55(15.5,0) 57(16,0) 59(16.5,0) 61(17,0) 63(17.5,0) 65(18,0) 67(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.85) 4(0.75,-2.05) 6(1.25,-2.85) 8(1.75,-2.05) 10(2.25,-2.85) 12(2.75,-2.05) 14(3.25,-2.85) 16(3.75,-2.05) 18(4.25,-2.85) 20(4.75,-2.05) 22(5.25,-2.85) 24(7.75,-2.05) 26(8.25,-2.85) 28(8.75,-2.05) 30(9.25,-2.85) 32(9.75,-2.05) 34(10.25,-2.85) 36(10.75,-2.05) 38(11.25,-2.85) 40(11.75,-2.05) 42(12.25,-2.85) 44(12.75,-2.05) 46(13.25,-2.85) 48(13.75,-2.05) 50(14.25,-2.85) 52(14.75,-2.05) 54(15.25,-2.85) 56(15.75,-2.05) 58(16.25,-2.85) 60(16.75,-2.05) 62(17.25,-2.85) 64(17.75,-2.05) 66(18.25,-2.85)
  rect 1.194x2.743 smd: 68(20.635,-6.52) 69(-2.135,-6.52)
LOTES_APCI0133-P001A_67P-T
  round 1.143 hole 1.143 unplated: (-1.75,-1.55)
  round 1.651 hole 1.651 unplated: (20.25,-1.55)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(5,0) 15(5.5,0) 17(6,0) 19(6.5,0) 21(7,0) 23(7.5,0) 25(8,0) 27(8.5,0) 29(9,0) 31(9.5,0) 33(10,0) 35(10.5,0) 37(11,0) 39(11.5,0) 41(12,0) 43(12.5,0) 45(13,0) 47(13.5,0) 49(14,0) 51(14.5,0) 53(15,0) 55(15.5,0) 57(16,0) 59(16.5,0) 61(17,0) 63(17.5,0) 65(18,0) 67(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.85) 4(0.75,-2.05) 6(1.25,-2.85) 8(1.75,-2.05) 10(2.25,-2.85) 12(4.75,-2.05) 14(5.25,-2.85) 16(5.75,-2.05) 18(6.25,-2.85) 20(6.75,-2.05) 22(7.25,-2.85) 24(7.75,-2.05) 26(8.25,-2.85) 28(8.75,-2.05) 30(9.25,-2.85) 32(9.75,-2.05) 34(10.25,-2.85) 36(10.75,-2.05) 38(11.25,-2.85) 40(11.75,-2.05) 42(12.25,-2.85) 44(12.75,-2.05) 46(13.25,-2.85) 48(13.75,-2.05) 50(14.25,-2.85) 52(14.75,-2.05) 54(15.25,-2.85) 56(15.75,-2.05) 58(16.25,-2.85) 60(16.75,-2.05) 62(17.25,-2.85) 64(17.75,-2.05) 66(18.25,-2.85)
  rect 1.194x2.743 smd: 68(-2.135,-6.52) 69(20.635,-6.52)
LOTES_APCI0170-P001A_75P-T
  round 1.143 hole 1.143 unplated: (-1.75,-1.55)
  round 1.651 hole 1.651 unplated: (20.25,-1.55)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(3,0) 15(3.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.85) 4(0.75,-2.05) 6(1.25,-2.85) 8(1.75,-2.05) 10(2.25,-2.85) 12(2.75,-2.05) 14(3.25,-2.85) 16(3.75,-2.05) 18(4.25,-2.85) 20(4.75,-2.05) 22(5.25,-2.85) 24(5.75,-2.05) 26(6.25,-2.85) 28(6.75,-2.05) 30(7.25,-2.85) 32(7.75,-2.05) 34(8.25,-2.85) 36(8.75,-2.05) 38(9.25,-2.85) 40(9.75,-2.05) 42(10.25,-2.85) 44(10.75,-2.05) 46(11.25,-2.85) 48(11.75,-2.05) 50(12.25,-2.85) 52(12.75,-2.05) 54(13.25,-2.85) 56(13.75,-2.05) 58(14.25,-2.85) 68(16.75,-2.05) 70(17.25,-2.85) 72(17.75,-2.05) 74(18.25,-2.85)
  rect 1.194x2.743 smd: 76(-2.135,-6.52) 77(20.635,-6.52)
LSM9DS1TR_LGA24_3P5X3
  oval 0.229x0.66 smd: 1(0,0) 6(0,-2.65) 7(0.43,-2.65) 8(0.86,-2.65) 9(1.29,-2.65) 10(1.72,-2.65) 11(2.15,-2.65) 12(2.58,-2.65) 13(3.01,-2.65) 18(3.01,0) 19(2.58,0) 20(2.15,0) 21(1.72,0) 22(1.29,0) 23(0.86,0) 24(0.43,0)
  oval 0.66x0.229 smd: 2(-0.07,-0.68) 3(-0.07,-1.11) 4(-0.07,-1.54) 5(-0.07,-1.97) 14(3.08,-1.97) 15(3.08,-1.54) 16(3.08,-1.11) 17(3.08,-0.68)
MAG_MMD-04AB-R47M-V2_2P
  rect 1.905x2.311 smd: 1(0,0) 2(3.055,0)
MAG_MMD-04AE-R47M-M1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-05ABHR47M-T1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-05ABHR47MET1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MEC1641-PZV_TFBGA_144P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) C5(2.001,-1) C6(2.501,-1) C7(3.001,-1) C8(3.501,-1) C9(4.001,-1) C10(4.501,-1) C11(5.001,-1) C12(5.501,-1) C13(6.002,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E3(1,-2.001) E4(1.5,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F3(1,-2.501) F4(1.5,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G3(1,-3.001) G4(1.5,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H3(1,-3.501) H4(1.5,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J3(1,-4.001) J4(1.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MURAT_BLM15AX100SN1D_2P
  rect 0.457x0.508 smd: 1(-0.05,0) 2(0.8,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX181SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18EG221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLW21HN900HQ2L_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_LQG15HS10NJ02D_2P
  rect 0.559x0.508 smd: 1(0,0) 2(0.95,0)
NPCT650JAAYX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
OPA376AIDCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
P_SN74LVC1G02DCKR_SC70_5P
  oval 0.33x0.762 smd: 1(-0.65,-0.97) 2(0,-0.97) 3(0.65,-0.97) 4(0.65,0.97) 5(-0.65,0.97)
PANAS_AXT580124_80P-T
  oval 0.203x0.914 smd: 1(0,0) 2(0,-3.28) 3(0.4,0) 4(0.4,-3.28) 5(0.8,0) 6(0.8,-3.28) 7(1.2,0) 8(1.2,-3.28) 9(1.6,0) 10(1.6,-3.28) 11(2,0) 12(2,-3.28) 13(2.4,0) 14(2.4,-3.28) 15(2.8,0) 16(2.8,-3.28) 17(3.2,0) 18(3.2,-3.28) 19(3.6,0) 20(3.6,-3.28) 21(4,0) 22(4,-3.28) 23(4.4,0) 24(4.4,-3.28) 25(4.8,0) 26(4.8,-3.28) 27(5.2,0) 28(5.2,-3.28) 29(5.6,0) 30(5.6,-3.28) 31(6,0) 32(6,-3.28) 33(6.4,0) 34(6.4,-3.28) 35(6.8,0) 36(6.8,-3.28) 37(7.2,0) 38(7.2,-3.28) 39(7.6,0) 40(7.6,-3.28) 41(8,0) 42(8,-3.28) 43(8.4,0) 44(8.4,-3.28) 45(8.8,0) 46(8.8,-3.28) 47(9.2,0) 48(9.2,-3.28) 49(9.6,0) 50(9.6,-3.28) 51(10,0) 52(10,-3.28) 53(10.4,0) 54(10.4,-3.28) 55(10.8,0) 56(10.8,-3.28) 57(11.2,0) 58(11.2,-3.28) 59(11.6,0) 60(11.6,-3.28) 61(12,0) 62(12,-3.28) 63(12.4,0) 64(12.4,-3.28) 65(12.8,0) 66(12.8,-3.28) 67(13.2,0) 68(13.2,-3.28) 69(13.6,0) 70(13.6,-3.28) 71(14,0) 72(14,-3.28) 73(14.4,0) 74(14.4,-3.28) 75(14.8,0) 76(14.8,-3.28) 77(15.2,0) 78(15.2,-3.28) 79(15.6,0) 80(15.6,-3.28)
  rect 0.711x1.194 smd: 81(-0.9,-0.14) 82(-0.9,-3.14) 83(16.5,-0.14) 84(16.5,-3.14)
PD3S230L-7_POWERDI323-2
  rect 2.007x1.092 smd: 1(0,0)
  rect 0.787x0.787 smd: 2(1.9,0)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PJSOT24CW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PMDXB600UNE_DFN1010B-6
  oval 0.254x0.305 smd: 1(0,0) 2(0.35,0) 3(0.7,0) 4(0.7,0.85) 5(0.35,0.85) 6(0,0.85)
PS8338BQFN60GTR-A0_QFN60_5X9
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RCLAMP0524PATCT_SLP2510P8-10-9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
RT9069-33GB_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.94,0) 3(1.879,0) 4(1.879,2.339) 5(0,2.339)
RTS5242-GR_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SAMTE_BSH-030-01-L-D-A-TR_60P-S
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2303CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI2336DS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SKL-Y-REV1P2_BGA_1515P-T
  round 0.305 smd: A5(0.909,0) A7(1.364,0) A9(1.903,0) A11(2.547,0) A14(3.191,0) A16(3.835,0) A18(4.479,0) A20(5.123,0) A22(5.768,0) A24(6.412,0) A26(7.056,0) A28(7.7,0) A30(8.344,0) A32(8.988,0) A34(9.632,0) A36(10.277,0) A38(10.921,0) A40(11.565,0) A42(12.209,0) A44(12.853,0) A46(13.497,0) A48(14.141,0) A50(14.786,0) A52(15.43,0) A54(16.074,0) A56(16.718,0) A58(17.263,0) A60(17.711,0) A62(18.166,0) A64(18.621,0) AA2(0.272,-5.609) AA4(0.765,-5.609) AA6(1.257,-5.609) AA8(1.75,-5.609) AA10(2.243,-5.609) AA12(2.736,-5.609) AA53(15.885,-5.609) AA55(16.378,-5.609) AA57(16.871,-5.609) AB1(0,-5.931) AB3(0.518,-5.931) AB5(1.011,-5.931) AB7(1.504,-5.931) AB9(1.996,-5.931) AB11(2.489,-5.931) AB13(2.982,-5.936) AB54(16.132,-5.931) AB56(16.624,-5.931) AB58(17.117,-5.931) AB64(18.621,-5.931) AC2(0.272,-6.253) AC4(0.765,-6.253) AC6(1.257,-6.253) AC8(1.75,-6.253) AC10(2.243,-6.253) AC12(2.736,-6.253) AC53(15.885,-6.253) AC55(16.378,-6.253) AC57(16.871,-6.253) AD1(0,-6.575) AD3(0.518,-6.575) AD5(1.011,-6.575) AD7(1.504,-6.575) AD9(1.996,-6.575) AD11(2.489,-6.575) AD13(2.982,-6.58) AD54(16.132,-6.575) AD56(16.624,-6.575) AD58(17.117,-6.575) AD64(18.621,-6.575) AE2(0.272,-6.897) AE4(0.765,-6.897) AE6(1.257,-6.897) AE8(1.75,-6.897) AE10(2.243,-6.897) AE12(2.736,-6.897) AE53(15.885,-6.897) AE55(16.378,-6.897) AE57(16.871,-6.897) AF1(0,-7.219) AF3(0.518,-7.219) AF5(1.011,-7.219) AF7(1.504,-7.219) AF9(1.996,-7.219) AF11(2.489,-7.219) AF13(2.982,-7.224) AF54(16.132,-7.219) AF56(16.624,-7.219) AF58(17.117,-7.219) AF60(17.61,-7.219) AF62(18.103,-7.219) AF64(18.621,-7.219) AG2(0.272,-7.541) AG4(0.765,-7.541) AG6(1.257,-7.541) AG8(1.75,-7.541) AG10(2.243,-7.541) AG12(2.736,-7.541) AG53(15.885,-7.541) AG55(16.378,-7.541) AG57(16.871,-7.541) AG59(17.363,-7.541) AG61(17.856,-7.541) AG63(18.349,-7.541) AH1(0,-7.863) AH3(0.518,-7.863) AH5(1.011,-7.863) AH7(1.504,-7.863) AH9(1.996,-7.863) AH11(2.489,-7.863) AH13(2.982,-7.868) AH54(16.132,-7.863) AH56(16.624,-7.863) AH58(17.117,-7.863) AH60(17.61,-7.863) AH62(18.103,-7.863) AH64(18.621,-7.863) AJ2(0.272,-8.185) AJ4(0.765,-8.185) AJ6(1.257,-8.185) AJ8(1.75,-8.185) AJ10(2.243,-8.185) AJ12(2.736,-8.185) AJ53(15.885,-8.185) AJ55(16.378,-8.185) AJ57(16.871,-8.185) AJ59(17.363,-8.185) AJ61(17.856,-8.185) AJ63(18.349,-8.185) AK1(0,-8.507) AK3(0.518,-8.507) AK5(1.011,-8.507) AK7(1.504,-8.507) AK9(1.996,-8.507) AK11(2.489,-8.507) AK13(2.982,-8.512) AK54(16.132,-8.507) AK56(16.624,-8.507) AK58(17.117,-8.507) AK60(17.61,-8.507) AK62(18.103,-8.507) AK64(18.621,-8.507) AL2(0.272,-8.829) AL4(0.765,-8.829) AL6(1.257,-8.829) AL8(1.75,-8.829) AL10(2.243,-8.829) AL12(2.736,-8.829) AL53(15.885,-8.829) AL55(16.378,-8.829) AL57(16.871,-8.829) AL59(17.363,-8.829) AL61(17.856,-8.829) AL63(18.349,-8.829) AM1(0,-9.151) AM3(0.518,-9.151) AM5(1.011,-9.151) AM7(1.504,-9.151) AM9(1.996,-9.151) AM11(2.489,-9.151) AM13(2.982,-9.156) AM54(16.132,-9.151) AM56(16.624,-9.151) AM58(17.117,-9.151) AM60(17.61,-9.151) AM62(18.103,-9.151) AM64(18.621,-9.151) AN2(0.272,-9.473) AN4(0.765,-9.473) AN6(1.257,-9.473) AN8(1.75,-9.473) AN10(2.243,-9.473) AN12(2.736,-9.473) AN53(15.885,-9.473) AN55(16.378,-9.473) AN57(16.871,-9.473) AN59(17.363,-9.473) AN61(17.856,-9.473) AN63(18.349,-9.473) AP1(0,-9.796) AP3(0.518,-9.796) AP5(1.011,-9.796) AP7(1.504,-9.796) AP9(1.996,-9.796) AP11(2.489,-9.796) AP13(2.982,-9.801) AP54(16.132,-9.796) AP56(16.624,-9.796) AP58(17.117,-9.796) AP60(17.61,-9.796) AP62(18.103,-9.796) AP64(18.621,-9.796) AR2(0.272,-10.118) AR4(0.765,-10.118) AR6(1.257,-10.118) AR8(1.75,-10.118) AR10(2.243,-10.118) AR12(2.736,-10.118) AR53(15.885,-10.118) AR55(16.378,-10.118) AR57(16.871,-10.118) AR59(17.363,-10.118) AR61(17.856,-10.118) AR63(18.349,-10.118) AT1(0,-10.44) AT3(0.518,-10.44) AT5(1.011,-10.44) AT7(1.504,-10.44) AT9(1.996,-10.44) AT11(2.489,-10.44) AT13(2.982,-10.445) AT54(16.132,-10.44) AT56(16.624,-10.44) AT58(17.117,-10.44) AT60(17.61,-10.44) AT62(18.103,-10.44) AT64(18.621,-10.44) AU2(0.272,-10.762) AU4(0.765,-10.762) AU6(1.257,-10.762) AU8(1.75,-10.762) AU10(2.243,-10.762) AU12(2.736,-10.762) AU53(15.885,-10.762) AU55(16.378,-10.762) AU57(16.871,-10.762) AU59(17.363,-10.762) AU61(17.856,-10.762) AU63(18.349,-10.762) AV1(0,-11.084) AV3(0.518,-11.084) AV5(1.011,-11.084) AV7(1.504,-11.084) AV9(1.996,-11.084) AV11(2.489,-11.084) AV13(2.982,-11.084) AV15(3.429,-11.115) AV16(3.835,-11.115) AV18(4.479,-11.115) AV20(5.123,-11.115) AV22(5.768,-11.115) AV24(6.412,-11.115) AV26(7.056,-11.115) AV28(7.7,-11.115) AV30(8.344,-11.115) AV32(8.988,-11.115) AV34(9.632,-11.115) AV36(10.277,-11.115) AV38(10.921,-11.115) AV40(11.565,-11.115) AV42(12.209,-11.115) AV44(12.853,-11.115) AV46(13.497,-11.115) AV48(14.141,-11.115) AV50(14.786,-11.115) AV52(15.43,-11.115) AV54(16.132,-11.084) AV56(16.624,-11.084) AV58(17.117,-11.084) AV60(17.61,-11.084) AV62(18.103,-11.084) AV64(18.621,-11.084) AW2(0.272,-11.406) AW4(0.765,-11.406) AW6(1.257,-11.406) AW8(1.75,-11.406) AW10(2.243,-11.406) AW12(2.736,-11.406) AW17(4.157,-11.361) AW19(4.801,-11.361) AW21(5.446,-11.361) AW23(6.09,-11.361) AW25(6.734,-11.361) AW27(7.378,-11.361) AW29(8.022,-11.361) AW31(8.666,-11.361) AW33(9.31,-11.361) AW35(9.955,-11.361) AW37(10.599,-11.361) AW39(11.243,-11.361) AW41(11.887,-11.361) AW43(12.531,-11.361) AW45(13.175,-11.361) AW47(13.819,-11.361) AW49(14.464,-11.361) AW51(15.108,-11.361) AW53(15.752,-11.369) AW55(16.378,-11.406) AW57(16.871,-11.406) AW59(17.363,-11.406) AW61(17.856,-11.406) AW63(18.349,-11.406) AY14(3.316,-11.501) AY16(3.835,-11.607) AY18(4.479,-11.607) AY20(5.123,-11.607) AY22(5.768,-11.607) AY24(6.412,-11.607) AY26(7.056,-11.607) AY28(7.7,-11.607) AY30(8.344,-11.607) AY32(8.988,-11.607) AY34(9.632,-11.607) AY36(10.277,-11.607) AY38(10.921,-11.607) AY40(11.565,-11.607) AY42(12.209,-11.607) AY44(12.853,-11.607) AY46(13.497,-11.607) AY48(14.141,-11.607) AY50(14.786,-11.607) AY52(15.43,-11.607) B3(0.429,-0.429) B4(0.859,-0.429) B6(1.288,-0.429) B8(1.717,-0.429) B10(2.225,-0.272) B12(2.869,-0.272) B15(3.513,-0.272) B17(4.157,-0.272) B19(4.801,-0.272) B21(5.446,-0.272) B23(6.09,-0.272) B25(6.734,-0.272) B27(7.378,-0.272) B29(8.022,-0.272) B31(8.666,-0.272) B33(9.31,-0.272) B35(9.955,-0.272) B37(10.599,-0.272) B39(11.243,-0.272) B41(11.887,-0.272) B43(12.531,-0.272) B45(13.175,-0.272) B47(13.819,-0.272) B49(14.464,-0.272) B51(15.108,-0.272) B53(15.752,-0.272) B55(16.396,-0.272) B58(17.088,-0.363) B61(17.79,-0.429) B62(18.191,-0.429) B64(18.621,-0.455) BA1(0,-11.728) BA3(0.518,-11.728) BA5(1.011,-11.728) BA7(1.504,-11.728) BA9(1.996,-11.728) BA11(2.489,-11.728) BA13(2.982,-11.728) BA15(3.513,-11.854) BA17(4.157,-11.854) BA19(4.801,-11.854) BA21(5.446,-11.854) BA23(6.09,-11.854) BA25(6.734,-11.854) BA27(7.378,-11.854) BA29(8.022,-11.854) BA31(8.666,-11.854) BA33(9.31,-11.854) BA35(9.955,-11.854) BA37(10.599,-11.854) BA39(11.243,-11.854) BA41(11.887,-11.854) BA43(12.531,-11.854) BA45(13.175,-11.854) BA47(13.819,-11.854) BA49(14.464,-11.854) BA51(15.108,-11.854) BA53(15.752,-11.861) BA56(16.624,-11.728) BA58(17.117,-11.728) BA60(17.61,-11.728) BA62(18.103,-11.728) BA64(18.621,-11.728) BB2(0.272,-12.05) BB4(0.765,-12.05) BB6(1.257,-12.05) BB8(1.75,-12.05) BB10(2.243,-12.05) BB12(2.762,-12.1) BB14(3.191,-12.1) BB16(3.835,-12.1) BB18(4.479,-12.1) BB20(5.123,-12.1) BB22(5.768,-12.1) BB24(6.412,-12.1) BB26(7.056,-12.1) BB28(7.7,-12.1) BB30(8.344,-12.1) BB32(8.988,-12.1) BB34(9.632,-12.1) BB36(10.277,-12.1) BB38(10.921,-12.1) BB40(11.565,-12.1) BB42(12.209,-12.1) BB44(12.853,-12.1) BB46(13.497,-12.1) BB48(14.141,-12.1) BB50(14.786,-12.1) BB52(15.43,-12.1) BB54(16.074,-12.1) BB57(16.871,-12.05) BB59(17.363,-12.05) BB61(17.856,-12.05) BB63(18.349,-12.05) BC1(0,-12.372) BC3(0.518,-12.372) BC5(1.011,-12.372) BC7(1.504,-12.372) BC9(1.996,-12.372) BC11(2.615,-12.519) BC15(3.513,-12.346) BC17(4.157,-12.346) BC19(4.801,-12.346) BC21(5.446,-12.346) BC23(6.09,-12.346) BC25(6.734,-12.346) BC27(7.378,-12.346) BC29(8.022,-12.346) BC31(8.666,-12.346) BC33(9.31,-12.346) BC35(9.955,-12.346) BC37(10.599,-12.346) BC39(11.243,-12.346) BC41(11.887,-12.346) BC43(12.531,-12.346) BC45(13.175,-12.346) BC47(13.819,-12.346) BC49(14.464,-12.346) BC51(15.108,-12.346) BC53(15.752,-12.346) BC55(16.396,-12.346) BC58(17.117,-12.372) BC60(17.61,-12.372) BC62(18.103,-12.372) BC64(18.621,-12.372) BD2(0.272,-12.694) BD4(0.765,-12.694) BD6(1.257,-12.694) BD8(1.75,-12.694) BD10(2.243,-12.69) BD14(3.191,-12.593) BD16(3.835,-12.593) BD18(4.479,-12.593) BD20(5.123,-12.593) BD22(5.768,-12.593) BD24(6.412,-12.593) BD26(7.056,-12.593) BD28(7.7,-12.593) BD30(8.344,-12.593) BD32(8.988,-12.593) BD34(9.632,-12.593) BD36(10.277,-12.593) BD38(10.921,-12.593) BD40(11.565,-12.593) BD42(12.209,-12.593) BD44(12.853,-12.593) BD46(13.497,-12.593) BD48(14.141,-12.593) BD50(14.786,-12.593) BD52(15.43,-12.593) BD54(16.074,-12.593) BD56(16.718,-12.593) BD59(17.443,-12.778) BD61(17.856,-12.694) BD63(18.349,-12.694) BE12(2.869,-12.839) BE15(3.513,-12.839) BE17(4.157,-12.839) BE19(4.801,-12.839) BE21(5.446,-12.839) BE23(6.09,-12.839) BE25(6.734,-12.839) BE27(7.378,-12.839) BE29(8.022,-12.839) BE31(8.666,-12.839) BE33(9.31,-12.839) BE35(9.955,-12.839) BE37(10.599,-12.839) BE39(11.243,-12.839) BE41(11.887,-12.839) BE43(12.531,-12.839) BE45(13.175,-12.839) BE47(13.819,-12.839) BE49(14.464,-12.839) BE51(15.108,-12.839) BE53(15.752,-12.839) BE55(16.396,-12.839) BE57(17.04,-12.839) BF1(0,-13.016) BF3(0.518,-13.016) BF5(1.011,-13.016) BF7(1.504,-13.016) BF9(2.002,-13.021) BF11(2.547,-13.086) BF14(3.191,-13.086) BF16(3.835,-13.086) BF18(4.479,-13.086) BF20(5.123,-13.086) BF22(5.768,-13.086) BF24(6.412,-13.086) BF26(7.056,-13.086) BF28(7.7,-13.086) BF30(8.344,-13.086) BF32(8.988,-13.086) BF34(9.632,-13.086) BF36(10.277,-13.086) BF38(10.921,-13.086) BF40(11.565,-13.086) BF42(12.209,-13.086) BF44(12.853,-13.086) BF46(13.497,-13.086) BF48(14.141,-13.086) BF50(14.786,-13.086) BF52(15.43,-13.086) BF54(16.074,-13.086) BF56(16.718,-13.086) BF59(17.474,-13.18) BF62(18.103,-13.016) BF64(18.621,-13.016) BG2(0.272,-13.338) BG4(0.765,-13.338) BG6(1.257,-13.338) BG8(1.75,-13.338) BG10(2.14,-13.431) BG12(2.869,-13.332) BG15(3.513,-13.332) BG17(4.157,-13.332) BG19(4.801,-13.332) BG21(5.446,-13.332) BG23(6.09,-13.332) BG25(6.734,-13.332) BG27(7.378,-13.332) BG29(8.022,-13.332) BG31(8.666,-13.332) BG33(9.31,-13.332) BG35(9.955,-13.332) BG37(10.599,-13.332) BG39(11.243,-13.332) BG41(11.887,-13.332) BG43(12.531,-13.332) BG45(13.175,-13.332) BG47(13.819,-13.332) BG49(14.464,-13.332) BG51(15.108,-13.332) BG53(15.752,-13.332) BG55(16.396,-13.332) BG57(17.04,-13.332) BG61(17.856,-13.338) BG63(18.349,-13.338) BH11(2.547,-13.578) BH14(3.191,-13.578) BH16(3.835,-13.578) BH18(4.479,-13.578) BH20(5.123,-13.578) BH22(5.768,-13.578) BH24(6.412,-13.578) BH26(7.056,-13.578) BH28(7.7,-13.578) BH30(8.344,-13.578) BH32(8.988,-13.578) BH34(9.632,-13.578) BH36(10.277,-13.578) BH38(10.921,-13.578) BH40(11.565,-13.578) BH42(12.209,-13.578) BH44(12.853,-13.578) BH46(13.497,-13.578) BH48(14.141,-13.578) BH50(14.786,-13.578) BH52(15.43,-13.578) BH54(16.074,-13.578) BH56(16.718,-13.578) BH59(17.362,-13.578) BJ1(0,-13.718) BJ3(0.429,-13.794) BJ4(0.859,-13.794) BJ6(1.288,-13.794) BJ8(1.717,-13.794) BJ10(2.225,-13.825) BJ12(2.869,-13.825) BJ15(3.513,-13.825) BJ17(4.157,-13.825) BJ19(4.801,-13.825) BJ21(5.446,-13.825) BJ23(6.09,-13.825) BJ25(6.734,-13.825) BJ27(7.378,-13.825) BJ29(8.022,-13.825) BJ31(8.666,-13.825) BJ33(9.31,-13.825) BJ35(9.955,-13.825) BJ37(10.599,-13.825) BJ39(11.243,-13.825) BJ41(11.887,-13.825) BJ43(12.531,-13.825) BJ45(13.175,-13.825) BJ47(13.819,-13.825) BJ49(14.464,-13.825) BJ51(15.108,-13.825) BJ53(15.752,-13.825) BJ55(16.396,-13.825) BJ57(17.04,-13.825) BJ61(17.762,-13.794) BJ62(18.191,-13.794) BJ64(18.621,-13.718) BK11(2.547,-14.071) BK14(3.191,-14.071) BK16(3.835,-14.071) BK18(4.479,-14.071) BK20(5.123,-14.071) BK22(5.768,-14.071) BK24(6.412,-14.071) BK26(7.056,-14.071) BK28(7.7,-14.071) BK30(8.344,-14.071) BK32(8.988,-14.071) BK34(9.632,-14.071) BK36(10.277,-14.071) BK38(10.921,-14.071) BK40(11.565,-14.071) BK42(12.209,-14.071) BK44(12.853,-14.071) BK46(13.497,-14.071) BK48(14.141,-14.071) BK50(14.786,-14.071) BK52(15.43,-14.071) BK54(16.074,-14.071) BK56(16.718,-14.071) BK59(17.413,-13.995) BL1(0,-14.173) BL3(0.429,-14.223) BL4(0.859,-14.223) BL6(1.288,-14.223) BL8(1.717,-14.223) BL10(2.225,-14.317) BL12(2.869,-14.317) BL15(3.513,-14.317) BL17(4.157,-14.317) BL19(4.801,-14.317) BL21(5.446,-14.317) BL23(6.09,-14.317) BL25(6.734,-14.317) BL27(7.378,-14.317) BL29(8.022,-14.317) BL31(8.666,-14.317) BL33(9.31,-14.317) BL35(9.955,-14.317) BL37(10.599,-14.317) BL39(11.243,-14.317) BL41(11.887,-14.317) BL43(12.531,-14.317) BL45(13.175,-14.317) BL47(13.819,-14.317) BL49(14.464,-14.317) BL51(15.108,-14.317) BL53(15.752,-14.317) BL55(16.396,-14.317) BL57(17.04,-14.31) BL61(17.762,-14.223) BL62(18.191,-14.223) BL64(18.621,-14.173) BM11(2.547,-14.564) BM14(3.191,-14.564) BM16(3.835,-14.564) BM18(4.479,-14.564) BM20(5.123,-14.564) BM22(5.768,-14.564) BM24(6.412,-14.564) BM26(7.056,-14.564) BM28(7.7,-14.564) BM30(8.344,-14.564) BM32(8.988,-14.564) BM34(9.632,-14.564) BM36(10.277,-14.564) BM38(10.921,-14.564) BM40(11.565,-14.564) BM42(12.209,-14.564) BM44(12.853,-14.564) BM46(13.497,-14.564) BM48(14.141,-14.564) BM50(14.786,-14.564) BM52(15.43,-14.564) BM54(16.074,-14.564) BM56(16.718,-14.564) BM59(17.409,-14.464) BN1(0,-14.627) BN3(0.429,-14.653) BN4(0.859,-14.653) BN6(1.288,-14.653) BN8(1.717,-14.653) BN10(2.225,-14.81) BN12(2.869,-14.81) BN15(3.513,-14.81) BN17(4.157,-14.81) BN19(4.801,-14.81) BN21(5.446,-14.81) BN23(6.09,-14.81) BN25(6.734,-14.81) BN27(7.378,-14.81) BN29(8.022,-14.81) BN31(8.666,-14.81) BN33(9.31,-14.81) BN35(9.955,-14.81) BN37(10.599,-14.81) BN39(11.243,-14.81) BN41(11.887,-14.81) BN43(12.531,-14.81) BN45(13.175,-14.81) BN47(13.819,-14.81) BN49(14.464,-14.81) BN51(15.108,-14.81) BN53(15.752,-14.81) BN55(16.396,-14.81) BN58(17.088,-14.719) BN61(17.762,-14.653) BN62(18.191,-14.653) BN64(18.621,-14.627) BP1(0,-15.082) BP3(0.455,-15.082) BP5(0.909,-15.082) BP7(1.364,-15.082) BP9(1.903,-15.082) BP11(2.547,-15.082) BP14(3.191,-15.082) BP16(3.835,-15.082) BP18(4.479,-15.082) BP20(5.123,-15.082) BP22(5.768,-15.082) BP24(6.412,-15.082) BP26(7.056,-15.082) BP28(7.7,-15.082) BP30(8.344,-15.082) BP32(8.988,-15.082) BP34(9.632,-15.082) BP36(10.277,-15.082) BP38(10.921,-15.082) BP40(11.565,-15.082) BP42(12.209,-15.082) BP44(12.853,-15.082) BP46(13.497,-15.082) BP48(14.141,-15.082) BP50(14.786,-15.082) BP52(15.43,-15.082) BP54(16.074,-15.082) BP56(16.718,-15.082) BP58(17.257,-15.082) BP60(17.711,-15.082) BP62(18.166,-15.082) BP64(18.621,-15.082) C11(2.547,-0.518) C14(3.191,-0.518) C16(3.835,-0.518) C18(4.479,-0.518) C20(5.123,-0.518) C22(5.768,-0.518) C24(6.412,-0.518) C26(7.056,-0.518) C28(7.7,-0.518) C30(8.344,-0.518) C32(8.988,-0.518) C34(9.632,-0.518) C36(10.277,-0.518) C38(10.921,-0.518) C40(11.565,-0.518) C42(12.209,-0.518) C44(12.853,-0.518) C46(13.497,-0.518) C48(14.141,-0.518) C50(14.786,-0.518) C52(15.43,-0.518) C54(16.074,-0.518) C56(16.713,-0.518) C59(17.421,-0.623) D1(0,-0.909) D3(0.429,-0.859) D4(0.859,-0.859) D6(1.288,-0.859) D8(1.717,-0.859) D10(2.225,-0.765) D12(2.869,-0.765) D15(3.513,-0.765) D17(4.157,-0.765) D19(4.801,-0.765) D21(5.446,-0.765) D23(6.09,-0.765) D25(6.734,-0.765) D27(7.378,-0.765) D29(8.022,-0.765) D31(8.666,-0.765) D33(9.31,-0.765) D35(9.955,-0.765) D37(10.599,-0.765) D39(11.243,-0.765) D41(11.887,-0.765) D43(12.531,-0.765) D45(13.175,-0.765) D47(13.819,-0.765) D49(14.464,-0.765) D51(15.108,-0.765) D53(15.752,-0.765) D55(16.459,-0.853) D57(17.035,-0.785) D61(17.762,-0.859) D62(18.191,-0.859) D64(18.621,-0.909) E11(2.547,-1.011) E14(3.191,-1.011) E16(3.835,-1.011) E18(4.479,-1.011) E20(5.123,-1.011) E22(5.768,-1.011) E24(6.412,-1.011) E26(7.056,-1.011) E28(7.7,-1.011) E30(8.344,-1.011) E32(8.988,-1.011) E34(9.632,-1.011) E36(10.277,-1.011) E38(10.921,-1.011) E40(11.565,-1.011) E42(12.209,-1.011) E44(12.853,-1.011) E46(13.497,-1.011) E48(14.141,-1.011) E50(14.786,-1.011) E52(15.43,-1.011) E54(16.074,-1.011) E56(16.82,-1.138) E59(17.399,-1.128) F1(0,-1.364) F3(0.429,-1.288) F4(0.859,-1.288) F6(1.288,-1.288) F8(1.717,-1.288) F10(2.225,-1.257) F12(2.869,-1.257) F15(3.513,-1.257) F17(4.157,-1.257) F19(4.801,-1.257) F21(5.446,-1.257) F23(6.09,-1.257) F25(6.734,-1.257) F27(7.378,-1.257) F29(8.022,-1.257) F31(8.666,-1.257) F33(9.31,-1.257) F35(9.955,-1.257) F37(10.599,-1.257) F39(11.243,-1.257) F41(11.887,-1.257) F43(12.531,-1.257) F45(13.175,-1.257) F47(13.819,-1.257) F49(14.464,-1.257) F51(15.108,-1.257) F53(15.752,-1.257) F55(16.396,-1.257) F61(17.788,-1.288) F62(18.191,-1.288) F64(18.621,-1.37) G11(2.547,-1.504) G14(3.191,-1.504) G16(3.835,-1.504) G18(4.479,-1.504) G20(5.123,-1.504) G22(5.768,-1.504) G24(6.412,-1.504) G26(7.056,-1.504) G28(7.7,-1.504) G30(8.344,-1.504) G32(8.988,-1.504) G34(9.632,-1.504) G36(10.277,-1.504) G38(10.921,-1.504) G40(11.565,-1.504) G42(12.209,-1.504) G44(12.853,-1.504) G46(13.497,-1.504) G48(14.141,-1.504) G50(14.786,-1.504) G52(15.43,-1.504) G54(16.074,-1.504) G56(16.728,-1.53) G58(17.129,-1.445) H2(0.272,-1.744) H4(0.765,-1.744) H6(1.257,-1.744) H8(1.75,-1.744) H10(2.14,-1.651) H12(2.869,-1.75) H15(3.513,-1.75) H17(4.157,-1.75) H19(4.801,-1.75) H21(5.446,-1.75) H23(6.09,-1.75) H25(6.734,-1.75) H27(7.378,-1.75) H29(8.022,-1.75) H31(8.666,-1.75) H33(9.31,-1.75) H35(9.955,-1.75) H37(10.599,-1.75) H39(11.243,-1.75) H41(11.887,-1.75) H43(12.531,-1.75) H45(13.175,-1.75) H47(13.819,-1.75) H49(14.464,-1.75) H51(15.108,-1.75) H53(15.752,-1.75) H55(16.396,-1.758) H59(17.441,-1.702) H61(17.856,-1.744) J1(0,-2.066) J3(0.518,-2.066) J5(1.011,-2.066) J7(1.504,-2.066) J9(1.996,-2.066) J11(2.547,-1.996) J14(3.191,-1.996) J16(3.835,-1.996) J18(4.479,-1.996) J20(5.123,-1.996) J22(5.768,-1.996) J24(6.412,-1.996) J26(7.056,-1.996) J28(7.7,-1.996) J30(8.344,-1.996) J32(8.988,-1.996) J34(9.632,-1.996) J36(10.277,-1.996) J38(10.921,-1.996) J40(11.565,-1.996) J42(12.209,-1.996) J44(12.853,-1.996) J46(13.497,-1.996) J48(14.141,-1.996) J50(14.786,-1.996) J52(15.43,-1.996) J54(16.074,-1.996) J56(16.718,-1.996) J58(17.116,-1.935) J60(17.61,-2.066) J62(18.103,-2.066) J64(18.621,-2.066) K12(2.869,-2.243) K15(3.513,-2.243) K17(4.157,-2.243) K19(4.801,-2.243) K21(5.446,-2.243) K23(6.09,-2.243) K25(6.734,-2.243) K27(7.378,-2.243) K29(8.022,-2.243) K31(8.666,-2.243) K33(9.31,-2.243) K35(9.955,-2.243) K37(10.599,-2.243) K39(11.243,-2.243) K41(11.887,-2.243) K43(12.531,-2.243) K45(13.175,-2.243) K47(13.819,-2.243) K49(14.464,-2.243) K51(15.108,-2.243) K53(15.752,-2.243) K55(16.396,-2.243) L2(0.272,-2.388) L4(0.765,-2.388) L6(1.257,-2.388) L8(1.75,-2.388) L10(2.243,-2.388) L14(3.191,-2.489) L16(3.835,-2.489) L18(4.479,-2.489) L20(5.123,-2.489) L22(5.768,-2.489) L24(6.412,-2.489) L26(7.056,-2.489) L28(7.7,-2.489) L30(8.344,-2.489) L32(8.988,-2.489) L34(9.632,-2.489) L36(10.277,-2.489) L38(10.921,-2.489) L40(11.565,-2.489) L42(12.209,-2.489) L44(12.853,-2.489) L46(13.497,-2.489) L48(14.141,-2.489) L50(14.786,-2.489) L52(15.43,-2.489) L54(16.074,-2.489) L57(16.971,-2.309) L59(17.363,-2.388) L61(17.856,-2.388) M1(0,-2.71) M3(0.518,-2.71) M5(1.011,-2.71) M7(1.504,-2.71) M9(1.996,-2.71) M11(2.489,-2.71) M15(3.513,-2.736) M17(4.157,-2.736) M19(4.801,-2.736) M21(5.446,-2.736) M23(6.09,-2.736) M25(6.734,-2.736) M27(7.378,-2.736) M29(8.022,-2.736) M31(8.666,-2.736) M33(9.31,-2.736) M35(9.955,-2.736) M37(10.599,-2.736) M39(11.243,-2.736) M41(11.887,-2.736) M43(12.531,-2.736) M45(13.175,-2.736) M47(13.819,-2.736) M49(14.464,-2.736) M51(15.108,-2.736) M53(15.752,-2.736) M56(16.652,-2.551) M58(17.117,-2.71) M64(18.621,-2.71) N2(0.272,-3.032) N4(0.765,-3.032) N6(1.257,-3.032) N8(1.75,-3.032) N10(2.243,-3.032) N12(2.736,-3.032) N14(3.191,-2.982) N16(3.835,-2.982) N18(4.479,-2.982) N20(5.123,-2.982) N22(5.768,-2.982) N24(6.412,-2.982) N26(7.056,-2.982) N28(7.7,-2.982) N30(8.344,-2.982) N32(8.988,-2.982) N34(9.632,-2.982) N36(10.277,-2.982) N38(10.921,-2.982) N40(11.565,-2.982) N42(12.209,-2.982) N44(12.853,-2.982) N46(13.497,-2.982) N48(14.141,-2.982) N50(14.786,-2.982) N52(15.43,-2.982) N54(16.088,-2.954) N55(16.487,-2.916) N57(16.871,-3.032) P1(0,-3.354) P3(0.518,-3.354) P5(1.011,-3.354) P7(1.504,-3.354) P9(1.996,-3.354) P11(2.489,-3.354) P13(2.982,-3.359) P52(15.734,-3.264) P54(16.132,-3.354) P56(16.624,-3.354) P58(17.117,-3.354) P64(18.621,-3.354) R2(0.272,-3.676) R4(0.765,-3.676) R6(1.257,-3.676) R8(1.75,-3.676) R10(2.243,-3.676) R12(2.736,-3.676) R53(15.885,-3.676) R55(16.378,-3.676) R57(16.871,-3.676) T1(0,-3.998) T3(0.518,-3.998) T5(1.011,-3.998) T7(1.504,-3.998) T9(1.996,-3.998) T11(2.489,-3.998) T13(2.982,-4.003) T54(16.132,-3.998) T56(16.624,-3.998) T58(17.117,-3.998) T64(18.621,-3.998) U2(0.272,-4.32) U4(0.765,-4.32) U6(1.257,-4.32) U8(1.75,-4.32) U10(2.243,-4.32) U12(2.736,-4.32) U53(15.885,-4.32) U55(16.378,-4.32) U57(16.871,-4.32) V1(0,-4.642) V3(0.518,-4.642) V5(1.011,-4.642) V7(1.504,-4.642) V9(1.996,-4.642) V11(2.489,-4.642) V13(2.982,-4.647) V54(16.132,-4.642) V56(16.624,-4.642) V58(17.117,-4.642) V64(18.621,-4.642) W2(0.272,-4.964) W4(0.765,-4.964) W6(1.257,-4.964) W8(1.75,-4.964) W10(2.243,-4.964) W12(2.736,-4.964) W53(15.885,-4.964) W55(16.378,-4.964) W57(16.871,-4.964) Y1(0,-5.287) Y3(0.518,-5.287) Y5(1.011,-5.287) Y7(1.504,-5.287) Y9(1.996,-5.287) Y11(2.489,-5.287) Y13(2.982,-5.292) Y54(16.132,-5.287) Y56(16.624,-5.287) Y58(17.117,-5.287) Y64(18.621,-5.287)
  round 0.33 smd: AA15(3.464,-5.671) AA16(3.96,-5.671) AA18(4.455,-5.671) AA19(4.95,-5.671) AA21(5.446,-5.671) AA23(5.941,-5.671) AA24(6.436,-5.671) AA26(6.931,-5.671) AA27(7.427,-5.671) AA29(7.922,-5.671) AA30(8.417,-5.671) AA32(8.913,-5.671) AA33(9.408,-5.671) AA35(9.903,-5.671) AA36(10.399,-5.671) AA38(10.894,-5.671) AA40(11.389,-5.671) AA41(11.884,-5.671) AA43(12.38,-5.671) AA44(12.875,-5.671) AA46(13.37,-5.671) AA47(13.866,-5.671) AA49(14.361,-5.671) AA50(14.856,-5.671) AA51(15.352,-5.671) AC15(3.464,-6.23) AC16(3.96,-6.23) AC18(4.455,-6.23) AC19(4.95,-6.23) AC21(5.446,-6.23) AC23(5.941,-6.23) AC24(6.436,-6.23) AC26(6.931,-6.23) AC27(7.427,-6.23) AC29(7.922,-6.23) AC30(8.417,-6.23) AC32(8.913,-6.23) AC33(9.408,-6.23) AC35(9.903,-6.23) AC36(10.399,-6.23) AC38(10.894,-6.23) AC40(11.389,-6.23) AC41(11.884,-6.23) AC43(12.38,-6.23) AC44(12.875,-6.23) AC46(13.37,-6.23) AC47(13.866,-6.23) AC49(14.361,-6.23) AC50(14.856,-6.23) AC51(15.352,-6.23) AE15(3.464,-6.789) AE16(3.96,-6.789) AE18(4.455,-6.789) AE19(4.95,-6.789) AE21(5.446,-6.789) AE23(5.941,-6.789) AE24(6.436,-6.789) AE26(6.931,-6.789) AE27(7.427,-6.789) AE29(7.922,-6.789) AE30(8.417,-6.789) AE32(8.913,-6.789) AE33(9.408,-6.789) AE35(9.903,-6.789) AE36(10.399,-6.789) AE38(10.894,-6.789) AE40(11.389,-6.789) AE41(11.884,-6.789) AE43(12.38,-6.789) AE44(12.875,-6.789) AE46(13.37,-6.789) AE47(13.866,-6.789) AE49(14.361,-6.789) AE50(14.856,-6.789) AE51(15.352,-6.789) AF15(3.464,-7.348) AF16(3.96,-7.348) AF18(4.455,-7.348) AF19(4.95,-7.348) AF21(5.446,-7.348) AF23(5.941,-7.348) AF24(6.436,-7.348) AF26(6.931,-7.348) AF27(7.427,-7.348) AF29(7.922,-7.348) AF30(8.417,-7.348) AF32(8.913,-7.348) AF33(9.408,-7.348) AF35(9.903,-7.348) AF36(10.399,-7.348) AF38(10.894,-7.348) AF40(11.389,-7.348) AF41(11.884,-7.348) AF43(12.38,-7.348) AF44(12.875,-7.348) AF46(13.37,-7.348) AF47(13.866,-7.348) AF49(14.361,-7.348) AF50(14.856,-7.348) AF51(15.352,-7.348) AH15(3.464,-7.907) AH16(3.96,-7.907) AH18(4.455,-7.907) AH19(4.95,-7.907) AH21(5.446,-7.907) AH23(5.941,-7.907) AH24(6.436,-7.907) AH26(6.931,-7.907) AH27(7.427,-7.907) AH29(7.922,-7.907) AH30(8.417,-7.907) AH32(8.913,-7.907) AH33(9.408,-7.907) AH35(9.903,-7.907) AH36(10.399,-7.907) AH38(10.894,-7.907) AH40(11.389,-7.907) AH41(11.884,-7.907) AH43(12.38,-7.907) AH44(12.875,-7.907) AH46(13.37,-7.907) AH47(13.866,-7.907) AH49(14.361,-7.907) AH50(14.856,-7.907) AH51(15.352,-7.907) AK15(3.464,-8.465) AK16(3.96,-8.465) AK18(4.455,-8.465) AK19(4.95,-8.465) AK21(5.446,-8.465) AK23(5.941,-8.465) AK24(6.436,-8.465) AK26(6.931,-8.465) AK27(7.427,-8.465) AK29(7.922,-8.465) AK30(8.417,-8.465) AK32(8.913,-8.465) AK33(9.408,-8.465) AK35(9.903,-8.465) AK36(10.399,-8.465) AK38(10.894,-8.465) AK40(11.389,-8.465) AK41(11.884,-8.465) AK43(12.38,-8.465) AK44(12.875,-8.465) AK46(13.37,-8.465) AK47(13.866,-8.465) AK49(14.361,-8.465) AK50(14.856,-8.465) AK51(15.352,-8.465) AL15(3.464,-9.024) AL16(3.96,-9.024) AL18(4.455,-9.024) AL19(4.95,-9.024) AL21(5.446,-9.024) AL23(5.941,-9.024) AL24(6.436,-9.024) AL26(6.931,-9.024) AL27(7.427,-9.024) AL29(7.922,-9.024) AL30(8.417,-9.024) AL32(8.913,-9.024) AL33(9.408,-9.024) AL35(9.903,-9.024) AL36(10.399,-9.024) AL38(10.894,-9.024) AL40(11.389,-9.024) AL41(11.884,-9.024) AL43(12.38,-9.024) AL44(12.875,-9.024) AL46(13.37,-9.024) AL47(13.866,-9.024) AL49(14.361,-9.024) AL50(14.856,-9.024) AL51(15.352,-9.024) AN15(3.464,-9.583) AN16(3.96,-9.583) AN18(4.455,-9.583) AN19(4.95,-9.583) AN21(5.446,-9.583) AN23(5.941,-9.583) AN24(6.436,-9.583) AN26(6.931,-9.583) AN27(7.427,-9.583) AN29(7.922,-9.583) AN30(8.417,-9.583) AN32(8.913,-9.583) AN33(9.408,-9.583) AN35(9.903,-9.583) AN36(10.399,-9.583) AN38(10.894,-9.583) AN40(11.389,-9.583) AN41(11.884,-9.583) AN43(12.38,-9.583) AN44(12.875,-9.583) AN46(13.37,-9.583) AN47(13.866,-9.583) AN49(14.361,-9.583) AN50(14.856,-9.583) AN51(15.352,-9.583) AR15(3.464,-10.142) AR16(3.96,-10.142) AR18(4.455,-10.142) AR19(4.95,-10.142) AR21(5.446,-10.142) AR23(5.941,-10.142) AR24(6.436,-10.142) AR26(6.931,-10.142) AR27(7.427,-10.142) AR29(7.922,-10.142) AR30(8.417,-10.142) AR32(8.913,-10.142) AR33(9.408,-10.142) AR35(9.903,-10.142) AR36(10.399,-10.142) AR38(10.894,-10.142) AR40(11.389,-10.142) AR41(11.884,-10.142) AR43(12.38,-10.142) AR44(12.875,-10.142) AR46(13.37,-10.142) AR47(13.866,-10.142) AR49(14.361,-10.142) AR50(14.856,-10.142) AR51(15.352,-10.142) AT15(3.464,-10.701) AT16(3.96,-10.701) AT18(4.455,-10.701) AT19(4.95,-10.701) AT21(5.446,-10.701) AT23(5.941,-10.701) AT24(6.436,-10.701) AT26(6.931,-10.701) AT27(7.427,-10.701) AT29(7.922,-10.701) AT30(8.417,-10.701) AT32(8.913,-10.701) AT33(9.408,-10.701) AT35(9.903,-10.701) AT36(10.399,-10.701) AT38(10.894,-10.701) AT40(11.389,-10.701) AT41(11.884,-10.701) AT43(12.38,-10.701) AT44(12.875,-10.701) AT46(13.37,-10.701) AT47(13.866,-10.701) AT49(14.361,-10.701) AT50(14.856,-10.701) AT51(15.352,-10.701) R15(3.464,-3.436) R16(3.96,-3.436) R18(4.455,-3.436) R19(4.95,-3.436) R21(5.446,-3.436) R23(5.941,-3.436) R24(6.436,-3.436) R26(6.931,-3.436) R27(7.427,-3.436) R29(7.922,-3.436) R30(8.417,-3.436) R32(8.913,-3.436) R33(9.408,-3.436) R35(9.903,-3.436) R36(10.399,-3.436) R38(10.894,-3.436) R40(11.389,-3.436) R41(11.884,-3.436) R43(12.38,-3.436) R44(12.875,-3.436) R46(13.37,-3.436) R47(13.866,-3.436) R49(14.361,-3.436) R50(14.856,-3.436) R51(15.352,-3.436) T15(3.464,-3.995) T16(3.96,-3.995) T18(4.455,-3.995) T19(4.95,-3.995) T21(5.446,-3.995) T23(5.941,-3.995) T24(6.436,-3.995) T26(6.931,-3.995) T27(7.427,-3.995) T29(7.922,-3.995) T30(8.417,-3.995) T32(8.913,-3.995) T33(9.408,-3.995) T35(9.903,-3.995) T36(10.399,-3.995) T38(10.894,-3.995) T40(11.389,-3.995) T41(11.884,-3.995) T43(12.38,-3.995) T44(12.875,-3.995) T46(13.37,-3.995) T47(13.866,-3.995) T49(14.361,-3.995) T50(14.856,-3.995) T51(15.352,-3.995) V15(3.464,-4.554) V16(3.96,-4.554) V18(4.455,-4.554) V19(4.95,-4.554) V21(5.446,-4.554) V23(5.941,-4.554) V24(6.436,-4.554) V26(6.931,-4.554) V27(7.427,-4.554) V29(7.922,-4.554) V30(8.417,-4.554) V32(8.913,-4.554) V33(9.408,-4.554) V35(9.903,-4.554) V36(10.399,-4.554) V38(10.894,-4.554) V40(11.389,-4.554) V41(11.884,-4.554) V43(12.38,-4.554) V44(12.875,-4.554) V46(13.37,-4.554) V47(13.866,-4.554) V49(14.361,-4.554) V50(14.856,-4.554) V51(15.352,-4.554) Y15(3.464,-5.113) Y16(3.96,-5.113) Y18(4.455,-5.113) Y19(4.95,-5.113) Y21(5.446,-5.113) Y23(5.941,-5.113) Y24(6.436,-5.113) Y26(6.931,-5.113) Y27(7.427,-5.113) Y29(7.922,-5.113) Y30(8.417,-5.113) Y32(8.913,-5.113) Y33(9.408,-5.113) Y35(9.903,-5.113) Y36(10.399,-5.113) Y38(10.894,-5.113) Y40(11.389,-5.113) Y41(11.884,-5.113) Y43(12.38,-5.113) Y44(12.875,-5.113) Y46(13.37,-5.113) Y47(13.866,-5.113) Y49(14.361,-5.113) Y50(14.856,-5.113) Y51(15.352,-5.113)
  round 0.325 smd: AA59(17.363,-5.609) AA61(17.856,-5.609) AA63(18.349,-5.609) AB60(17.61,-5.931) AB62(18.103,-5.931) AC59(17.363,-6.253) AC61(17.856,-6.253) AC63(18.349,-6.253) AD60(17.61,-6.575) AD62(18.103,-6.575) AE59(17.363,-6.897) AE61(17.856,-6.897) AE63(18.349,-6.897) H63(18.349,-1.744) L63(18.349,-2.388) M60(17.61,-2.71) M62(18.103,-2.71) N59(17.363,-3.032) N61(17.856,-3.032) N63(18.349,-3.032) P60(17.61,-3.354) P62(18.103,-3.354) R59(17.363,-3.676) R61(17.856,-3.676) R63(18.349,-3.676) T60(17.61,-3.998) T62(18.103,-3.998) U59(17.363,-4.32) U61(17.856,-4.32) U63(18.349,-4.32) V60(17.61,-4.642) V62(18.103,-4.642) W59(17.363,-4.964) W61(17.856,-4.964) W63(18.349,-4.964) Y60(17.61,-5.287) Y62(18.103,-5.287)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G123DCUR_VSSOP8
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.825) 6(1,2.825) 7(0.5,2.825) 8(0,2.825)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STARC_111D10-000000-G4-R_10P
  oval 0.203x1.194 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0)
  rect 1.397x2.007 smd: 11(-2.5,-1.37) 12(6.1,-1.37)
SW_TS-A52-3-P1-S017_4P
  rect 0.889x0.991 smd: 1(0,0) 2(3.9,0) 3(0,3.85) 4(3.9,3.85)
SW_WCM2012F2S_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,-0.8) 4(0,-0.8)
SX9306IULTRT_QFN20_3X3
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.203x0.889 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.702x1.702 smd: 21(1.55,-0.8)
T-SOL_158-1000902614_23P-T
  oval 0.61x1.092 smd: 1(0,0) 2(-0.9,0) 3(-1.8,0) 4(-2.7,0) 5(-3.6,0) 6(-4.5,0) 7(-5.4,0) 8(-6.3,0) 9(-7.9,0)
  rect 0.889x1.499 smd: 10(-9.9,-0.51) 11(4.7,-0.51)
  rect 1.092x0.991 smd: 12(0.71,-13.45)
  oval 0.61x0.787 smd: 13(-0.54,-13.35) 14(-1.45,-13.35) 15(-2.36,-13.35) 16(-3.27,-13.35) 17(-4.18,-13.35) 18(-5.09,-13.35) 19(-6,-13.35) 20(-6.91,-13.35) 21(-7.82,-13.35)
  oval 1.092x1.905 hole 0.406x1.194: 22(4.6,-9.75) 23(-9.8,-9.75)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAIYO_MCF12102G900-T_4P
  rect 0.508x0.305 smd: 1(0,0) 2(0,-0.55) 3(1.25,-0.55) 4(1.25,0)
TLV1702AIDGKR_VSSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
TOKO_1239AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TOKO_1239AS-H-2R2N-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TOKO_1269AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TPC12
  round 0.305 smd: 1(0,0)
TPD2EUSB30DRTR_SOT3
  oval 0.305x0.356 smd: 1(0,0) 2(-0.35,-0.85) 3(0.35,-0.85)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TPS68470YFFR_DSBGA_56P
  round 0.271 smd: A1(0,0) A2(0.4,0) A3(0.8,0) A4(1.2,0) A5(1.6,0) A6(2,0) A7(2.4,0) B1(0,-0.4) B2(0.4,-0.4) B3(0.8,-0.4) B4(1.2,-0.4) B5(1.6,-0.4) B6(2,-0.4) B7(2.4,-0.4) C1(0,-0.8) C2(0.4,-0.8) C3(0.8,-0.8) C4(1.2,-0.8) C5(1.6,-0.8) C6(2,-0.8) C7(2.4,-0.8) D1(0,-1.2) D2(0.4,-1.2) D3(0.8,-1.2) D4(1.2,-1.2) D5(1.6,-1.2) D6(2,-1.2) D7(2.4,-1.2) E1(0,-1.6) E2(0.4,-1.6) E3(0.8,-1.6) E4(1.2,-1.6) E5(1.6,-1.6) E6(2,-1.6) E7(2.4,-1.6) F1(0,-2) F2(0.4,-2) F3(0.8,-2) F4(1.2,-2) F5(1.6,-2) F6(2,-2) F7(2.4,-2) G1(0,-2.4) G2(0.4,-2.4) G3(0.8,-2.4) G4(1.2,-2.4) G5(1.6,-2.4) G6(2,-2.4) G7(2.4,-2.4) H1(0,-2.8) H2(0.4,-2.8) H3(0.8,-2.8) H4(1.2,-2.8) H5(1.6,-2.8) H6(2,-2.8) H7(2.4,-2.8)
TPS79801QDGNRQ1_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
  rect 1.88x1.753 smd: 9(0.975,2.175)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q128FVPIQ_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
Y_7M25000016_4P
  rect 0.991x0.889 smd: 1(0,0) 2(2.15,0) 3(2.15,1.55) 4(0,1.55)
Y_9H03200031_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
