# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DDI1_N0: length 81.1
  TOP w0.152: C88.1 56.09,96.44 56.09,96.59 v7(55.9,96.78)
  IN1 w0.06: 114.15,95.52 114.17,95.52 114.17,95.57 114.34,95.57 114.42,95.65 115.88,95.65 116.31,95.21 119.18,95.21 119.3,95.33 120.08,95.33 121.85,97.11 121.85,97.36 121.92,97.43 v1(121.92,97.57)
  IN1 w0.089: 114.15,95.52 112.69,95.52 112.3,95.92 110.77,95.92 110.66,96.03 107.38,96.03 106.99,95.64 103.69,95.64 103,96.33 102.82,96.33 102.56,96.07 102.56,95.96 v5(102.65,95.87)
  GND1 w0.089: v4(102.72,95.47) 102.65,95.55 v5(102.65,95.87)
  IN3 w0.084: v7(55.9,96.78) 55.96,96.78 56.18,96.56 56.18,96.34 56.48,96.04 56.97,96.04 57.15,96.21 57.15,96.73 57.23,96.81 57.45,96.81 57.54,96.73 57.54,96.21 57.72,96.04 58.07,96.04 58.25,96.21 58.25,96.73 58.33,96.81 58.56,96.81 58.64,96.73 58.64,96.21 58.82,96.04 59.17,96.04 59.35,96.21 59.35,96.73 59.44,96.81 59.66,96.81 59.74,96.73 59.74,96.21 59.92,96.04 60.32,96.04 64.62,91.73 74.38,91.73 74.83,91.27 75.7,91.27 75.99,90.99 75.99,90.57 76.17,90.4 76.53,90.4 76.7,90.57 76.7,90.98 76.82,91.09 76.98,91.09 77.09,90.98 77.09,90.57 77.27,90.4 77.84,90.4 78.06,90.62 78.06,90.95 78.19,91.08 78.56,91.08 78.69,90.95 78.69,90.62 78.91,90.4 87.7,90.4 90.55,93.25 96.65,93.25 97,92.9 99.61,92.9 101.62,94.92 102.4,94.92 102.54,95.07 102.54,95.29 v4(102.72,95.47)
PCH_DDI1_N0_R: length 1.9
  TOP w0.152: C88.2 55.97,95.52 55.97,94.86 55.86,94.75 55.86,94.45 55.83,94.41 U23.7
PCH_DDI1_N1: length 81.1
  TOP w0.152: v7(54.63,96.79) 54.67,96.75 54.67,96.29 C142.1
  IN1 w0.06: 114.15,96.93 114.16,96.93 114.21,96.89 115.2,96.89 115.51,96.57 116.13,96.57 116.86,95.84 118.88,95.84 119.66,96.62 120,96.62 120.24,96.86 120.49,96.86 121.08,97.44 121.08,97.65 121.28,97.85 v1(121.28,98.09)
  IN1 w0.089: 114.15,96.93 113.68,96.93 113.2,97.42 108.98,97.42 108.9,97.51 108.9,97.61 108.68,97.82 108.23,97.82 108.02,97.61 108.02,97.51 107.93,97.42 107.66,97.42 107.57,97.51 107.57,97.61 107.36,97.82 106.91,97.82 106.7,97.61 106.7,97.51 106.61,97.42 106.46,97.42 106.34,97.53 104.29,97.53 104.17,97.42 v5(103.74,97.42)
  GND1 w0.089: v5(103.74,97.42) 103.7,97.38 103.5,97.38 v4(103.36,97.52)
  IN3 w0.084: v4(103.36,97.52) 103.97,97.52 104.16,97.33 104.16,97.05 103.31,96.2 103.31,94.71 102.97,94.37 101.86,94.37 99.85,92.35 96.75,92.35 96.41,92.7 90.78,92.7 87.93,89.84 75.93,89.84 75.09,90.69 74.59,90.69 74.11,91.17 64.37,91.17 60.09,95.45 59.65,95.45 59.56,95.36 59.56,95.16 59.36,94.96 59.05,94.96 58.85,95.16 58.85,95.4 58.76,95.48 58.54,95.48 58.46,95.4 58.46,95.16 58.26,94.96 57.95,94.96 57.75,95.16 57.75,95.36 57.66,95.45 54.92,95.45 54.63,95.74 v7(54.63,96.79)
PCH_DDI1_N1_R: length 1.8
  TOP w0.152: U23.10 54.63,94.38 54.68,94.43 54.68,95.08 54.7,95.1 54.7,95.52 C142.2
PCH_DDI1_N2: length 81
  TOP w0.152: C144.1 53.52,96.41 53.52,96.6 v7(53.35,96.78)
  IN1 w0.06: 114.15,94.99 114.17,94.99 114.22,95.04 115.97,95.04 116.06,94.95 119.34,94.95 119.46,95.08 120.19,95.08 122.24,97.13 v1(122.24,97.84)
  IN1 w0.089: 114.15,94.99 112.06,94.99 111.59,95.46 110.12,95.46 109.79,95.13 102.99,95.13 102.86,95 102.86,94.42 v5(102.94,94.34)
  GND1 w0.089: v5(102.94,94.34) 102.84,94.24 102.84,94.1 v4(102.98,93.96)
  IN3 w0.084: v4(102.98,93.96) 102.64,93.62 102.64,93.52 102.38,93.26 101.55,93.26 99.78,91.5 97.75,91.5 97.7,91.44 96.87,91.44 96.23,92.08 90.95,92.08 88.16,89.29 75.68,89.29 74.87,90.1 74.25,90.1 73.88,90.47 64.12,90.47 60.19,94.41 56.79,94.41 56.61,94.59 56.61,94.86 56.58,94.9 56.27,94.9 56.23,94.85 56.23,94.59 56.05,94.41 54.27,94.41 53.49,95.19 53.49,95.54 53.67,95.72 54.04,95.72 54.08,95.76 54.08,96.05 54.03,96.1 53.76,96.1 53.58,96.28 53.58,96.55 v7(53.35,96.78)
PCH_DDI1_N2_R: length 1.9
  TOP w0.152: C144.2 53.49,95.46 53.49,94.45 53.43,94.39 U23.13
PCH_DDI1_N3: length 81.1
  TOP w0.152: v7(52.08,96.79) 52.24,96.63 52.24,96.4 C146.1
  IN1 w0.06: 114.15,96.13 114.17,96.13 114.17,96.18 114.55,96.18 114.79,95.94 116.12,95.94 116.59,95.47 119.06,95.47 119.18,95.59 119.95,95.59 121.6,97.24 v1(121.6,97.84)
  IN1 w0.089: v5(104.76,96.15) 104.86,96.25 106.43,96.25 106.91,96.73 112.55,96.73 113.15,96.13 114.15,96.13
  GND1 w0.089: v4(104.34,95.99) 104.49,96.15 v5(104.76,96.15)
  IN3 w0.084: v7(52.08,96.79) 52.29,96.58 52.29,95.61 54.05,93.85 59.97,93.85 65.15,88.67 76.2,88.67 76.65,88.22 85.15,88.22 85.67,88.74 88.38,88.74 90.17,90.53 97.56,90.53 97.98,90.95 100.01,90.95 101.75,92.69 102.59,92.69 103.88,93.98 103.88,95.99 104.06,96.18 104.16,96.18 v4(104.34,95.99)
PCH_DDI1_N3_R: length 1.8
  TOP w0.152: C146.2 52.25,95.43 52.25,94.41 52.23,94.4 U23.16
PCH_DDI1_P0: length 81.1
  TOP w0.152: v7(56.48,96.78) 56.35,96.64 56.35,96.36 C87.1
  IN1 w0.06: 114.15,95.74 114.17,95.74 114.22,95.69 114.29,95.69 114.37,95.77 115.93,95.77 116.36,95.33 119.13,95.33 119.25,95.45 120.03,95.45 121.72,97.15 121.72,97.65 121.88,97.82 121.88,98.05 v1(121.92,98.09)
  IN1 w0.089: v5(102.29,95.87) 102.34,95.92 102.34,96.16 102.73,96.54 103.09,96.54 103.78,95.86 106.9,95.86 107.3,96.25 110.75,96.25 110.86,96.13 112.39,96.13 112.78,95.74 114.15,95.74
  GND1 w0.089: v5(102.29,95.87) 102.29,95.58 v4(102.19,95.47)
  IN3 w0.084: v7(56.48,96.78) 56.48,96.77 56.34,96.63 56.34,96.4 56.55,96.2 56.9,96.2 56.99,96.28 56.99,96.8 57.16,96.98 57.52,96.98 57.7,96.8 57.7,96.28 57.78,96.2 58,96.2 58.09,96.28 58.09,96.8 58.27,96.98 58.62,96.98 58.8,96.8 58.8,96.28 58.89,96.2 59.11,96.2 59.19,96.28 59.19,96.8 59.37,96.98 59.73,96.98 59.9,96.8 59.9,96.28 59.99,96.2 60.38,96.2 64.69,91.89 74.44,91.89 74.9,91.44 75.77,91.44 76.15,91.05 76.15,90.64 76.24,90.56 76.46,90.56 76.54,90.64 76.54,91.05 76.75,91.26 77.05,91.26 77.26,91.05 77.26,90.64 77.34,90.56 77.77,90.56 77.9,90.68 77.9,91.02 78.12,91.24 78.63,91.24 78.85,91.02 78.85,90.68 78.97,90.56 87.63,90.56 90.48,93.41 96.72,93.41 97.07,93.07 99.54,93.07 101.56,95.08 102.33,95.08 102.38,95.13 102.38,95.28 v4(102.19,95.47)
PCH_DDI1_P0_R: length 1.9
  TOP w0.152: U23.6 56.23,94.39 56.2,94.43 56.2,94.61 56.31,94.72 56.31,95.44 C87.2
PCH_DDI1_P1: length 81
  TOP w0.152: C109.1 55.18,96.21 55,96.38 55,96.63 55.16,96.79 v7(55.21,96.79)
  IN1 w0.06: v1(121.28,97.57) 121.29,97.58 121.33,97.58 121.36,97.55 121.36,97.34 121.32,97.3 121.11,97.3 120.54,96.74 120.29,96.74 120.05,96.5 119.71,96.5 118.93,95.72 116.81,95.72 116.08,96.45 115.46,96.45 115.15,96.77 114.21,96.77 114.16,96.72 114.15,96.72
  IN1 w0.089: v5(103.74,97.06) 103.82,97.06 103.96,97.2 104.26,97.2 104.38,97.32 106.25,97.32 106.37,97.2 106.7,97.2 106.91,97.42 106.91,97.52 107,97.61 107.27,97.61 107.36,97.52 107.36,97.42 107.57,97.2 108.02,97.2 108.23,97.42 108.23,97.52 108.32,97.61 108.59,97.61 108.68,97.52 108.68,97.42 108.89,97.2 113.11,97.2 113.6,96.72 114.15,96.72
  GND1 w0.089: v5(103.74,97.06) 103.64,97.16 103.4,97.16 103.36,97.13 v4(103.36,97.01)
  IN3 w0.084: v7(55.21,96.79) 55.21,96.55 55.12,96.46 54.87,96.46 54.79,96.39 54.79,95.81 54.99,95.61 57.73,95.61 57.91,95.43 57.91,95.23 58.02,95.12 58.19,95.12 58.3,95.23 58.3,95.47 58.48,95.65 58.83,95.65 59.01,95.47 59.01,95.23 59.12,95.12 59.29,95.12 59.4,95.23 59.4,95.43 59.58,95.61 60.16,95.61 64.43,91.33 74.18,91.33 74.66,90.85 75.15,90.85 76,90.01 87.86,90.01 90.71,92.86 96.47,92.86 96.82,92.52 99.78,92.52 101.79,94.53 102.9,94.53 103.15,94.78 103.15,96.27 104,97.12 104,97.26 103.9,97.36 103.69,97.36 103.36,97.03 v4(103.36,97.01)
PCH_DDI1_P1_R: length 1.9
  TOP w0.152: C109.2 55.04,95.44 55.04,94.96 55.02,94.94 55.02,94.4 55.03,94.39 U23.9
PCH_DDI1_P2: length 81
  TOP w0.152: C143.1 53.79,96.38 53.79,96.63 v7(53.93,96.78)
  IN1 w0.06: v1(122.24,98.34) 122.24,98.13 122.04,97.93 122.04,97.75 122.12,97.67 122.12,97.18 120.14,95.2 119.41,95.2 119.29,95.07 116.11,95.07 116.02,95.16 114.22,95.16 114.17,95.21 114.15,95.21
  IN1 w0.089: 114.15,95.21 112.15,95.21 111.68,95.68 110.03,95.68 109.7,95.35 102.9,95.35 102.65,95.09 102.65,94.41 v5(102.58,94.34)
  GND1 w0.089: v5(102.58,94.34) 102.58,94.08 v4(102.47,93.96)
  IN3 w0.084: v7(53.93,96.78) 53.74,96.59 53.74,96.34 53.82,96.26 54.1,96.26 54.24,96.12 54.24,95.7 54.1,95.56 53.73,95.56 53.65,95.48 53.65,95.26 54.34,94.57 55.98,94.57 56.06,94.65 56.06,94.92 56.21,95.06 56.64,95.06 56.78,94.93 56.78,94.65 56.86,94.57 60.26,94.57 64.19,90.64 73.95,90.64 74.32,90.27 74.94,90.27 75.75,89.46 88.09,89.46 90.88,92.25 96.3,92.25 96.94,91.61 97.63,91.61 97.69,91.66 99.71,91.66 101.48,93.43 102.31,93.43 102.47,93.58 v4(102.47,93.96)
PCH_DDI1_P2_R: length 1.8
  TOP w0.152: C143.2 53.83,95.5 U23.12
PCH_DDI1_P3: length 81.2
  TOP w0.152: C145.1 52.5,96.4 52.5,96.63 v7(52.66,96.79)
  IN1 w0.06: 114.15,96.35 114.17,96.35 114.17,96.3 114.6,96.3 114.84,96.06 116.17,96.06 116.64,95.59 119.01,95.59 119.13,95.71 119.9,95.71 121.48,97.29 121.48,97.68 121.4,97.76 121.4,97.93 121.6,98.13 v1(121.6,98.34)
  IN1 w0.089: v5(104.76,96.5) 104.79,96.46 106.34,96.46 106.83,96.95 112.64,96.95 113.24,96.35 114.15,96.35
  GND1 w0.089: v5(104.76,96.5) v4(104.34,96.5)
  IN3 w0.084: v7(52.66,96.79) 52.45,96.58 52.45,95.68 54.12,94.01 60.03,94.01 65.22,88.83 76.27,88.83 76.72,88.38 85.08,88.38 85.6,88.9 88.32,88.9 90.1,90.69 97.5,90.69 97.91,91.11 99.94,91.11 101.68,92.85 102.52,92.85 103.72,94.05 103.72,96.06 103.99,96.34 104.17,96.34 v4(104.34,96.5)
PCH_DDI1_P3_R: length 1.8
  TOP w0.152: C145.2 52.58,95.52 52.58,94.45 52.63,94.41 U23.15
PCH_DDI2_CLK: length 9.1
  IN1 w0.06: 138.12,97.32 138.08,97.36 138.08,97.37 137.44,98 136.29,98 135.88,98.41 135.88,98.62 135.22,99.27 134.69,99.27 v1(134.65,99.31)
  IN1 w0.089: v5(140.39,96.1) 140.37,96.12 140.25,96.12 139.8,96.57 139.17,96.57 138.8,96.93 138.51,96.93 138.12,97.32
  GND1 w0.119: v4(140.68,95.7) 140.54,95.84 140.54,95.94 v5(140.39,96.1)
  GND4 w0.119: v4(140.68,95.7) 140.89,95.91 v9(140.89,96.05)
  BOTTOM w0.119: v9(140.89,96.05) 140.95,95.98 141.43,95.98 141.67,96.21 RC32.2
PCH_DDI2_DAT: length 9.4
  IN1 w0.06: 137.81,97.32 137.25,97.88 135.68,97.88 134.71,98.86 v1(134.56,98.86)
  IN1 w0.089: 137.81,97.32 138.39,96.74 138.72,96.74 139.09,96.38 139.72,96.38 140.36,95.74 v5(141.37,95.74)
  GND1 w0.119: v4(141.89,95.72) 141.87,95.74 v5(141.37,95.74)
  GND4 w0.119: v4(141.89,95.72) 141.98,95.72 142.35,96.08 v9(142.35,96.21)
PCH_DPWROK: length 128.2
  TOP w0.089: U27.A5 235.86,124.7 236.35,124.7 v2(236.38,124.67)
  TOP w0.119: RH56.1 146.23,121.39 145.9,121.06 145.9,119.79 T31.1 RH67.2 146.59,118.73 146.74,118.58 146.74,117.43 146.59,117.28 146.59,114.38 v1(146.41,114.21)
  IN1 w0.089: v1(146.41,114.21) 147.14,114.21 149.21,112.14 149.21,111.45 149.93,110.73 151.79,110.73 153.78,108.73 153.78,105.67 154.03,105.42 156.67,105.42 158.24,103.86 162.17,103.86 162.6,104.29 163.9,104.29 164.33,103.86 165.04,103.86 165.21,104.02 167.9,104.02 168.09,103.83 172.22,103.83 172.63,103.42 179.34,103.42 179.59,103.67 182.38,103.67 182.74,104.03 186.65,104.03 188.15,105.53 188.62,105.53 190.03,106.93 190.03,108.36 190.94,109.27 190.94,110.67 196.54,116.27 196.54,118.47 198.63,120.57 199.97,120.57 200.14,120.39 202.13,120.39 202.38,120.65 203.26,120.65 203.47,120.86 203.47,121.35 203.79,121.66 204.23,121.66 204.49,121.92 204.49,122.34 204.83,122.68 205.26,122.68 205.51,122.92 205.51,123.43 205.74,123.66 206.64,123.66 207.31,124.33 208.85,124.33 v3(209.4,124.89)
  IN2 w0.084: v2(236.38,124.67) 236.38,124.26 236.58,124.06 236.58,122.33 235.64,121.39 235.64,121.14 235.17,120.66 235.17,120.08 233.8,118.72 229.99,118.72 229.86,118.84 229.17,118.84 227.64,120.37 227.64,120.51 226.69,121.45 224.61,121.45 223.04,123.02 221.55,123.02 220.96,123.6 215.02,123.6 212.57,126.05 211.13,126.05 210.98,126.21 210.02,126.21 209.4,125.59 v3(209.4,124.89)
PCH_DPWROK_R: length 23.8
  TOP w0.076: 138.4,116.07 138.4,114.88 138.23,114.72 137.21,114.72 136.57,114.08 133.71,114.08 132.96,113.33 132.43,113.33 131.9,112.81 UC1.BN15
  TOP w0.119: RH50.2 145.23,122.25 RH56.2 145.32,122.61 145.15,122.78 143.99,122.78 C1.2 143.53,122.33 143.2,122.66 143.2,122.84 v1(143.05,122.99) ; v1(138.42,118.28) 138.42,117.16 v13(137.98,116.72) 137.98,116.49 138.4,116.07
  IN1 w0.089: v1(138.42,118.28) 138.79,118.65 138.79,121.54 139.71,122.46 141.23,122.46 141.41,122.64 141.99,122.64 142.35,122.99 v1(143.05,122.99)
PCH_ENVDD: length 55.8
  TOP w0.119: D1.2 175.19,103.63 175.19,104.71 174.73,105.16 174.02,105.16 173.26,105.93 172.47,105.93 171.48,104.94 170.82,104.94 170,104.11 168.74,104.11 168.2,103.58 167.46,103.58 167.38,103.65 167.38,105.08 v7(167.24,105.21)
  TOP w0.191: UC1.D3 135.01,98.43 135.31,98.13
  TOP w0.254: 135.31,98.13 135.59,98.13 136.79,96.93 v1(136.79,96.63)
  IN1 w0.06: v1(136.79,96.63) 137.27,96.63
  IN1 w0.089: v5(153.15,94.31) 153.14,94.3 150.39,94.3 150.08,93.99 149.02,93.99 148.6,93.57 148.41,93.57 148.04,93.94 146.43,93.94 146.24,93.75 145.08,93.75 144.99,93.65 140.96,93.65 140.01,94.6 140.01,94.62 139.83,94.8 139.76,94.8 138.96,95.6 138.79,95.6 138.41,95.98 137.92,95.98 137.27,96.63
  GND1 w0.119: v4(153.69,94.3) 153.68,94.31 v5(153.15,94.31)
  GND4 w0.119: v9(154.27,94.08) 154.05,94.3 v4(153.69,94.3)
  BOTTOM w0.119: v7(167.24,105.21) 166.86,105.6 166.4,105.6 166.19,105.39 166.19,103.63 160.43,97.87 160.43,96.63 157.92,94.12 154.31,94.12 v9(154.27,94.08)
PCH_GPIOA7: length 4.6
  IN1 w0.06: v1(134.9,110.59) 134.97,110.51 135.51,110.51 135.57,110.46 137.82,110.46 v5(137.83,110.45)
  GND1 w0.119: v4(138,110.82) 137.83,110.65 v5(137.83,110.45)
  IN3 w0.084: v4(138,110.82) 137.78,110.6 v6(137.78,110.31)
  BOTTOM w0.119: TC106.1 137.31,110.31 v6(137.78,110.31)
PCH_GPP_D11: length 7
  TOP w0.119: RH120.1 140.29,99.68 v1(139.45,99.68)
  IN1 w0.06: v1(134.41,101.57) 134.44,101.57 134.64,101.37 135.29,101.37 135.86,100.8 136.28,100.8 137.37,99.71 137.54,99.71 137.72,99.53 139.3,99.53 v1(139.45,99.68)
PCH_INV_PWM: length 64.8
  TOP w0.119: v2(177.9,98.94) 177.9,103.41 D3.3
  IN1 w0.06: 137.31,96.86 136.53,96.86 136.32,97.07 135.83,97.07 135.77,97.01 135.11,97.01 134.92,97.2 134.92,97.49 134.57,97.84 134.29,97.84 v1(134.13,98)
  IN1 w0.089: 137.31,96.86 138,96.17 138.49,96.17 138.85,95.8 139.03,95.8 139.78,95.05 139.84,95.05 140.2,94.69 140.2,94.68 140.59,94.29 141.17,94.29 141.62,93.84 144.87,93.84 144.96,93.94 146.16,93.94 146.49,94.27 150.07,94.27 150.5,94.7 152.44,94.7 152.58,94.85 153,94.85 153.6,94.24 154.99,94.24 155.29,93.94 157.83,93.94 158.24,93.54 162.51,93.54 163.07,92.97 165.35,92.97 167.65,90.67 169.88,90.67 170.2,90.36 178.5,90.36 180.84,92.7 v3(180.84,92.92)
  IN2 w0.084: v3(180.84,92.92) 180.84,94.92 178.83,96.94 178.83,97.66 177.9,98.6 v2(177.9,98.94)
PCH_JTAG_TCK: length 5.3
  TOP w0.119: RC35.1 119.69,95.46 v10(119.69,95.94) 119.69,96.35 119.67,96.38 UC1.B53
  GND1 w0.089: v4(119.95,95.51) 119.69,95.77 v10(119.69,95.94)
  GND4 w0.089: v6(120.5,95.31) 120.15,95.31 v4(119.95,95.51)
  BOTTOM w0.152: RC22.1 120.75,95.07 v6(120.5,95.31) 120.26,95.31 v13(120.06,95.11)
PCH_JTAG_TDI: length 18.9
  TOP w0.119: RC51.1 126.2,89.25 RC34.1 125.6,88.77 125.11,88.28 124.47,88.28 124.36,88.39 124.36,89.78 124.08,90.07 v10(123.46,90.07)
  IN1 w0.06: v5(118.73,96.25) 118.95,96.25 119.54,96.85 119.54,97.01 119.76,97.23 120.16,97.23 120.68,97.74 120.68,98.04 v1(120.63,98.09)
  GND1 w0.119: v5(118.73,96.25) 118.71,96.24 118.71,95.97 v4(118.63,95.88) ; v4(123.58,91.04) 123.58,90.19 v10(123.46,90.07)
  IN3 w0.084: v4(123.58,91.04) 123.65,91.12 123.65,92.06 123.32,92.39 123.32,92.67 122.71,93.28 122.71,94.57 121.84,95.44 121.09,95.44 120.68,95.03 119.82,95.03 119.09,95.77 118.74,95.77 v4(118.63,95.88)
  GND4 w0.119: v15(119.12,96.08) 118.92,95.88 v4(118.63,95.88)
PCH_JTAG_TDO: length 21.3
  TOP w0.152: 118.24,90.3 v7(117.62,90.3) ; 118.24,90.3 118.59,90.65 120.76,90.65 121.65,89.76 121.65,89.05 122.12,88.58 RC38.1 ; 118.24,90.3 118.27,90.3 119.09,89.48 119.09,89.05 RC49.1
  IN1 w0.06: v1(120.31,97.84) 119.98,97.84 119.78,97.65 119.78,97.59 119.2,97 118.68,97 118.02,96.35 117.25,96.35 116.92,96.68 v5(116.9,96.68)
  GND1 w0.089: v5(116.9,96.68) 116.62,96.68 v4(116.36,96.43)
  IN3 w0.084: v4(116.36,96.43) 116.28,96.34 116.28,96.03 116.01,95.76 116.01,92.77 116.48,92.3 116.48,90.4 116.82,90.05 117.37,90.05 v7(117.62,90.3)
  GND4 w0.089: v4(116.36,96.43) v15(116.67,96.73)
PCH_JTAG_TMS: length 12.8
  TOP w0.119: v1(129.72,93.57) 129.72,93.66 130.41,94.34 RC52.1
  IN1 w0.06: v1(129.72,93.57) 129.01,93.57
  IN1 w0.089: v8(128.66,93.58) 128.67,93.57 129.01,93.57
  GND1 w0.119: v10(119.99,97.57) 119.96,97.54 v4(119.96,97.19) ; v4(128.19,93.71) 128.32,93.58 v8(128.66,93.58)
  GND4 w0.119: v4(128.19,93.71) 128.07,93.84 v9(127.77,93.84) ; v9(120.25,96.91) 120.24,96.91 v4(119.96,97.19)
  BOTTOM w0.119: v9(120.25,96.91) 121.06,96.91 121.34,96.63 123.12,96.63 125.91,93.84 v13(126.73,93.84) v9(127.77,93.84)
PCH_JTAG_TRST#: length 12.8
  TOP w0.119: RC62.1 116.26,90.23 v10(116.69,90.23)
  IN1 w0.06: v5(117.35,96.58) 117.41,96.53 118.03,96.53 118.63,97.12 119.15,97.12 119.66,97.63 119.66,97.7 119.99,98.02 v1(119.99,98.09)
  GND1 w0.119: v10(116.69,90.23) 116.82,90.23 v4(117.05,90.46) ; v5(117.35,96.58) 117.63,96.3 v4(117.65,96.3)
  IN3 w0.084: v4(117.65,96.3) 117.58,96.38 116.92,96.38 116.62,96.07 116.62,95.89 116.37,95.65 116.37,92.94 116.81,92.5 116.81,90.74 117.05,90.51 v4(117.05,90.46)
  GND4 w0.119: v15(117.82,95.79) 117.65,95.97 v4(117.65,96.3)
PCH_JTAGX: length 5.2
  TOP w0.06: 122.57,97.19 122.45,97.32 121.11,97.32 120.95,97.48 UC1.B49
  TOP w0.119: RC63.1 123.29,94.71 RC41.1 v13(122.87,96.05) 122.87,96.9 122.57,97.19
PCH_MUTE#: length 232.5
  IN1 w0.089: v5(110.2,129.17) 110.12,129.26 110.12,130.11 108.58,131.65 105.27,131.65 105.14,131.78 104.36,131.78 104.16,131.97 103.48,131.97 102.83,132.62 101.89,132.62 100.67,131.4 99.73,131.4 96.25,127.92 95.44,127.92 95.07,128.3 95.07,128.57 94.77,128.87 94.48,128.87 94.29,128.68 89.51,128.68 88.04,127.21 86.6,127.21 85.98,126.6 81.34,126.6 75.64,120.9 72.51,120.9 70.28,118.66 68.9,118.66 65.88,115.64 65.88,114.92 64.79,113.83 64.79,111.27 63.79,110.27 63.79,101.74 60.1,98.05 50.67,98.05 48.56,95.94 47.4,95.94 46.69,95.23 43.17,95.23 41.51,93.58 40.92,93.58 36.2,88.86 36.2,87.63 34.79,86.22 34.79,84.22 33.01,82.44 33.01,77.53 32.12,76.64 32.12,75.38 31.42,74.68 31.42,65.3 32.56,64.16 32.56,64.13 34,62.69 34,55.37 35.1,54.27 35.1,44.51 35.44,44.17 35.44,42.63 35.73,42.34 35.73,39.29 34.19,37.75 34.19,34 33.72,33.53 33.72,29.33 33.6,29.21 33.6,28.14 v3(32.94,27.48)
  GND1 w0.119: v4(110.55,128.96) 110.34,129.17 v5(110.2,129.17)
  IN2 w0.06: v2(133.67,103.18) 133.68,103.17 134.75,103.17 134.9,103.32 135.55,103.32 136.49,102.38 137.51,102.38 138.43,101.46 v4(138.51,101.46)
  IN2 w0.084: v2(36.69,27.13) 33.29,27.13 v3(32.94,27.48)
  GND3 w0.119: v4(110.55,128.96) 110.8,128.96 114.5,125.26 120.42,125.26 121.69,124 121.69,122.57 123.22,121.04 123.33,121.04 124.8,119.57 126.35,119.57 127.01,120.23 136.37,120.23 136.61,120 v4(137.51,120)
  IN3 w0.084: v4(137.51,120) 138.43,119.08 138.43,118 138.56,117.86 138.56,116.72 137.53,115.68 136.49,115.68 136.12,115.32 136.12,113.24 136.46,112.91 136.46,112.01 136.59,111.87 136.59,109.22 137.01,108.8 137.01,107.91 137.53,107.39 137.53,106.9 138.16,106.27 138.16,104.6 137.97,104.41 137.97,103.56 137.42,103.01 137.42,102.64 138.51,101.54 v4(138.51,101.46)
PCH_OPIRCOMP: length 7.5
  TOP w0.089: UC1.BP16 131.58,112.7 132.36,113.48 132.9,113.48 133.67,114.25 136.51,114.25 137.26,114.99 137.93,114.99 RC15.1
PCH_PLTRST#: length 106.1
  TOP w0.14: RH47.2 146.46,109.09 145.92,109.63 UH1.2 ; RH47.2 146.41,108.98 UH1.1 ; RH47.2 146.54,109.06 146.54,108.43 RH41.1 146.26,108.4 v10(145.94,108.09)
  IN1 w0.06: 140.52,109.44 139.75,109.44 139.22,108.92 134.88,108.92 134.74,108.78 134.73,108.78 134.73,108.77 134.58,108.77 134.3,109.04 133.88,109.04 133.67,109.26 v1(133.67,109.62)
  IN1 w0.084: v10(145.94,108.09) 145.54,108.09 144.8,108.82 143.79,108.82 142.96,109.66 142.65,109.66 142.52,109.53 142.09,109.53 142,109.44 140.52,109.44
  GND1 w0.084: v10(145.94,108.09) 146.02,108.01 146.11,108.01 v4(146.44,107.68) ; v10(195.37,144.1) 195.47,144.2 v4(195.88,144.2)
  IN2 w0.079: v4(149.71,129.28) 149.99,129 153.42,129 154.4,128.02 158.47,128.02 160.01,129.57 160.42,129.57 160.85,129.99 163.51,129.99 164.16,130.64 165.72,130.64 165.86,130.5 172.23,130.5 172.57,130.16 177.83,130.16 178.98,131.31 189.68,131.31 190.95,132.58 190.95,134.12 194.11,137.28 194.85,137.28 195.93,138.36 v4(196.96,138.36)
  IN3 w0.079: v4(146.44,107.68) 146.84,107.27 146.84,107.09 147.22,106.71 147.5,106.71 148.02,107.23 148.02,108.18 149.39,109.55 149.39,113.25 149.68,113.54 149.68,117.19 149.4,117.47 149.4,121.03 149.02,121.41 148.63,121.41 148.05,121.99 148.05,122.37 147.94,122.49 147.94,124.83 148.42,125.31 148.42,125.85 148.51,125.94 148.65,125.94 149.03,126.32 149.03,127.55 149.71,128.24 v4(149.71,129.28) ; v4(196.96,138.36) 196.96,143.31 196.07,144.2 v4(195.88,144.2)
  GND4 w0.084: v15(196.5,138.44) 196.58,138.36 v4(196.96,138.36)
PCH_PWR_EN: length 112.2
  TOP w0.119: PR740.1 174.15,125.17 PR739.1 174.19,125.04 174.64,124.58 PR736.1 174.95,124.49 175.05,124.39 176.31,124.39 177.1,125.18 177.1,126.83 v2(177.07,126.86) ; U27.H13 232.21,120.65 v10(232.21,120.2)
  IN1 w0.089: v2(177.07,126.86) 177.07,124.53 178.44,123.16 178.44,122.29 178.76,121.97 182.59,121.97 183.45,122.83 183.45,123.43 183.72,123.7 184.98,123.7 187.13,125.85 187.13,127.43 188.57,128.88 190.06,128.88 v3(190.62,129.44)
  GND1 w0.119: v10(232.21,120.2) 232.21,120.18 232.47,119.92 v4(232.47,119.9)
  IN2 w0.06: v2(167.59,125.2) 167.85,125.46 167.85,125.51
  IN2 w0.084: v4(227.51,140.9) 219.9,140.9 219.5,140.5 216.88,140.5 216.72,140.67 214.01,140.67 213.69,140.35 205.11,140.35 201.16,136.4 197.34,136.4 195.79,134.85 195.79,134.02 193.73,131.97 192.77,131.97 190.66,129.86 190.66,129.48 v3(190.62,129.44) ; v2(177.07,126.86) 176.93,126.86 176.36,127.42 172.19,127.42 171.16,128.45 168.15,128.45 167.62,127.92 166.88,127.92 166.66,127.7 166.66,127.07 167.61,126.12 167.61,125.93 167.85,125.7 167.85,125.51
  IN3 w0.084: v4(232.47,119.9) 232.64,119.9 232.92,120.18 232.92,121.17 233.37,121.61 233.37,121.84 232.61,122.6 232.61,123.48 234.11,124.98 234.11,129.18 233.66,129.62 233.66,132.67 233.03,133.31 233.03,134.05 232.17,134.91 232.17,137.29 230.65,138.81 228.61,138.81 228.01,139.4 228.01,139.77 227.51,140.27 v4(227.51,140.9)
PCH_RSMRST#: length 158.6
  TOP w0.089: v1(229.06,122.02) 229.06,121.78 229.3,121.53 229.52,121.53 U27.N12
  TOP w0.119: RC29.1 123.76,92.32 v10(123.62,92.18) ; RH67.1 146.28,116.75 T27.1 RH49.2 145.18,115.95 v1(144.58,115.35)
  IN1 w0.089: v1(229.06,122.02) 229.03,122.06 227.53,122.06 226.94,122.64 225.05,122.64 224.28,123.4 224.28,124.86 223.26,125.88 218.24,125.88 218.08,126.04 217.39,126.04 217.15,126.27 216.22,126.27 215.99,126.04 215.24,126.04 214.9,125.69 213.87,125.69 213.51,126.05 211.4,126.05 210.66,125.31 210.66,124.41 210.34,124.09 210.34,122.75 210.17,122.58 207.96,122.58 206.85,121.47 205.9,121.47 205.68,121.26 205.68,120.78 205.37,120.47 204.92,120.47 204.67,120.21 204.67,119.79 204.35,119.48 203.86,119.48 203.46,119.08 200.26,119.08 199.62,118.44 198.99,118.44 197.64,117.08 197.64,116 191.92,110.29 191.92,107.98 191,107.05 191,106.55 189.73,105.28 189.73,104.15 188.99,103.42 187.66,103.42 187.31,103.07 183.13,103.07 182.78,102.72 179.99,102.72 179.73,102.47 167.67,102.47 167.23,102.9 157.7,102.9 156.5,104.1 153.84,104.1 v5(152.69,105.25) 152.36,105.58 152.36,108.14 151.41,109.09 150.76,109.09 147.93,111.92 147.93,112.88 147.11,113.7 146.19,113.7 145.48,114.4 145.36,114.4 144.58,115.18 v1(144.58,115.35)
  GND1 w0.119: v5(152.69,105.25) 152.69,105.47 v4(152.53,105.62) ; v10(123.62,92.18) 123.35,92.18 v4(123.17,92.01)
  IN3 w0.084: v6(151.14,102.22) 151.14,103.43 152.53,104.83 v4(152.53,105.62)
  GND4 w0.119: v4(123.17,92.01) 123.17,91.94 v9(123.42,91.69)
  BOTTOM w0.119: v9(123.42,91.69) 124.73,90.38 130.59,90.38 131.1,90.9 132.09,90.9 132.52,90.47 132.52,89.42 133.44,88.5 136.33,88.5 137.88,90.05 139.05,90.05 139.36,90.36 142.56,90.36 144.01,91.81 144.01,92.7 147,95.68 147,99.33 149.4,101.74 150.65,101.74 v6(151.14,102.22)
PCH_RSMRST#_R: length 14.3
  TOP w0.089: v1(142.28,116.12) 142.35,116.06 143.26,116.06 143.67,115.65 RH53.2
  IN1 w0.06: v1(132.55,111.4) 132.53,111.42 132.53,112.25 132.73,112.46 132.98,112.46 133.06,112.55 133.06,112.77 134.01,113.72 136.57,113.72 137.87,115.02 138.26,115.02 138.52,115.28 138.85,115.28
  IN1 w0.089: v1(142.28,116.12) 142.25,116.16 141.81,116.16 141.74,116.09 139.66,116.09 138.85,115.28
PCH_RTCX1: length 15.5
  TOP w0.089: UC1.BN19 130.62,112.95 131.08,113.42 131.62,113.42 132.16,113.97 132.66,113.97 133.43,114.74 135.91,114.74 136.81,115.64 136.81,116.33
  TOP w0.14: 136.81,116.33 137.14,116.66 137.14,118.8 RH48.1 138.21,119.72 CH7.1 139.48,119.72 140.24,120.48 YH2.1
PCH_RTCX2: length 14.4
  TOP w0.089: UC1.BP18 130.94,112.84 131.36,113.26 131.67,113.26 132.22,113.81 132.73,113.81 133.47,114.55 135.96,114.55 137.09,115.68 137.09,116.26
  TOP w0.14: YH2.2 139.89,117.98 CH8.1 138.99,118.88 RH48.2 137.61,118.88 137.36,118.63 137.36,116.53 137.09,116.26
PCH_RTD3_CIO_PWR_EN: length 297.4
  TOP w0.119: RT10.2 21.62,26.26 v7(21.62,25.85)
  IN1 w0.06: v1(133.67,101.89) 133.67,102.25 133.71,102.3 133.83,102.41 134,102.41 134.07,102.34 134.25,102.34 134.32,102.41 134.49,102.41 134.57,102.33 134.74,102.33 134.82,102.42 135.91,102.42 136.26,102.07 136.26,101.76 137.1,100.91 138.35,100.91 138.54,100.72 139.04,100.72 139.42,100.35 139.55,100.35 139.56,100.34
  IN1 w0.089: 139.56,100.34 139.94,100.34 142.01,98.27 142.01,97.21 142.75,96.47 143.82,96.47 144.03,96.27 145.03,96.27 v5(145.22,96.45)
  GND1 w0.119: v5(145.22,96.45) 145.46,96.69 v4(145.46,96.83)
  IN2 w0.084: v7(21.62,25.85) 21.2,26.27 21.11,26.27 19.29,28.1 17.68,28.1 15.27,30.51 15.27,31.9 14.46,32.72 14.46,37.78 14.98,38.3 14.98,41.33 8.43,47.88 8.43,48.28 7.91,48.8 7.91,55.79 8.44,56.32 8.44,59.31 8.13,59.62 8.13,63.12 17.17,72.16 17.17,78.6 14.98,80.79 14.98,86.46 16.29,87.77 16.29,89.29 18.06,91.06 18.06,94.19 17.11,95.14 17.11,96.79 16.78,97.12 16.78,98.61 16.4,98.99 16.4,99.9 v4(16.76,100.26)
  IN3 w0.06: v6(134.59,104.58) 134.59,105.24 134.09,105.74 134.09,108.1 133.72,108.47 133.72,109.14
  IN3 w0.084: v4(16.76,100.26) 17.5,100.26 19.31,102.07 25.81,102.07 25.99,101.89 30.16,101.89 31.23,100.82 35.79,100.82 37.7,102.73 40.1,102.73 41.41,101.41 42.79,101.41 42.97,101.23 61.39,101.23 63.65,103.49 63.65,107.92 63.34,108.22 63.34,118.84 68.62,124.11 68.62,125.44 70.4,127.22 72.52,127.22 73.25,127.95 76.72,127.95 78.07,129.29 79.43,129.29 79.51,129.37 81.79,129.37 82.13,129.04 85.28,129.04 85.46,129.22 92.03,129.22 92.41,128.85 94.37,128.85 94.71,128.52 100.03,128.52 100.8,129.28 101.82,129.28 102.89,130.35 104.45,130.35 104.68,130.58 105.24,130.58 105.96,129.86 108.9,129.86 110.8,127.96 111.25,127.96 112.59,126.62 120.77,126.62 123.19,124.2 123.19,119.48 125.59,117.08 126.21,117.08 126.69,117.57 132.2,117.57 133.72,116.05 133.72,109.14
  GND4 w0.119: v9(145.47,96.45) 145.46,96.46 v4(145.46,96.83)
  BOTTOM w0.119: v6(134.59,104.58) 134.59,104.24 134.04,103.69 134.04,100.87 133.17,100 133.17,93.22 135.07,91.32 138.59,91.32 138.86,91.58 141.87,91.58 142.23,91.95 142.23,92.65 145.47,95.88 v9(145.47,96.45)
PCH_RTD3_USB_PWR_EN: length 259.8
  IN2 w0.06: v4(133.17,105.95) 132.9,105.95 132.67,105.72 132.67,105.38 132.44,105.15 132.44,104.83 132.66,104.62 132.66,104.22 132.48,104.05 132.48,103.74 132.61,103.61 132.61,103.41 132.46,103.27 132.46,102.42 132.55,102.34 133.26,102.34 133.34,102.42 133.5,102.42 133.58,102.34 134.28,102.34 v2(134.41,102.21)
  IN2 w0.084: v4(24.13,31.95) 24.27,31.82 24.27,30.04 23.12,28.9 20.59,28.9 19.9,29.58 18.4,29.58 16.75,31.22 16.75,32.52 15.94,33.33 15.94,37.16 16.47,37.69 16.47,39.32 17.34,40.19 17.34,41.89 14.69,44.54 14.69,44.84 v4(14.1,45.42)
  IN3 w0.084: v6(8.76,59.44) 8.76,58.48 12.64,54.59 12.64,52.19 12.93,51.9 12.93,50.12 12.75,49.94 12.75,47.72 13.27,47.21 13.27,45.86 13.55,45.57 13.96,45.57 v4(14.1,45.42) ; v6(17.98,99.5) 17.98,99.51 19.78,101.32 25.51,101.32 25.68,101.15 29.85,101.15 30.97,100.04 36.07,100.04 38.02,101.99 39.78,101.99 41.12,100.65 42.5,100.65 42.66,100.49 61.69,100.49 64.42,103.22 64.42,108.33 64.12,108.63 64.12,118.54 69.59,124 69.59,125.34 70.62,126.37 77.56,126.37 79.19,128 85.49,128 85.92,127.56 88.75,127.56 89.67,128.48 91.73,128.48 92.73,127.48 93.78,127.48 93.81,127.45 94.5,127.45 94.53,127.48 101.11,127.48 102.73,129.1 104.2,129.1 104.2,129.11 108.6,129.11 110.49,127.22 110.94,127.22 112.28,125.88 120.29,125.88 121.12,125.04 121.12,122.81 121.45,122.48 121.45,119.13 124.29,116.28 128.42,116.28 128.94,116.81 131.91,116.81 132.98,115.74 132.98,107.86 133.49,107.35 133.49,106.3 133.17,105.97 v4(133.17,105.95)
  GND4 w0.119: v4(24.13,31.95) 24.02,31.95 23.53,32.44 v9(23.35,32.44)
  BOTTOM w0.119: v6(8.76,59.44) 8.76,60.09 10.64,61.97 12.77,61.97 13.28,62.48 13.28,66.91 14.05,67.69 14.05,87.08 12.45,88.68 12.45,96.87 15.08,99.5 v6(17.98,99.5)
PCH_SPI1_CLK: length 33.7
  TOP w0.119: RC73.2 149.57,93.58 149.57,93.48 149.21,93.11 148.89,93.11 148.76,92.98 148.76,92.67 148.65,92.57 148.5,92.57 148.39,92.67 148.39,93.43 148.52,93.56 v2(148.98,93.56)
  IN2 w0.06: 138.88,97.91 138.66,98.13 138.66,98.37 138.25,98.79 137.95,98.79 137.5,99.25 137.5,99.55 137.66,99.71 137.66,99.89 137.36,100.19 137.09,100.19 136.89,99.98 136.61,99.98 136.51,100.08 136.51,100.48 136.42,100.57 136.31,100.57 136.23,100.48 136.23,100.19 136.17,100.13 136.02,100.13 135.97,100.19 135.97,100.54 135.9,100.62 135.77,100.62 135.69,100.54 135.69,100.39 135.62,100.31 134.61,100.31 134.17,100.76 134.17,101.05 134.05,101.17 133.84,101.17 133.59,100.92 v2(133.42,100.92)
  IN2 w0.084: 138.88,97.91 139.2,97.59 139.2,96.83 139.51,96.52 140.91,96.52 141.26,96.87 141.43,96.87 141.72,96.59 141.9,96.59 142.02,96.71 142.16,96.71 142.32,96.54 142.42,96.54 142.59,96.71 142.74,96.71 142.96,96.49 143.12,96.49 143.33,96.7 143.45,96.7 143.52,96.62 143.52,96.51 143.3,96.28 143.3,96.14 143.43,96.01 143.57,96.01 144.1,96.54 144.24,96.54 144.34,96.44 144.34,96.31 143.76,95.73 143.76,95.59 143.86,95.49 144,95.49 144.6,96.09 144.74,96.09 144.84,95.99 144.84,95.86 144.44,95.46 144.44,95.31 144.62,95.13 144.62,94.95 144.7,94.87 145.05,94.87 145.31,95.12 145.31,95.3 145.21,95.4 145.05,95.4 144.96,95.48 144.96,95.6 145.05,95.69 145.51,95.69 145.66,95.54 145.66,95.45 145.56,95.35 145.56,95.28 145.66,95.18 145.8,95.18 145.9,95.28 145.9,95.38 145.98,95.47 146.15,95.47 146.23,95.38 146.23,95.28 146.3,95.21 146.51,95.21 146.57,95.28 146.57,95.38 146.65,95.47 146.95,95.47 147.04,95.38 147.04,95.07 147.12,94.99 147.43,94.99 147.81,94.61 147.81,94.42 147.86,94.37 148.52,94.37 148.96,93.93 149.14,93.93 149.21,93.86 149.21,93.71 149.05,93.56 v2(148.98,93.56)
PCH_SPI1_CS#: length 32.9
  TOP w0.119: RC89.2 162.62,92.57 v2(162.41,92.36)
  IN1 w0.06: v1(134.16,100.6) 134.37,100.6 134.57,100.4 134.74,100.4 134.82,100.48 135.03,100.48 136.52,98.99 137.24,98.99 137.55,98.69 v3(139.05,98.69)
  IN2 w0.06: 139.68,98.05 v3(139.05,98.69)
  IN2 w0.084: 139.68,98.05 139.73,98 140.29,98 140.62,97.67 141.91,97.67 142.21,97.37 144.51,97.37 144.86,97.01 144.86,96.65 145.34,96.16 145.67,96.16 145.73,96.1 146.06,96.1 146.22,95.93 147.15,95.93 148.24,94.84 148.89,94.84 150.04,93.69 155.06,93.69 155.12,93.63 156.9,93.63 157.58,92.95 158.73,92.95 158.81,93.03 161.75,93.03 v2(162.41,92.36)
PCH_SPI1_IO2: length 31.8
  TOP w0.119: RC77.2 148.6,95.92 148.52,95.84 v2(148.52,95.59)
  IN2 w0.06: 139.56,99.84 138.88,99.84 138.21,100.52 138.21,100.69 138.28,100.77 138.58,100.77 138.68,100.87 138.68,101.01 138.58,101.11 138.27,101.11 138.21,101.18 138.21,101.51 137.95,101.77 137.95,101.77 137.64,102.07 136.81,102.07 136.62,102.26 136.44,102.26 136.11,102.58 135.11,102.58 134.84,102.86 133.01,102.86 v2(132.68,102.54)
  IN2 w0.084: v2(148.52,95.59) 148.47,95.54 148.33,95.54 148.19,95.68 148.19,95.82 148.26,95.89 148.26,96.01 148.18,96.09 148.06,96.09 147.99,96.02 147.85,96.02 147.75,96.12 147.75,96.26 147.81,96.32 147.81,96.44 147.69,96.56 147.57,96.56 147.51,96.5 147.37,96.5 147.27,96.59 147.27,96.73 147.34,96.8 147.34,96.91 147.21,97.05 146.29,97.05 146.21,97.13 146.21,97.25 146.11,97.36 145.98,97.36 145.9,97.43 145.9,97.57 145.81,97.67 145.67,97.67 145.57,97.57 145.57,97.44 145.51,97.37 145.38,97.37 144.83,97.92 144.35,97.92 144.27,98.01 144.27,98.49 143.74,99.02 143.32,99.02 143.22,98.92 143.22,98.76 143.32,98.66 143.59,98.66 143.93,98.32 143.93,98.02 143.83,97.92 143.67,97.92 143.57,98.02 143.57,98.28 143.47,98.38 143.33,98.38 143.24,98.28 143.24,98.05 143.11,97.92 142.68,97.92 142.55,98.05 142.55,98.84 142.45,98.94 141.98,98.94 141.8,99.12 141.8,99.27 141.73,99.35 141.62,99.35 141.52,99.25 141.52,98.73 141.64,98.61 142.21,98.61 142.31,98.51 142.31,98.33 142.21,98.23 141.59,98.23 141.24,98.58 141.24,99.36 141.15,99.45 141.02,99.45 140.93,99.36 140.93,98.97 140.84,98.88 139.79,98.88 139.63,99.04 139.63,99.21 139.57,99.27 139.32,99.27 139.24,99.35 139.24,99.47 139.32,99.55 139.56,99.55 139.65,99.64 139.65,99.76 139.56,99.84
PCH_SPI1_IO3: length 33.8
  TOP w0.119: RC80.2 156.98,97.14 158.27,97.14 158.41,97 158.41,95.43 158.71,95.13 158.71,94.17 v2(158.35,93.81)
  IN1 w0.06: v3(138.86,100.38) 138.84,100.4 138.34,100.4 138.06,100.67 137,100.67 136.02,101.65 135.81,101.65 135.45,102.01 134.82,102.01 134.72,102.11 134.58,102.11 134.48,102 134.33,102 134.24,102.09 134.04,102.09 v1(133.91,102.21)
  IN2 w0.06: 139.55,100.37 139.55,100.38 v3(138.86,100.38)
  IN2 w0.084: 139.55,100.37 139.56,100.37 139.92,100.01 141.12,100.01 141.34,99.79 141.84,99.79 142.24,99.39 143.89,99.39 145.23,98.05 146.01,98.05 146.64,97.42 147.37,97.42 150.25,94.54 152.77,94.54 153.29,95.06 154.84,95.06 155.53,94.37 157.28,94.37 157.81,93.84 158.32,93.84 v2(158.35,93.81)
PCH_SPI1_MISO: length 33.1
  TOP w0.119: v2(148.48,93.89) 148.48,95.2 148.58,95.31 148.74,95.31 RC75.2
  IN2 w0.06: 138.68,97.71 138.54,97.85 138.15,97.85 137.95,98.04 137.95,98.13 138.04,98.21 138.04,98.3 137.95,98.38 137.87,98.38 137.78,98.3 137.7,98.3 137.62,98.38 137.62,98.47 137.7,98.55 137.7,98.64 137.61,98.72 137.53,98.72 137.45,98.64 137.36,98.64 137.28,98.72 137.28,98.81 137.36,98.89 137.36,98.98 137.28,99.06 137.19,99.06 137.11,98.98 137.02,98.98 136.94,99.06 136.94,99.15 137.02,99.23 137.02,99.32 136.94,99.4 136.85,99.4 136.77,99.32 136.68,99.32 136.6,99.4 136.24,99.4 135.7,99.93 134.48,99.93 133.87,100.55 133.72,100.55 v2(133.67,100.6)
  IN2 w0.084: 138.68,97.71 139.02,97.37 139.02,96.81 139.38,96.45 139.38,96.22 139.54,96.06 140.99,96.06 141.12,95.93 141.12,95.61 141.23,95.5 141.39,95.5 141.5,95.61 141.5,95.99 141.62,96.12 142.12,96.12 142.25,95.99 142.25,95.6 142.33,95.51 142.45,95.51 142.54,95.6 142.54,95.96 142.64,96.06 142.77,96.06 142.87,95.96 142.87,95.44 143,95.31 143.38,95.31 143.5,95.18 143.5,94.58 143.6,94.48 143.75,94.48 143.85,94.58 143.85,94.94 143.94,95.03 144.06,95.03 144.15,94.94 144.15,94.53 144.38,94.31 144.38,93.98 144.48,93.87 144.63,93.87 144.74,93.98 144.74,94.29 144.84,94.39 144.98,94.39 145.08,94.29 145.08,93.85 145.21,93.72 145.32,93.72 145.45,93.85 145.45,94.6 145.55,94.7 145.7,94.7 145.8,94.6 145.8,93.91 145.88,93.83 146.08,93.83 146.18,93.93 146.18,94.64 146.29,94.75 146.45,94.75 146.56,94.64 146.56,93.63 146.67,93.51 146.92,93.51 147.01,93.6 147.01,94.42 147.1,94.52 147.24,94.52 147.34,94.42 147.34,93.35 147.44,93.25 147.58,93.25 147.68,93.35 147.68,93.79 147.78,93.89 147.91,93.89 148.01,93.79 148.01,93.35 148.11,93.25 148.38,93.25 148.48,93.35 v2(148.48,93.89)
PCH_SPI1_MOSI: length 30.2
  TOP w0.119: v1(148.55,96.35) 149,96.81 RC76.2
  IN1 w0.06: v1(134.9,100.92) 135.1,100.92 135.93,100.1 136.48,100.1 137.22,99.35 137.39,99.35 137.58,99.17 139.24,99.17 139.44,98.97 139.73,98.97 139.78,98.92 139.78,98.66 139.86,98.59 140.06,98.59
  IN1 w0.089: 140.06,98.59 140.31,98.59 140.62,98.27 140.62,98.1 140.44,97.93 140.44,97.68 140.55,97.57 141.13,97.57 141.25,97.45 141.25,96.9 142.49,95.66 143.5,95.66 143.66,95.5 144.48,95.5 144.56,95.42 144.56,95.36 144.63,95.28 144.79,95.28 144.86,95.36 144.86,95.42 144.94,95.5 145.14,95.5 145.22,95.42 145.22,95.36 145.29,95.28 145.52,95.28 145.6,95.36 145.6,95.41 145.68,95.49 145.98,95.49 146.06,95.41 146.06,95.36 146.13,95.28 146.36,95.28 146.44,95.36 146.44,96.19 146.53,96.28 146.68,96.28 146.79,96.16 146.79,95.36 146.87,95.28 149.38,95.28 150.03,95.93 150.72,95.93 150.84,96.05 150.84,96.22 150.73,96.34 149.8,96.34 149.52,96.62 149.22,96.62 149.08,96.48 149.08,96.36 149.43,96.01 149.43,95.89 149.3,95.76 149.17,95.76 148.83,96.1 148.71,96.1 148.57,95.97 148.32,95.97 147.99,95.64 147.25,95.64 147.17,95.72 147.17,96.07 147.53,96.43 147.61,96.43 147.68,96.35 147.96,96.35 148.06,96.45 148.44,96.45 v1(148.55,96.35)
PCH_SPI_CLK: length 70.7
  TOP w0.152: RC55.1 210.8,137.37 v7(210.83,137.35) ; v2(206.08,135.01) 206.08,134.82 205.57,134.31 205.57,132.91 204.84,132.19 R1035.1 204.6,131.94 C135.1 203.97,131.14 203.63,130.79 201.97,130.79 201.56,130.37 201.56,130.01 200.93,129.38 200.93,127.38 201.1,127.21 v2(201.1,124.75) ; v2(164.27,108.9) 164.27,109.16 163.67,109.76 RC72.1
  IN2 w0.084: v2(201.1,124.75) 200.46,124.11 199.9,124.11 198,122.21 198,121.32 197.46,120.78 197.46,120.35 196.65,119.54 196.3,119.54 195.69,118.93 195.69,118.17 193.47,115.95 193.47,115.64 186.59,108.77 173.29,108.77 172.61,108.1 171.62,108.1 171.48,107.95 170.23,107.95 170.17,107.89 165.28,107.89 164.27,108.9 v2(164.27,108.9) ; v2(206.08,135.01) 206.08,135.11 205.95,135.24 205.95,135.66 206.3,136.01 206.65,136.01 207.32,136.69 209.05,136.69 209.71,137.35 v7(210.83,137.35)
  BOTTOM w0.152: JSPI1.8 210.78,137.39 v7(210.83,137.35)
PCH_SPI_CLK_R: length 34.7
  TOP w0.152: v2(145.36,111.46) 145.97,112.07 v2(146.59,112.07)
  IN2 w0.06: v2(133.17,108.33) 133.28,108.44 133.49,108.44 133.59,108.53 133.8,108.53 133.95,108.38 134.37,108.38 134.84,108.85 134.88,108.85 135.36,109.33 136.2,109.33 136.3,109.23 137.07,109.23 137.15,109.16 138.39,109.16 138.45,109.21 138.69,109.21 139.41,109.94 139.41,110.87 140.13,111.58 140.23,111.58
  IN2 w0.084: v2(163.53,108.85) 163.46,108.92 161.59,108.92 159.88,110.63 153.2,110.63 152.75,111.08 151.16,111.08 151.03,110.96 149.61,110.96 149.2,111.37 148.31,111.37 148.06,111.62 146.97,111.62 146.59,112 v2(146.59,112.07) ; 140.23,111.58 141.03,111.58 141.2,111.41 143.81,111.41 144.26,111.86 144.96,111.86 v2(145.36,111.46)
PCH_SPI_CS0#: length 106.6
  TOP w0.152: v7(209.15,137.4) 209.76,138.01 RC56.1
  IN1 w0.06: v1(134.65,108.33) 135.25,108.33 135.69,107.89 136.43,107.89 136.57,107.75 136.71,107.75 136.93,107.97 137.9,107.97 137.93,107.94 v3(137.93,107.93)
  IN2 w0.06: 139.81,109.74 139.72,109.74 138.81,108.82 138.59,108.82 138.56,108.8 137.93,108.8 137.69,108.56 137.69,108.28 137.93,108.03 v3(137.93,107.93)
  IN2 w0.084: 139.81,109.74 140.79,109.74 141.58,110.52 144.63,110.52 144.69,110.58 146.1,110.58 146.43,110.25 147.54,110.25 147.8,110 148.71,110 149.48,109.23 149.48,108.74 150.35,107.88 151.77,107.88 152.06,107.59 152.06,106.35 152.16,106.26 152.16,105.49 152.38,105.26 153.15,105.26 153.39,105.02 159.32,105.02 159.98,104.36 161.9,104.36 164.12,106.58 170.71,106.58 170.78,106.64 172.02,106.64 172.16,106.79 173.16,106.79 173.82,107.45 175.75,107.45 176.19,107.01 178.77,107.01 179.21,107.46 187.18,107.46 194.97,115.24 194.97,115.6 199.17,119.81 200.24,119.81 202.16,121.72 202.16,122.25 202.46,122.55 202.46,123.08 203.15,123.77 204.54,123.77 204.76,123.99 206.74,123.99 v4(206.81,124.06)
  IN3 w0.084: v4(206.81,124.06) 206.61,124.26 206.61,134.86 v7(209.15,137.4)
  BOTTOM w0.152: JSPI1.10 209.78,140.14 209.53,139.89 209.53,137.78 v7(209.15,137.4)
PCH_SPI_CS2#: length 122.3
  TOP w0.152: R5739.1 203.37,140.22 203.37,141.55 203.71,141.89 v7(203.82,141.89) ; R1036.1 204.74,133.07 v7(205.16,133.49) ; v1(196.04,131.17) 197.5,129.71 197.5,129.43 197.71,129.23 198.51,129.23 R5714.1
  IN1 w0.089: v1(196.04,131.17) 196.13,131.26 201.53,131.26 201.7,131.1 202.88,131.1 203.03,130.95 203.6,130.95 203.67,131.02 203.67,133.06 204.1,133.49 v7(205.16,133.49)
  IN2 w0.06: 139.81,110.65 139.55,110.4 139.55,109.91 138.74,109.09 138.5,109.09 138.44,109.04 137.1,109.04 137.03,109.1 136.12,109.1 136.05,109.17 135.37,109.17 134.95,108.75 134.94,108.75 134.93,108.73 134.92,108.73 134.44,108.25 133.75,108.25 v2(133.67,108.33)
  IN2 w0.084: 139.81,110.65 140.28,111.12 140.84,111.12 141.01,110.94 144.37,110.94 144.43,111.01 146.28,111.01 146.61,110.68 147.75,110.68 148,110.43 148.88,110.43 150.41,108.9 151.47,108.9 152.58,107.78 152.58,106.43 153.57,105.44 159.49,105.44 160.15,104.78 161.73,104.78 163.95,107 170.54,107 170.6,107.07 171.84,107.07 171.87,107.09 171.99,107.21 172.98,107.21 173.64,107.87 175.93,107.87 176.36,107.43 178.59,107.43 179.04,107.88 187.01,107.88 194.35,115.23 194.35,115.59 198.99,120.23 198.99,120.92 199.56,121.49 200.26,121.49 201.99,123.22 201.99,123.29 203.23,124.53 204.95,124.53 v4(205.14,124.34)
  IN3 w0.084: v4(205.14,124.34) 205.14,124.58 205.67,125.12 205.67,132.11 205.16,132.62 v7(205.16,133.49)
  BOTTOM w0.152: v7(205.16,133.49) 205.16,136.97 204.13,138.01 204.13,141.04 204.25,141.16 204.25,141.52 203.88,141.89 v7(203.82,141.89)
PCH_SPI_CS2#_R: length 1.8
  TOP w0.152: R1036.2 203.57,132.95 202.5,132.95 202.42,132.87 U15.20
PCH_SPI_IO2: length 153.8
  TOP w0.152: v7(131.96,90.25) 132.11,90.1 132.11,87.71 130.9,86.5 128.59,86.5 127.65,85.56 RC26.1 ; RC57.1 208.77,137.93 208.34,137.5 v7(208.34,137.4)
  IN2 w0.06: 139.11,111.09 138.49,110.47 138.41,110.47 137.92,109.98 136.36,109.98 136,109.61 135.3,109.61 134.81,109.13 134.81,109.13 134.79,109.11 134.08,109.11 133.75,108.77 133.58,108.77 133.5,108.86 133.34,108.86 133.14,108.65 v2(132.93,108.65)
  IN2 w0.084: v4(205.97,124.42) 205.65,124.74 202.95,124.74 201.46,123.26 200.27,123.26 198.78,121.77 198.78,120.31 194.14,115.67 194.14,115.31 186.92,108.09 178.95,108.09 178.5,107.65 176.45,107.65 176.01,108.08 173.55,108.08 172.89,107.42 171.9,107.42 171.76,107.28 170.51,107.28 170.45,107.21 162.35,107.21 159.6,109.96 152.43,109.96 152.16,109.69 151.43,109.69 150.97,110.15 149.46,110.15 ; 149.46,110.15 150.5,109.11 151.55,109.11 152.94,107.72 v4(152.94,106.71) ; 149.46,110.15 148.96,110.65 148.07,110.65 147.96,110.76 147.83,110.89 146.7,110.89 145.83,111.76 145.83,112.78 145.5,113.11 144.63,113.11 144.11,112.59 143.9,112.59 143.39,112.08 142.5,112.08 142.16,112.42 140.98,112.42 140.82,112.26 140.28,112.26 139.11,111.09
  IN3 w0.084: v4(205.97,124.42) 206.38,124.82 206.38,135.31 208.34,137.27 v7(208.34,137.4) ; v4(152.94,106.71) 153.12,106.54 153.12,105.11 151.56,103.55 151.56,102.15 v6(151.54,102.14)
  BOTTOM w0.152: v7(208.34,137.4) 208.34,137.73 208.72,138.11 208.72,140 208.78,140.06 JSPI1.12 ; v7(131.96,90.25) 131.96,89.57 133.38,88.15 136.35,88.15 137.92,89.72 139.09,89.72 139.47,90.1 142.67,90.1 144.27,91.7 144.27,92.59 147.34,95.65 147.34,99.2 149.52,101.38 150.78,101.38 v6(151.54,102.14)
PCH_SPI_IO3: length 105
  TOP w0.152: RC58.1 207.75,137.37 v7(207.78,137.35)
  IN2 w0.06: 139.34,112.06 139.11,112.06 138.76,111.71 138.54,111.71 137.96,111.13 137.83,111.13 137.55,110.85 137.55,110.52 137.36,110.34 136.16,110.34 135.8,109.98 135.15,109.98 134.7,109.53 133.8,109.53 133.57,109.3 133.53,109.3 133.41,109.18 133.26,109.18 133.26,109.18 133.09,109.18 133.09,109.18 132.88,108.97 132.88,108.89 132.66,108.67 132.65,108.65 v2(132.44,108.65)
  IN2 w0.084: v4(205.97,124.95) 205.97,124.96 202.86,124.96 201.38,123.48 200.2,123.48 198.57,121.85 198.57,120.4 193.93,115.76 193.93,115.4 186.83,108.3 178.86,108.3 178.42,107.86 176.54,107.86 176.1,108.29 173.47,108.29 172.81,107.63 171.81,107.63 171.67,107.49 170.43,107.49 170.36,107.42 162.43,107.42 159.69,110.17 152.94,110.17 152.49,110.62 151.35,110.62 151.15,110.42 149.49,110.42 149,110.9 148.11,110.9 147.92,111.1 146.78,111.1 146.08,111.8 146.08,112.83 145.6,113.32 144.54,113.32 144.06,112.85 143.86,112.85 143.3,112.29 142.58,112.29 142.24,112.63 140.9,112.63 140.73,112.47 139.97,112.47 139.56,112.06 139.34,112.06
  IN3 w0.084: v7(207.78,137.35) 205.97,135.54 v4(205.97,124.95)
  BOTTOM w0.152: JSPI1.14 207.78,137.35 v7(207.78,137.35)
PCH_SPI_SCLK: length 2
  TOP w0.152: R1035.2 203.29,132.59 202.58,132.59 202.35,132.37 U15.19
PCH_SPI_SI: length 82.9
  TOP w0.152: R1034.1 204.86,134.15 204.86,134.58 v10(205.7,135.42) ; v7(211.64,136.74) 212.25,136.74 213.04,137.52 RC54.1 ; RC71.1 164.8,103.28 163.93,104.15 RC235.1 v2(163.93,105.07)
  GND1 w0.089: v10(205.7,135.42) 205.7,135.24 v4(205.52,135.06)
  IN2 w0.084: v4(205.52,135.06) 205.52,134.87 206.01,134.38 206.56,134.38 207.75,135.57 209.89,135.57 210.09,135.36 210.7,135.36 211.66,136.33 211.66,136.71 v7(211.64,136.74) ; v2(163.93,105.07) 163.93,105.53 164.76,106.37 170.8,106.37 170.86,106.43 172.11,106.43 172.25,106.58 173.24,106.58 173.9,107.24 175.66,107.24 176.1,106.8 178.85,106.8 179.3,107.25 187.27,107.25 195.18,115.15 195.18,115.51 198.3,118.64 199.37,118.64 202.37,121.64 202.37,122.08 202.85,122.56 204.35,122.56 204.6,122.82 204.6,123.26 204.91,123.56 205.35,123.56 v4(205.39,123.6)
  IN3 w0.084: v4(205.39,123.6) 205.24,123.6 204.68,124.16 204.68,124.42 205.46,125.2 205.46,131.28 204.53,132.21 204.53,133.87 205.52,134.86 v4(205.52,135.06)
  BOTTOM w0.152: v7(211.64,136.74) 212.01,136.74 212.57,137.3 212.57,139.9 212.78,140.11 JSPI1.4
PCH_SPI_SI_MOSI: length 2.2
  TOP w0.152: U15.21 203.1,133.37 203.29,133.55 203.68,133.55 R1034.2
PCH_SPI_SI_R: length 35.9
  TOP w0.152: RC71.2 164.8,104.5 v2(164.29,105.01)
  IN1 w0.06: 142.09,108.94 141.84,108.94 141.15,108.25 139.95,108.25 139.84,108.14 139.07,108.14 138.51,107.57 136.88,107.57 136.82,107.51 136.47,107.51 136.33,107.65 135.52,107.65 135.16,108.01 v1(134.9,108.01)
  IN1 w0.089: v3(142.79,109.33) 142.79,109.32 142.6,109.13 142.29,109.13 142.09,108.94
  GND1 w0.089: v3(142.79,109.33) 142.79,110.19 v12(142.86,110.25)
  IN2 w0.084: v2(164.29,105.01) 164.08,104.8 162.64,104.8 161.99,104.15 159.89,104.15 159.23,104.81 153.31,104.81 153.06,105.05 152.2,105.05 151.91,105.34 151.91,106.18 151.17,106.92 150.81,106.92 149.24,108.48 149.24,108.69 148.68,109.25 148.11,109.25 147.32,110.04 146.35,110.04 146.02,110.37 144.78,110.37 144.72,110.31 142.92,110.31 v12(142.86,110.25)
PCH_SPI_SO: length 111.7
  TOP w0.152: R1033.1 205.11,135.31 v10(205.21,135.42) 205.52,135.72 206.1,135.72 v2(206.31,135.52)
  GND1 w0.089: v4(204.98,135.06) 204.98,135.19 v10(205.21,135.42)
  IN2 w0.06: v2(132.68,108.33) 132.89,108.33 133.09,108.13 133.26,108.13 133.35,108.22 133.49,108.22 133.58,108.13 134.49,108.13 134.97,108.61 134.98,108.61 134.99,108.62 135,108.62 135.4,109.02 136.03,109.02 136.08,108.97 136.99,108.97 137.05,108.92 138.49,108.92 138.55,108.97 138.79,108.97 139.68,109.87 139.68,110.23 139.81,110.35
  IN2 w0.084: 139.81,110.35 140.36,110.91 140.75,110.91 140.92,110.73 144.54,110.73 144.61,110.8 146.19,110.8 146.52,110.47 147.63,110.47 147.88,110.21 148.8,110.21 149.69,109.31 149.69,108.83 150.43,108.09 151.86,108.09 152.3,107.65 152.3,106.41 153.48,105.23 159.41,105.23 160.07,104.57 161.82,104.57 164.04,106.79 170.63,106.79 170.69,106.85 171.93,106.85 172.08,107 173.07,107 173.73,107.66 175.84,107.66 176.27,107.22 178.68,107.22 179.12,107.67 187.09,107.67 194.56,115.14 194.56,115.5 199.21,120.14 199.21,120.84 199.61,121.24 200.3,121.24 202.24,123.18 202.24,123.22 203,123.99 204.16,123.99 v4(204.31,124.14) ; v2(206.31,135.52) 206.81,135.52 207.52,136.22 209.27,136.22 209.78,136.74 210.9,136.74 211.41,137.24 v7(211.92,137.24)
  IN3 w0.084: v4(204.98,135.06) 204.98,134.78 204.3,134.09 204.3,132.11 205.25,131.16 205.25,125.29 204.31,124.35 v4(204.31,124.14)
  BOTTOM w0.152: JSPI1.6 211.78,140.12 211.63,139.97 211.63,137.53 v7(211.92,137.24)
PCH_SPI_SO_R: length 2.1
  TOP w0.152: R1033.2 202.9,135.9 202.61,135.61 202.61,135.03 202.44,134.87 U15.24
PCH_SRTCRST#: length 18.8
  TOP w0.119: v1(139.17,117.25) 139.22,117.31 141.76,117.31 141.97,117.51 141.97,119.24 CH6.1 143.19,119.85 T34.1 RH45.2
  IN1 w0.06: v1(130.94,111.15) 131.38,111.59 131.38,111.73 131.46,111.81 131.46,111.97 131.38,112.05 131.38,112.22 131.52,112.35 131.54,112.35 133.64,114.45 136.06,114.45 138.87,117.25 v1(139.17,117.25)
PCH_STROBE_OUT: length 110.8
  TOP w0.119: R63.1 v10(197.11,145.5)
  IN1 w0.06: v1(134.65,100.6) 134.65,100.6 135.08,100.6 135.83,99.86 136.38,99.86 137.12,99.11 137.29,99.11 137.48,98.93 139.12,98.93 139.55,98.5 139.55,98.26 139.83,97.98
  IN1 w0.089: v5(140.17,97.72) 140.09,97.72 139.83,97.98
  GND1 w0.119: v4(197.26,146.01) 197.26,145.65 v10(197.11,145.5) ; v4(140.14,97.34) 140.17,97.37 v5(140.17,97.72)
  IN3 w0.084: v4(197.26,146.01) 197.26,146.21 196.58,146.9 194.42,146.9 191.72,144.2 191.72,143.15 190.09,141.51 190.09,138.63 188.24,136.79 180.32,136.79 178.04,134.5 176.59,134.5 176.36,134.28 173.75,134.28 172.06,135.97 164.5,135.97 163.3,134.77 161.34,134.77 161.16,134.59 161.16,133.9 160.01,132.76 160.01,131.97 158.86,130.82 157.04,130.82 155.84,132.01 155.54,132.01 151.33,127.8 151.33,125.29 150.58,124.55 150.58,122.07 151.09,121.56 151.09,118.23 151.43,117.89 151.43,116.68 153.19,114.92 153.19,108.43 151.7,106.94 149.66,106.94 148.37,105.65 148.37,103.79 v6(148.23,103.65)
  GND4 w0.119: v9(140.32,97.7) 140.32,97.57 140.14,97.39 v4(140.14,97.34)
  BOTTOM w0.119: v6(148.23,103.65) 148.75,103.13 148.75,101.86 147.96,101.07 147,101.07 145.74,99.82 145.74,98.16 145.06,97.48 141.4,97.48 141.27,97.35 RH27.1 140.66,97.35 v9(140.32,97.7)
PCH_TBT_FORCE_PWR: length 263.8
  IN1 w0.06: v1(132.93,102.21) 133.05,102.33 133.26,102.33 133.47,102.54 133.47,102.62 133.58,102.74 133.75,102.74 133.83,102.66 134,102.66 134.2,102.86 134.79,102.86 135.98,102.86 137.08,101.75 137.08,101.6 v5(137.31,101.38)
  GND1 w0.119: v5(137.31,101.38) 137.38,101.31 v4(137.82,101.31)
  IN2 w0.084: v4(17.3,99.16) 17.23,99.08 17.23,97.2 17.48,96.95 17.48,95.3 18.46,94.32 18.46,90.93 17.36,89.83 17.36,87.41 16.69,86.74 16.69,79.6 17.54,78.75 17.54,72 8.5,62.96 8.5,59.9 8.81,59.59 8.81,56.16 8.28,55.64 8.28,48.98 8.8,48.46 8.8,48.12 10.37,46.55 11.06,46.55 13.27,44.33 13.27,43.61 15.35,41.53 15.35,38.15 14.83,37.62 14.83,32.87 15.64,32.06 15.64,30.7 17.88,28.47 19.44,28.47 21.27,26.64 21.97,26.64 v7(22.78,25.84)
  IN3 w0.06: 137.14,104.22 136.89,104.48 136.21,104.48 135.71,103.97 134.43,103.97 133.67,104.73 133.67,107.49 133.17,108 133.17,108.58
  IN3 w0.084: 137.14,104.22 137.22,104.15 137.22,102.58 137.92,101.87 137.92,101.41 v4(137.82,101.31) ; v4(17.3,99.16) 17.58,99.44 17.58,99.51 19.58,101.51 25.59,101.51 25.76,101.34 29.93,101.34 31.02,100.24 36,100.24 37.93,102.17 39.86,102.17 41.2,100.83 42.58,100.83 42.74,100.68 61.62,100.68 64.22,103.28 64.22,108.16 63.9,108.48 63.9,118.6 69.18,123.88 69.18,125.21 70.63,126.66 77.59,126.66 79.2,128.27 85.58,128.27 86.05,127.81 88.73,127.81 89.59,128.67 91.8,128.67 92.17,128.29 94.14,128.29 94.58,127.85 101.22,127.85 102.65,129.29 104.12,129.29 104.13,129.29 108.68,129.29 110.57,127.4 111.02,127.4 112.36,126.06 120.43,126.06 121.31,125.18 121.31,122.88 121.63,122.56 121.63,119.23 124.34,116.53 126.44,116.53 126.93,117.01 131.97,117.01 133.17,115.82 133.17,108.58
  BOTTOM w0.119: v7(22.78,25.84) 22.97,26.03 RT7.2
