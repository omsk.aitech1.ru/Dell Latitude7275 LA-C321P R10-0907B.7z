# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_RCLK_M: length 11.6
  TOP w0.152: RR10.2 CR23.1 24.99,84.68 24.85,84.82 v1(24.85,85.56) ; JCR1.8 17.91,89.52 v7(18.45,88.98)
  IN1 w0.089: v7(18.45,88.98) 18.94,88.5 22.66,88.5 24.85,86.31 v1(24.85,85.56)
SD_RCLK_M_L: length 3.5
  TOP w0.152: UR1.15 26.78,81.97 26.42,82.33 25.68,82.33 25.14,82.87 25.14,83.37 RR10.1
SD_RCLK_P: length 11.3
  TOP w0.152: v1(17.52,88.62) 17.52,88.62 JCR1.7 ; v7(24.39,85.61) 24.19,85.61 23.72,85.14 CR22.1 RR11.2
  IN1 w0.089: v7(24.39,85.61) 24.47,85.68 24.47,86.38 22.57,88.28 18.57,88.28 18.23,88.62 v1(17.52,88.62)
SD_RCLK_P_L: length 3.5
  TOP w0.152: RR11.1 24.86,83.35 24.86,82.75 25.57,82.04 26.26,82.04 26.38,81.91 UR1.16
SDAT: length 1.5
  TOP w0.119: PR836.2 69.09,110.98 69.75,110.98 69.98,110.75 PU800.K5
SDIO_RCOMP: length 4
  TOP w0.305: UC1.BF1 136.32,110.59 136.35,110.55 137.24,110.55 137.45,110.75 138.68,110.75 138.97,111.04 RC60.2
SENSOR_I2C_CLK: length 69.3
  TOP w0.119: v2(143.59,137.27) 143.51,137.19 JP1.5 ; v1(190.37,145.83) C1417.2
  IN1 w0.089: v2(193.77,143.3) 193.77,143.31 193.33,143.75 192.72,143.75 190.64,145.83 v1(190.37,145.83)
  IN2 w0.084: v2(193.77,143.3) 193.68,143.21 191.62,143.21 189.87,141.46 189.87,139.39 190.2,139.06 190.2,136.52 189.2,135.52 186.66,135.52 186.16,135.01 184.28,135.01 183.39,134.12 173.06,134.12 172.69,134.48 170.39,134.48 170.21,134.3 162.26,134.3 161.74,133.79 160.11,133.79 159.57,133.25 158.26,133.25 157.73,132.72 157.73,131.34 157.57,131.18 155.5,131.18 155.13,131.55 155.13,131.56 154.27,132.42 147.54,132.42 147.07,132.89 146.02,132.89 145.21,133.7 144.61,133.7 143.78,134.53 143.78,137.08 v2(143.59,137.27)
SENSOR_I2C_DATA: length 68.9
  TOP w0.119: v1(189.74,145.83) C1418.2 ; v2(143.48,136.11) 143.67,136.11 143.91,136.36 JP1.7
  IN1 w0.089: v2(193.77,142.5) 193.18,142.5 191.24,144.44 191.24,144.95 190.64,145.55 190.13,145.55 189.85,145.83 v1(189.74,145.83)
  IN2 w0.084: v2(143.48,136.11) 143.34,135.97 143.34,134.65 144.55,133.45 145.13,133.45 146.03,132.55 146.03,132.39 146.28,132.14 146.84,132.14 146.94,132.23 154.19,132.23 154.95,131.48 154.95,131.47 155.43,130.99 157.67,130.99 157.92,131.24 157.92,132.64 158.34,133.06 159.64,133.06 160.18,133.6 161.82,133.6 162.34,134.12 170.29,134.12 170.47,134.3 172.61,134.3 172.98,133.93 183.47,133.93 184.36,134.82 186.23,134.82 186.74,135.33 189.28,135.33 190.79,136.84 190.79,140.47 191.07,140.75 191.32,140.75 192.41,141.84 192.6,141.84 193.26,142.5 v2(193.77,142.5)
SIO_EXT_SCI#: length 128.5
  IN1 w0.089: v3(230.45,119.65) 230.45,119.55 230.41,119.52 230.41,119.34 229.47,118.4 v3(229.47,118.33)
  IN2 w0.06: 139.4,112.58 139.34,112.52 139.34,112.47 138.82,111.95 138.44,111.95 137.86,111.37 137.73,111.37 137.54,111.19 137.11,111.19 136.61,110.68 136.28,110.68 135.71,110.12 135.1,110.12 134.64,109.66 133.76,109.66 133.52,109.42 133.48,109.42 133.36,109.3 133.31,109.3 133.04,109.3 132.72,108.98 v2(132.68,108.98)
  IN2 w0.084: v3(229.47,118.33) 227.66,118.33 225.89,120.1 224.94,120.1 223.3,121.74 222.47,121.74 220.79,123.42 214.09,123.42 213.97,123.3 211.83,123.3 210.71,124.42 207.96,124.42 206.41,125.97 205.61,125.97 205.21,125.57 199.9,125.57 196.11,121.78 196.11,121.57 194.49,119.95 194.49,118.62 191.31,115.44 191.31,114.42 186.34,109.45 172.99,109.45 172.29,108.75 171.35,108.75 171.21,108.6 169.96,108.6 169.9,108.54 167.62,108.54 166.49,109.68 165.28,109.68 164.97,109.37 163.95,109.37 163.93,109.39 161.78,109.39 160.08,111.1 153.39,111.1 151.12,113.37 148.27,113.37 147.92,113.72 144.37,113.72 143.9,113.24 143.59,113.24 143.55,113.28 143.01,113.28 142.91,113.18 142.45,113.18 142.3,113.03 140.2,113.03 v4(140.16,113.06) 139.88,113.06 139.4,112.58 ; v2(234.81,125.25) 234.81,125.11 235.08,124.83 235.08,124.63 234.88,124.43 234.7,124.43 234.63,124.51 233.75,124.51 233.37,124.12 233.37,123.1 234,122.46 234.14,122.46 234.6,122 234.6,121.61 234.52,121.53 234.52,120.24 233.83,119.54 232.29,119.54 231.53,120.3 230.74,120.3 230.45,120.01 v3(230.45,119.65)
  GND4 w0.119: v9(140.79,112.17) 140.79,112.23 140.16,112.85 v4(140.16,113.06)
SIO_EXT_SMI#: length 128.1
  IN1 w0.089: v5(215.65,126.74) 215.75,126.84 217.39,126.84 217.62,126.61 218.59,126.61 218.74,126.46 223.63,126.46 223.81,126.28 225.58,126.28 227.29,124.57 v1(227.31,124.57) ; v5(216.5,118.54) 216.32,118.54 215.02,117.24 213.04,117.24 210.12,114.32 209.93,114.32 208.12,112.51 207.83,112.51 204.07,108.75 202.19,108.75 201.19,107.75 198.43,104.99 198.43,102.91 198.06,102.53 198.06,101.6 197.48,101.02 197.48,98.84 196.61,97.97 194.37,97.97 193.16,96.76 191.2,96.76 187.23,92.79 183.83,92.79 183.41,93.21 180.34,93.21 178.06,90.93 170.73,90.93 170.24,91.42 167.97,91.42 165.41,93.98 v1(162.99,93.98) 162.89,94.08 158.97,94.08 158.72,94.32 155.58,94.32 154.81,95.09 153.3,95.09 153.16,95.23 152.43,95.23 152.29,95.09 150.36,95.09 149.94,94.67 143.64,94.67 143.39,94.42 142.92,94.42 142.03,95.31 140.42,95.31 v8(140.34,95.39)
  GND1 w0.119: v5(215.65,126.74) 215.65,127.19 v4(215.68,127.21) ; v4(216.41,119.03) 216.5,118.94 v5(216.5,118.54) ; v8(140.34,95.39) 140.1,95.39 v4(139.85,95.13)
  IN2 w0.06: v2(132.87,98.58) 133.86,98.58 134.62,97.82 134.62,97.14 v4(135.92,95.84)
  IN3 w0.076: v4(216.41,119.03) 216.21,119.24 216.21,120.91 215.75,121.37 215.75,122.78 216.21,123.24 216.21,124.58 216.63,125 216.63,125.7 215.68,126.65 v4(215.68,127.21)
  GND4 w0.119: v4(135.92,95.84) 136.12,95.84 v9(136.38,95.59) ; v9(139.6,95.47) 139.6,95.35 139.82,95.13 v4(139.85,95.13)
  BOTTOM w0.119: v9(139.6,95.47) 139.24,95.11 137.83,95.11 137.24,94.52 137.24,94.17 137.04,93.96 136.61,93.96 136.38,94.19 v9(136.38,95.59)
SIO_EXT_SMI#_R: length 2
  TOP w0.089: U27.N5 229.56,124.99 228.57,124.99 R164.2
SIO_EXT_WAKE#: length 148.7
  IN1 w0.06: 140.06,102.95 139.83,102.95 139.72,103.06 138.89,103.06 138.66,103.06 138.21,103.51 137.15,103.51 137.08,103.58 136.65,103.58 136.29,103.94 135.27,103.94 135.15,104.07 134.98,104.07 v1(134.9,104.15)
  IN1 w0.089: v5(140.48,102.66) 140.48,102.69 140.22,102.95 140.06,102.95
  GND1 w0.119: v5(140.48,102.66) 140.68,102.47 v4(140.68,101.75)
  IN2 w0.084: v4(149.38,122.08) 149.38,121.91 151.68,119.61 160.57,119.61 161.54,120.57 162.95,120.57 163.27,120.25 164.6,120.25 166.05,118.8 166.75,118.8 167.08,118.48 174.84,118.48 176.11,119.74 176.11,120.25 177.26,121.39 184.55,121.39 186.15,122.98 189.49,122.98 193.42,126.92 193.42,128.71 194.19,129.48 194.72,129.48 195.91,130.67 200.82,130.67 204.25,134.1 204.25,135.14 207.11,138 215.36,138 216.37,139 222.79,139 223,138.79 224.85,138.79 225.56,139.5 226.19,139.5 227.67,138.02 227.67,134.68 228.53,133.82 228.53,129.47 228.82,129.19 229.15,129.19 230.58,127.75 230.58,126.53 230.44,126.38 230.44,126.17 230.66,125.94 231.27,125.94 231.82,125.4 231.82,123.45 231.51,123.15 231.12,123.15 230.8,123.47 230.8,123.74 v2(230.81,123.75)
  IN3 w0.084: v6(147.2,103.92) 147.2,104.27 147.35,104.43 147.35,106.07 150.11,108.83 150.11,110.35 150.56,110.81 150.99,110.81 151.28,111.1 151.28,113.79 150.33,114.74 150.33,117.28 150.02,117.58 150.02,121.14 149.38,121.78 v4(149.38,122.08)
  GND4 w0.119: v4(140.68,101.75) 140.79,101.65 v9(140.79,101.18)
  BOTTOM w0.119: v6(147.2,103.92) 147.1,103.82 147.1,102.98 144.75,100.64 142.53,100.64 142.22,100.33 142.22,100.26 ; v9(140.79,101.18) 141.12,100.85 141.64,100.85 142.22,100.26 ; 142.22,100.26 RC202.2
SIO_PWRBTN#: length 189.9
  TOP w0.152: v1(229.28,120.61) 229.44,120.61 229.67,120.38 229.95,120.38 230.31,120.73 U27.M13 ; v1(145.52,119.46) 145.47,119.52 145.47,119.85 T36.1 145.14,120.48 144.77,120.85 RH57.2 ; v10(217.68,141.89) 218.7,142.91 219.51,142.91 219.77,143.17 JAPS2.11
  IN1 w0.089: v8(217.77,135.44) 213.65,135.44 210.78,132.57 210.46,132.57 204.82,126.93 204.33,126.93 203.62,126.22 203.18,126.22 202.58,125.62 198.6,125.62 197.59,124.62 195.54,124.62 193.27,122.35 193.27,121.1 192.86,120.69 192.86,120.32 191.23,118.69 191.23,118.14 187.84,114.75 187.84,110.41 185.46,108.03 179.59,108.03 178.93,107.37 178.36,107.37 177.89,106.91 175.51,106.91 175.24,107.18 173.34,107.18 172.88,107.63 170.85,107.63 168.74,109.74 v5(168.41,109.74) 168.23,109.74 164.37,113.6 164,113.6 163.79,113.81 163.47,113.81 163.31,113.65 153.93,113.65 151.72,115.86 151.72,116.29 150.93,117.08 150.16,117.08 149.85,116.77 149.63,116.77 148.57,117.83 148.57,118.26 147.59,119.25 145.74,119.25 v1(145.52,119.46) ; v1(229.28,120.61) 229.28,120.68 228.8,121.16 228.32,121.16 228.15,120.99 227.49,120.99 226.38,122.09 224.84,122.09 223.74,123.19 223.74,123.73 222.06,125.42 v5(221.7,125.42)
  GND1 w0.089: v5(221.7,125.42) 221.56,125.56 v4(221.25,125.56) ; v4(218.24,135.45) 217.79,135.45 v8(217.77,135.44) ; v10(123.34,93.51) 123.37,93.51 v4(123.68,93.2) ; v4(168.15,109.33) 168.15,109.48 v5(168.41,109.74) ; v4(217.23,141.84) 217.28,141.89 v10(217.68,141.89)
  IN3 w0.084: v4(168.15,109.33) 168.15,108.77 166.88,107.49 165.55,107.49 164.72,106.66 164.01,106.66 163.63,106.29 163.63,105.55 162.21,104.13 160.48,104.13 159.5,103.14 158.67,103.14 157.67,102.14 156.82,102.14 156.52,101.84 154.42,101.84 153.6,101.02 149.35,101.02 148.61,100.27 v6(147.5,100.27) ; v4(221.25,125.56) 221.25,128.77 218.24,131.78 v4(218.24,135.45) 217.61,136.09 217.61,138.87 217.05,139.43 217.05,141.66 v4(217.23,141.84)
  GND4 w0.089: v4(123.68,93.2) 123.82,93.2 v9(124.03,92.98)
  BOTTOM w0.152: v6(147.5,100.27) 147.38,100.27 146.56,99.46 146.56,95.8 143.62,92.86 143.62,91.97 142.4,90.75 139.2,90.75 138.93,90.48 137.76,90.48 136.31,89.03 133.47,89.03 132.91,89.59 132.91,90.65 132.25,91.31 130.92,91.31 130.41,90.8 126.22,90.8 v9(124.03,92.98)
SIO_RCIN#: length 127.2
  TOP w0.119: RH14.1 140.72,114.97 v1(140.49,115.2)
  IN1 w0.06: v1(133.19,111.89) 133.24,111.93 133.24,112.06 133.42,112.25 133.42,112.54 134.22,113.34 136.7,113.34 137.89,114.53 138.7,114.53 139.37,115.2 139.81,115.2
  IN1 w0.089: 139.81,115.2 v1(140.49,115.2) 140.55,115.25 141.77,115.25 142.36,115.84 142.99,115.84 143.2,116.05 143.9,116.05 143.95,116 146.01,116 146.31,115.71 146.31,115.38 146.56,115.12 146.56,114.84 146.72,114.69 147.19,114.69 149.61,112.27 149.61,111.92 149.76,111.77 151.67,111.77 153.15,110.29 161.44,110.29 162.67,109.07 162.67,107.78 163.28,107.17 165.94,107.17 166.97,106.15 168.27,106.15 168.55,105.87 168.55,105.15 169.49,104.21 178.89,104.21 179.09,104.41 186.5,104.41 188,105.91 188.46,105.91 189.65,107.09 189.65,108.52 190.56,109.43 190.56,110.83 196.15,116.42 196.15,119.41 197.95,121.22 200.44,121.22 200.77,121.55 202.56,121.55 202.67,121.66 203.25,121.66 203.47,121.89 203.47,122.34 203.81,122.68 204.29,122.68 204.49,122.88 204.49,123.35 205.18,124.04 206.48,124.04 207.16,124.72 208.45,124.72 211.1,127.36 v3(211.66,127.36)
  IN2 w0.084: v3(211.66,127.36) 213.1,127.36 214.52,125.94 216.59,125.94 216.77,126.12 217.96,126.12 218.19,126.35 218.65,126.35 218.95,126.04 223.81,126.04 224.19,125.66 226.38,125.66 228.6,123.44 230.05,123.44 230.38,123.11 230.38,122.39 230.47,122.3 230.47,122.08 230.59,121.97 232.42,121.97 232.64,122.19 233.34,122.19 233.79,121.75 v2(234.31,121.75)
SIO_SLP_A#: length 141.3
  TOP w0.119: v2(228.81,129.65) 228.38,129.22 228.38,128.18 U27.N1 ; v2(222.38,143.01) 222.27,143.12 JAPS2.6
  IN2 w0.06: v2(131.26,110.41) 131.26,110.62 131.95,111.31 132.25,111.31 132.47,111.53 132.77,111.53 133.58,112.33 133.77,112.33 133.92,112.48
  IN2 w0.084: 133.92,112.48 136.18,114.75 136.99,114.75 137.27,115.02 137.27,115.7 137.83,116.26 v2(137.83,117.99) 137.73,118.09 137.73,118.67 138.45,119.39 138.45,120.84 138.31,120.97 138.31,122.68 139.22,123.59 139.99,123.59 140.49,124.08 141.1,124.08 141.55,123.63 142.11,123.63 142.63,124.16 145.65,124.16 146.54,123.27 148.74,123.27 149.04,122.97 149.29,122.97 149.94,122.32 149.94,122 151.97,119.98 159.19,119.98 160.45,121.24 162.8,121.24 162.9,121.14 163.65,121.14 164.05,120.74 164.64,120.74 165.82,119.57 167.29,119.57 168.01,118.85 174.69,118.85 175.74,119.9 175.74,120.4 177.1,121.76 182.65,121.76 183.32,122.44 185.07,122.44 185.99,123.36 189.34,123.36 192.09,126.11 192.09,128.51 192.39,128.81 192.84,128.81 193.63,129.6 193.63,130.39 193.88,130.64 194.24,130.64 195.18,131.58 195.87,131.58 197.08,132.8 197.08,134.25 197.92,135.09 203.01,135.09 206.29,138.37 213.54,138.37 214.5,139.33 216.12,139.33 216.26,139.19 223.21,139.19 223.63,139.61 224.85,139.61 v4(224.95,139.5) 225.15,139.71 226.24,139.71 227.87,138.08 227.87,134.77 228.73,133.9 228.73,129.73 v2(228.81,129.65) ; v4(222.26,142.6) 222.26,142.88 v2(222.38,143.01)
  IN3 w0.084: v4(222.26,142.6) 222.76,142.1 223.72,142.1 224.16,141.65 224.16,140.29 v4(224.95,139.5)
SIO_SLP_EN#: length 59.8
  TOP w0.119: UH2.4 102.82,97.45 103.35,96.92 103.35,95.93 103,95.59 99.73,95.59 99.49,95.83 99.4,95.83 ; v1(128.2,85.41) 128.2,85.2 129.1,84.3 129.1,83.56 129.27,83.39 131.19,83.39 131.61,83.81 134.86,83.81 v14(135.15,84.09) 135.7,84.65 136.63,84.65 R1030.1 ; 99.4,95.83 99.21,95.64 99.21,94.5 R1028.1 ; 99.4,95.83 v1(99.38,95.84)
  IN1 w0.089: v1(99.38,95.84) 98.37,95.84 97.25,94.72 97.25,93.01 97.59,92.67 97.59,91.12 98.96,89.75 98.96,88.61 99.57,88 102.06,88 102.48,87.58 104.49,87.58 105.34,86.73 107.8,86.73 109.21,85.33 113.54,85.33 113.93,84.94 122.4,84.94 122.86,85.41 125.64,85.41 125.91,85.69 127.92,85.69 v1(128.2,85.41)
SIO_SLP_S0#: length 281.7
  TOP w0.119: R165.1 230.51,117.36 229.16,117.36 228.73,117.78 228.73,119.05 228.52,119.26 227.95,119.26 227.84,119.36 227.84,120.29 v1(227.56,120.57) ; v1(136.11,84.34) 135.35,83.59 131.7,83.59 131.28,83.17 129.18,83.17 128.87,83.47 128.87,84.2 128.05,85.03 127.08,85.03 127.01,85.1 126.71,85.1 v1(126.4,84.79) ; v1(216.68,141.7) 217.77,142.79 JAPS2.15 217.77,143.95 v2(218.31,144.48) ; v1(205.07,139.67) 202.61,139.67 202.55,139.61 202.55,138.65 202.41,138.51 201.49,138.51 R5715.1 ; v1(99.42,96.53) 99.42,96.21 99.82,95.81 102.46,95.81 102.88,96.22 R1039.1
  IN1 w0.089: v1(99.42,96.53) 98.42,96.53 96.93,95.04 96.93,92.88 97.4,92.41 97.4,91 98.72,89.68 98.72,88.58 99.49,87.81 101.99,87.81 102.4,87.39 104.41,87.39 105.27,86.53 106.03,86.53 108.37,84.19 112.86,84.19 113.12,83.93 123.18,83.93 123.84,84.59 126.2,84.59 v1(126.4,84.79) ; v1(227.56,120.57) 227.31,120.57 226.69,121.19 226.38,121.19 226.05,121.52 224.66,121.52 222.9,123.27 222.9,123.82 221.98,124.75 221.6,124.75 220.91,125.44 218.24,125.44 v5(218.13,125.33) 216.92,125.33 216.27,124.68 213.6,124.68 210.59,121.67 208.52,121.67 205.57,118.72 204.21,118.72 203.75,118.25 200.55,118.25 199.25,116.96 199.25,116.54 192.71,110 192.71,107.61 191.78,106.69 191.78,105.29 191.19,104.7 191.19,104.54 189.02,102.37 188.09,102.37 187.9,102.18 185.11,102.18 184.62,101.69 183.42,101.69 183.15,101.42 181.71,101.42 180.86,102.27 167.59,102.27 167.16,102.7 158.63,102.7 v5(158.55,102.62) 158.15,102.22 157.49,102.22 157.18,102.52 157.18,103.15 156.51,103.82 153.73,103.82 152.1,105.44 152.1,108.12 151.33,108.9 150.68,108.9 147.49,112.08 147.49,112.39 146.67,113.22 146.13,113.22 145.6,113.75 144.74,113.75 v1(144.68,113.7) ; v1(205.07,139.67) 205.07,139.79 205.68,140.4 206.04,140.4 207.76,142.11 212.24,142.11 212.64,141.71 212.86,141.71 212.94,141.64 216.62,141.64 v1(216.68,141.7) ; v1(136.11,84.34) 136.25,84.49 136.25,85.73 142.23,91.71 146.89,91.71 147.29,92.11 151.4,92.11 v5(151.62,92.32)
  GND1 w0.119: v5(218.13,125.33) 218.34,125.54 v4(218.34,125.99) ; v5(151.62,92.32) 151.76,92.32 151.95,92.13 v4(151.96,92.13) ; v4(157.82,103.28) 158.48,102.62 v5(158.55,102.62)
  IN2 w0.06: 165.72,124.33 166.51,124.33 166.65,124.2 167.71,124.2 167.91,124.4 v2(167.99,124.4)
  IN2 w0.084: v4(162.97,124.52) 163.95,124.52 164.14,124.33 165.72,124.33 ; v2(218.31,144.48) 217.67,144.48 217.66,144.5 v4(217.29,144.5)
  IN3 w0.084: v4(162.97,124.52) 162.97,123.81 161.68,122.52 161.68,120.53 161.37,120.22 161.37,117.25 161.53,117.08 161.53,116.18 161.25,115.89 161.25,115.3 161.4,115.15 161.85,115.15 162.52,114.48 162.52,113.12 161.86,112.45 161.86,106.38 162.36,105.88 162.36,105.29 161.87,104.8 160.18,104.8 159.29,103.92 158.4,103.92 157.82,103.34 v4(157.82,103.28) ; v4(218.34,125.99) 218.34,130.66 216.36,132.64 216.36,137.85 215.86,138.36 215.86,143.77 216.58,144.5 v4(217.29,144.5)
  GND4 w0.119: v9(157.6,102.91) 157.6,103.06 v4(157.82,103.28) ; v4(151.96,92.13) 152.1,92.13 152.28,92.31 v9(152.3,92.31)
  BOTTOM w0.119: v9(152.3,92.31) 152.3,92.35 152.97,93.02 152.97,94.58 153.62,95.23 156.51,95.23 156.76,95.47 156.76,97.2 155.28,98.67 155.28,100.52 155.91,101.15 156.42,101.15 156.75,100.82 157.24,100.82 157.6,101.18 v13(157.6,102.09) v9(157.6,102.91)
SIO_SLP_S0#_R: length 12.3
  TOP w0.119: RH51.1 143.72,113.52 v2(143.77,113.52)
  IN2 w0.06: 139,112.48 139,112.33 138.74,112.07 138.44,112.07 138.33,112.17 137.39,112.17 136.35,111.13 136.22,111.13 135.58,110.5 134.39,110.5 133.92,110.02 133.5,110.02 v2(133.42,109.94)
  IN2 w0.084: 139,112.48 139.98,113.46 140.72,113.46 140.94,113.24 142.25,113.24 142.37,113.37 142.83,113.37 142.93,113.47 143.72,113.47 v2(143.77,113.52)
SIO_SLP_S3#: length 534.7
  TOP w0.119: v1(98.3,89.7) 98.3,90.13 98.63,90.46 99.68,90.46 100.17,89.97 R134.1 ; v1(126.78,84.74) 126.84,84.81 127.96,84.81 128.65,84.11 128.65,83.38 129.08,82.95 131.37,82.95 131.79,83.37 136.01,83.37 136.58,83.93 142.37,83.93 144.91,86.47 144.91,87.91 145.88,88.88 v10(146.27,88.88) ; v1(99.35,97.06) 100.12,96.29 R1038.1 ; JAPS2.2 224.27,142.64 223.96,142.32 v2(223.78,142.32)
  IN1 w0.06: v2(167.59,124) 167.48,124 167.28,124.2 166.67,124.2 166.16,124.71 165.87,124.71 165.19,125.39 165.19,125.53 164.92,125.8 164.92,126.11 164.78,126.25 164.06,126.25
  IN1 w0.089: v1(99.35,97.06) 98.32,97.06 96.63,95.37 96.63,92.92 97.21,92.33 97.21,90.79 v1(98.3,89.7) 98.3,88.73 99.42,87.62 101.91,87.62 102.33,87.2 104.33,87.2 105.2,86.33 105.96,86.33 108.29,84 112.78,84 113.04,83.74 123.25,83.74 123.92,84.4 126.43,84.4 v1(126.78,84.74) ; v3(148.01,123.55) 148.24,123.78 149.49,123.78 151.11,125.41 151.11,127.95 152.16,128.99 v5(159.53,128.99) 159.54,128.98 161.28,128.98 161.65,128.61 161.65,127.95 161.45,127.75 161.45,127.41 161.65,127.21 161.65,126.88 161.78,126.75 162.72,126.75 163.34,126.13 163.57,126.13 163.68,126.25 164.06,126.25
  GND1 w0.06: v10(132.1,109.07) 131.89,109.07 131.61,108.79 v4(131.45,108.79)
  GND1 w0.119: v5(159.53,128.99) 159.5,128.96 157.91,128.96 v4(157.83,129.04) ; v4(146.65,88.9) 146.64,88.88 v10(146.27,88.88)
  IN2 w0.06: v4(131.45,108.79) 131.06,109.18 131.06,110.59 132.35,111.88 v4(132.48,111.88) 132.76,112.16 133.24,112.16 133.53,112.46 133.62,112.46 133.64,112.48 ; v2(167.59,124) 167.68,124 167.88,124.2 168.14,124.2 168.22,124.28 168.22,124.56 168.13,124.65 168.13,124.82 168.36,125.05 168.61,125.05 168.69,124.98 168.93,124.98 169.16,125.2 169.42,125.2 169.73,125.51
  IN2 w0.084: v4(16,99.16) 16,99.03 16.58,98.45 16.58,97.06 16.93,96.72 16.93,95.01 17.88,94.06 17.88,91.14 16.08,89.35 16.08,87.84 14.8,86.55 14.8,80.68 16.96,78.51 16.96,72.25 7.92,63.2 7.92,59.46 8.25,59.13 8.25,56.4 7.73,55.87 7.73,48.72 8.25,48.2 8.25,47.8 14.79,41.25 14.79,38.38 14.27,37.85 14.27,32.64 15.09,31.83 15.09,30.43 17.61,27.91 19.21,27.91 20.99,26.13 v7(20.99,25.84) ; v2(230.81,126.25) 230.77,126.29 230.77,128.63 228.94,130.46 228.94,133.96 228.06,134.84 228.06,138.16 226.25,139.96 223.45,139.96 v4(223.22,139.73) 222.86,139.37 216.44,139.37 216.28,139.53 214.44,139.53 213.47,138.55 206.22,138.55 202.95,135.29 197.86,135.29 196.9,134.32 196.9,132.88 195.79,131.77 195.1,131.77 194.18,130.84 193.78,130.84 193.45,130.51 193.45,129.68 192.78,129.01 192.33,129.01 191.9,128.59 191.9,126.18 189.26,123.54 185.91,123.54 185.06,122.69 183.29,122.69 182.55,121.95 178.27,121.95 177.86,122.36 177.86,123.68 175.88,125.66 173.01,125.66 172.6,126.07 170.29,126.07 169.73,125.51 ; 133.64,112.48 136.18,115.01 136.18,115.65 137.54,117.01 137.54,118.74 138.26,119.47 138.26,120.76 138.13,120.9 138.13,122.76 138.54,123.17 138.54,123.87 138.94,124.27 139.49,124.27 139.88,124.66 140.78,124.66 141.62,123.82 142.03,123.82 142.56,124.35 145.73,124.35 146.6,123.48 147.94,123.48 v3(148.01,123.55) ; v4(221.47,142.43) 221.65,142.25 223.7,142.25 v2(223.78,142.32)
  IN3 w0.084: v4(221.47,142.43) 221.47,141.94 222.31,141.11 222.31,140.01 222.64,139.68 223.16,139.68 v4(223.22,139.73) ; v6(158.98,104.66) 158.98,104.66 159.19,104.86 159.19,106.89 159.89,107.59 159.89,113.2 159.73,113.36 159.73,119.1 159.21,119.62 159.21,125.81 158.52,126.5 158.52,128.35 v4(157.83,129.04) ; v4(132.48,111.88) 132.48,115.74 131.61,116.62 129.01,116.62 128.49,116.1 124.22,116.1 121.26,119.05 121.26,122.41 120.92,122.75 120.92,124.98 120.21,125.69 112.12,125.69 110.85,126.96 110.42,126.96 108.47,128.92 102.81,128.92 101.18,127.3 94.61,127.3 94.58,127.26 93.73,127.26 93.7,127.3 92.65,127.3 91.65,128.29 89.74,128.29 88.83,127.38 85.85,127.38 85.41,127.81 79.26,127.81 77.64,126.19 70.7,126.19 69.77,125.26 69.77,123.92 64.31,118.46 64.31,108.71 64.61,108.41 64.61,102.8 62.11,100.3 42.58,100.3 42.42,100.46 41.04,100.46 39.7,101.8 38.1,101.8 36.15,99.85 30.89,99.85 29.78,100.96 26.62,100.96 26.28,100.63 25.22,100.63 24.72,101.13 20.05,101.13 17.64,98.72 16.44,98.72 v4(16,99.16)
  GND4 w0.119: v4(131.45,108.79) 131.5,108.84 131.55,108.84 131.79,109.08 v9(131.79,109.09) ; v9(147.47,88.9) v4(146.65,88.9)
  BOTTOM w0.119: v6(158.98,104.66) 158.48,104.66 158.26,104.44 158.26,104.17 159.12,103.32 v13(161.02,103.32) 162.39,103.32 162.97,102.74 162.97,102.21 162.47,101.71 159.98,101.71 158.11,99.85 156.37,99.85 156.16,100.06 155.78,100.06 155.51,99.78 155.51,98.76 156.98,97.29 156.98,95.36 156.62,95 153.71,95 153.19,94.48 153.19,92.77 152.28,91.86 151.19,91.86 148.23,88.9 v9(147.47,88.9) ; v7(20.99,25.84) 20.77,26.06 20.77,29.62 20.28,30.12 RT9.2
SIO_SLP_S4#: length 199.7
  TOP w0.089: v7(236.38,125.48) 236.04,125.48 235.81,125.26 U27.A4
  TOP w0.119: v2(222.79,145.23) 222.77,145.21 JAPS2.5 ; R1025.1 157.99,94.01 158.35,94.37 v10(158.35,94.6)
  GND1 w0.119: v4(158.73,94.81) 158.52,94.6 v10(158.35,94.6)
  IN2 w0.06: v2(131.58,110.66) 131.58,110.72 132.01,111.15 132.26,111.15 132.51,111.4 132.85,111.4 133.55,112.11 133.82,112.11 134.19,112.48 ; 165.72,124.8 166.48,124.8 166.68,124.6 167.03,124.6 167.23,124.4 v2(167.59,124.4)
  IN2 w0.084: 134.19,112.48 136.27,114.56 137.15,114.56 137.47,114.88 137.47,115.64 138.69,116.85 138.69,117.84 138.36,118.16 138.36,119.04 138.63,119.31 138.63,120.91 138.5,121.05 138.5,122.57 139.33,123.4 140.07,123.4 140.57,123.9 141.02,123.9 141.47,123.45 142.18,123.45 142.67,123.94 145.61,123.94 146.48,123.07 148.68,123.07 148.97,122.79 149.22,122.79 149.76,122.25 149.76,121.88 151.85,119.79 160.43,119.79 161.4,120.76 163.36,120.76 v4(163.46,120.66) 163.81,120.66 163.94,120.53 164.59,120.53 165.97,119.15 166.6,119.15 v4(166.63,119.18) 167.15,118.66 174.76,118.66 175.92,119.82 175.92,120.32 177.18,121.58 184.48,121.58 186.07,123.17 189.41,123.17 192.27,126.03 192.27,128.42 192.47,128.63 193.07,128.63 194.11,129.66 194.65,129.66 195.83,130.85 200.74,130.85 203.97,134.09 203.97,135.36 206.8,138.18 214.89,138.18 v4(215.35,138.64) ; v2(167.59,124.4) 167.59,124.61 168.23,125.25 168.74,125.25 v2(168.79,125.2) ; v2(222.79,145.23) 222.81,145.23 223.15,145.57 v4(223.15,145.79) ; 165.72,124.8 165.59,124.8 164.93,125.46 163.38,125.46 v4(163.2,125.64)
  IN3 w0.076: v4(215.35,138.64) 215.45,138.74 215.45,143.62 216.03,144.2 216.03,144.79 217.03,145.79 217.96,145.79
  IN3 w0.084: v4(163.2,125.64) 163.2,125.51 164.47,124.24 164.47,123.4 164.17,123.1 164.17,122.61 163.36,121.8 163.36,120.75 v4(163.46,120.66) ; v6(162.67,105.98) 162.67,106.32 163.22,106.87 163.22,108.26 163.96,109 164.85,109 165.68,109.83 165.68,113.44 165.47,113.65 165.47,114.91 165.24,115.14 165.24,116.83 166.22,117.81 166.5,117.81 166.76,118.07 166.76,119.06 v4(166.63,119.18) ; 217.96,145.79 v4(223.15,145.79) 223.53,145.79 224.11,145.21 224.5,145.21 225.32,146.03 226.43,146.03 227.51,144.95 227.51,143.02 229.74,140.79 232.1,140.79 234.77,138.12 234.77,131.05 235.66,130.15 235.66,128.21 235.97,127.9 235.97,125.9 v7(236.38,125.48)
  GND4 w0.119: v9(158.35,95.23) 158.73,94.85 v4(158.73,94.81)
  BOTTOM w0.119: v9(158.35,95.23) 158.72,95.23 160.17,96.68 160.17,97.92 164.42,102.17 164.42,103.77 162.87,105.32 162.87,105.77 v6(162.67,105.98)
SIO_SLP_S5#: length 129.2
  TOP w0.119: v2(219.01,142.55) 219.34,142.22 221.12,142.22 221.35,142.45 221.7,142.45 222.04,142.11 223.04,142.11 223.27,142.33 JAPS2.4
  IN1 w0.06: v1(132.23,111.15) 132.28,111.21 132.28,111.44 132.41,111.57 132.41,112.34 133.92,113.85 136.53,113.85 137.83,115.15 138.18,115.15 138.5,115.47 138.79,115.47
  IN1 w0.089: v8(217.1,132.56) 212.39,132.56 210.1,130.27 210.1,127.17 208.21,125.29 206.92,125.29 206.25,124.61 204.9,124.61 204.17,123.88 203.73,123.88 203.32,123.47 202.72,123.47 201.36,122.12 200.52,122.12 200.22,121.83 197.75,121.83 195.35,119.42 195.35,116.42 189.99,111.06 189.99,109.67 188.59,108.27 188.59,106.84 188.23,106.48 187.76,106.48 186.26,104.98 178.85,104.98 178.66,104.78 170.71,104.78 169.12,106.37 168.86,106.37 168.51,106.72 167.23,106.72 165.35,108.61 164.08,108.61 163.87,108.81 163.87,109.45 162.36,110.97 153.32,110.97 150.22,114.07 148.74,114.07 147.73,115.07 147.2,115.07 146.78,115.49 146.78,116.24 146.07,116.94 145.33,116.94 v1(145.28,116.9) 144.93,116.55 144.49,116.55 144.18,116.24 142.55,116.24 142.39,116.4 141.78,116.4 141.66,116.29 139.6,116.29 138.79,115.47
  GND1 w0.119: v8(217.1,132.56) v4(217.1,133.05)
  IN2 w0.084: v2(219.01,142.55) 218.67,142.88 v4(217.48,142.88)
  IN3 w0.084: v4(217.1,133.05) 217.1,137.24 216.9,137.45 216.9,138.34 216.59,138.64 216.59,141.99 v4(217.48,142.88)
SIO_SLP_SUS#: length 144.8
  TOP w0.119: v2(141.16,113.73) 139.72,113.73 RH55.2
  IN1 w0.06: v2(167.99,126) 167.99,126.09 166.66,127.42 166.66,127.8
  IN1 w0.089: v5(229.17,126.3) 229.31,126.16 229.79,126.16 230.2,125.75 v1(230.31,125.75) ; v3(150.58,125.64) 150.13,126.08 150.13,126.6 149.87,126.87 149.87,128.74 150.4,129.27 159.79,129.27 159.88,129.17 161.39,129.17 162.03,128.53 166.34,128.53 166.66,128.21 166.66,127.8
  GND1 w0.119: v4(229.28,126.68) 229.28,126.41 v5(229.17,126.3)
  IN2 w0.084: v2(167.99,126) 167.99,126 166.85,127.14 166.85,127.63 166.96,127.74 167.71,127.74 168.25,128.27 171.08,128.27 172.12,127.24 176.28,127.24 176.97,126.55 176.97,126.12 178.47,124.62 178.47,123.07 178.77,122.77 178.77,122.51 178.96,122.32 182.36,122.32 183.23,123.19 185.03,123.19 185.76,123.91 189.1,123.91 191.53,126.34 191.53,128.74 191.97,129.19 191.97,130.13 193.07,131.22 194.04,131.22 194.95,132.14 195.63,132.14 196.53,133.03 196.53,134.54 197.65,135.66 201.47,135.66 205.28,139.47 206.6,139.47 207.15,138.92 213.31,138.92 214.31,139.92 216.41,139.92 216.59,139.74 222.25,139.74 v4(222.67,140.17) ; v2(141.16,113.73) 141.24,113.81 141.8,113.81 142.12,114.13 142.83,114.13 142.89,114.2 143.65,114.2 143.94,113.9 146.52,113.9 146.83,114.21 150.1,114.21 v4(150.36,113.95) ; v4(150.15,125.64) v3(150.58,125.64)
  IN3 w0.084: v4(150.36,113.95) 150.02,114.29 150.02,117.33 149.78,117.57 149.78,121.12 149.16,121.74 148.77,121.74 148.48,122.04 148.48,122.42 148.32,122.58 148.32,124.37 148.27,124.41 148.27,124.69 148.65,125.07 149.02,125.07 149.52,125.57 150.08,125.57 v4(150.15,125.64) ; v4(229.28,126.68) 229.55,126.95 229.55,132.23 229.44,132.33 229.44,134.82 225.55,138.72 225.23,138.72 224.49,139.46 224.49,139.71 223.98,140.22 223.98,141.57 223.64,141.91 222.84,141.91 222.67,141.74 v4(222.67,140.17)
SIO_SLP_SUS#_L: length 6.4
  TOP w0.076: UC1.BN10 133.19,112.8 134.01,113.62 136.86,113.62 137.36,114.12 138.42,114.12 RH55.1
SIO_SLP_WLAN#: length 133.1
  TOP w0.119: U27.A8 235.82,123.25 v2(236.15,122.92)
  IN1 w0.06: v1(131.58,111.15) 131.82,111.15 132.29,111.62 132.29,112.42 133.84,113.97 136.39,113.97 137.69,115.27 138.11,115.27 138.39,115.55 138.39,115.83 138.51,115.95 139.02,115.95 139.55,116.49 139.81,116.49
  IN1 w0.089: v3(208.19,125.72) 207.95,125.48 206.84,125.48 206.17,124.8 204.82,124.8 204.09,124.07 203.66,124.07 203.24,123.66 202.64,123.66 201.29,122.31 200.44,122.31 200.14,122.02 197.67,122.02 195.15,119.5 195.15,116.5 189.8,111.14 189.8,109.74 188.39,108.33 188.39,106.91 188.15,106.67 187.68,106.67 186.18,105.17 178.77,105.17 178.58,104.97 170.79,104.97 169.2,106.56 168.94,106.56 168.23,107.27 166.97,107.27 165.89,108.34 165.89,109.22 165.67,109.44 164.15,109.44 162.44,111.16 153.39,111.16 150.3,114.26 149.21,114.26 148.09,115.37 147.33,115.37 147.15,115.55 147.15,116.14 146.11,117.17 145.17,117.17 144.9,116.9 v1(144.61,116.9) 144.57,116.9 144.11,116.44 142.63,116.44 142.46,116.61 141.7,116.61 141.59,116.49 139.81,116.49
  IN2 w0.084: v3(208.19,125.72) 208.85,125.72 209.52,126.39 211.06,126.39 211.2,126.24 212.64,126.24 215.09,123.79 216.46,123.79 217.39,124.72 219.2,124.72 219.64,124.28 220.55,124.28 221.62,123.2 223.12,123.2 224.68,121.64 226.77,121.64 227.84,120.57 227.84,120.43 229.22,119.05 229.93,119.05 230.07,118.9 233.73,118.9 234.98,120.16 234.98,120.74 235.46,121.22 235.46,121.46 236.15,122.16 v2(236.15,122.92)
SKTOCC#: length 6
  TOP w0.119: RC11.1 113.24,96.55 113.94,97.25 113.94,98.14 v1(113.96,98.17)
  IN1 w0.06: 114.15,98.36 114.23,98.43 115.26,98.43 115.37,98.32 115.75,98.32 115.96,98.1 115.96,97.91 116.07,97.8 117.02,97.8 v1(117.23,98)
  IN1 w0.089: v1(113.96,98.17) 114.15,98.36
SKYCAM_CSI0_D: length 70
  TOP w0.152: v10(158.87,133.35) L30.4 158.4,133.35 R1121.1
  GND1 w0.089: v10(158.87,133.35) 158.61,133.35 158.43,133.54 v4(158.43,133.66)
  IN2 w0.06: v4(128.47,96.74) 128.15,96.74 127.74,97.14 127.74,97.68 127.34,98.08 127.34,98.77 v2(127.4,98.83)
  IN3 w0.084: v4(128.47,96.74) 128.67,96.54 130.17,96.54 131.28,95.43 134.45,95.43 134.57,95.32 135.94,95.32 136.2,95.57 138.47,95.57 139.05,96.15 139.05,97.27 139.57,97.8 139.57,98.32 140.06,98.81 141.01,98.81 142.24,100.05 142.9,100.05 144.22,101.37 144.22,101.78 145.87,103.43 145.87,106.25 145.13,106.98 145.13,108.39 146.05,109.31 146.05,115.23 145.57,115.7 145.57,118.38 145,118.95 145,121.31 145.48,121.78 145.48,124.83 146.2,125.55 146.2,127.69 148.09,129.58 148.09,130.29 150.86,133.06 154.73,133.06 155.5,133.84 156.83,133.84 157.7,134.7 158.94,134.7 159.11,134.53 159.11,134.17 158.95,134.01 158.77,134.01 v4(158.43,133.66)
SKYCAM_CSI0_D#: length 70.1
  TOP w0.152: v10(158.87,134.2) L30.1 158.37,134.2 R1118.1
  GND1 w0.089: v10(158.87,134.2) 158.58,134.2 158.55,134.17 v4(158.43,134.17)
  IN2 w0.06: v2(127.4,99.32) 127.4,99.11 127.2,98.91 127.2,98.75 127.22,98.72 127.22,98.03 127.62,97.63 127.62,97.1 128.2,96.52 v4(128.2,96.3)
  IN3 w0.084: v4(128.2,96.3) 128.27,96.38 130.1,96.38 131.21,95.27 134.39,95.27 134.5,95.16 136.01,95.16 136.26,95.41 138.54,95.41 139.21,96.08 139.21,97.21 139.73,97.73 139.73,98.25 140.13,98.65 141.07,98.65 142.31,99.89 142.97,99.89 144.38,101.3 144.38,101.71 146.03,103.36 146.03,106.32 145.29,107.05 145.29,108.33 146.21,109.24 146.21,115.3 145.74,115.77 145.74,118.45 145.17,119.02 145.17,121.24 145.64,121.72 145.64,124.76 146.36,125.48 146.36,127.62 148.25,129.51 148.25,130.23 150.93,132.9 154.79,132.9 155.57,133.68 156.9,133.68 157.77,134.54 158.87,134.54 158.95,134.46 158.95,134.23 158.88,134.17 v4(158.43,134.17)
SKYCAM_CSI0_D#_L: length 17.9
  TOP w0.152: JP1.10 144.31,134.43 144.35,134.47 144.35,134.89 v2(144.33,134.91) ; v2(156.89,134.2) L30.2 157.31,134.2 R1118.2
  IN2 w0.084: v2(144.33,134.91) 144.42,135 144.42,135.28 144.9,135.76 147.14,135.76 147.29,135.61 147.29,134.82 148,134.1 148.54,134.1 148.63,134.19 148.63,134.47 148.81,134.65 149.24,134.65 149.42,134.47 149.42,134.19 149.5,134.1 149.72,134.1 149.95,134.33 155.49,134.33 156.18,135.03 156.48,135.03 156.69,134.82 156.69,134.52 156.61,134.44 156.61,134.06 156.68,133.99 156.82,133.99 156.89,134.06 v2(156.89,134.2)
SKYCAM_CSI0_D_L: length 18
  TOP w0.152: v2(156.89,133.35) L30.3 157.29,133.35 R1121.2 ; JP1.12 144.71,134.45 144.68,134.48 v2(144.68,134.91)
  IN2 w0.084: v2(156.89,133.35) 156.95,133.42 156.95,133.75 156.88,133.83 156.61,133.83 156.44,133.99 156.44,134.5 156.53,134.59 156.53,134.75 156.41,134.86 156.25,134.86 155.56,134.17 150.02,134.17 149.79,133.94 149.43,133.94 149.26,134.12 149.26,134.4 149.17,134.48 148.87,134.48 148.79,134.4 148.79,134.12 148.61,133.94 147.93,133.94 147.13,134.75 147.13,135.54 147.07,135.59 144.96,135.59 144.58,135.21 144.58,135.01 v2(144.68,134.91)
SKYCAM_CSI1_D: length 59.6
  TOP w0.152: R1128.1 144.74,127.83 v10(144.74,127.52)
  GND1 w0.089: v10(144.74,127.52) 144.74,127.62 v4(144.98,127.86)
  IN2 w0.06: v4(125.65,97.21) 125.81,97.21 125.92,97.32 125.92,98.61 125.9,98.63 125.9,98.91 125.96,98.97 125.96,98.97 125.98,98.99 125.98,99.2 v2(126.11,99.32)
  IN3 w0.084: v4(125.65,97.21) 125.85,97.21 126.13,97.49 126.78,97.49 126.94,97.66 130.24,97.66 131.49,96.4 134.5,96.4 134.69,96.59 134.94,96.59 135.32,96.97 136.2,96.97 136.65,97.42 136.65,97.48 137.91,98.75 138.39,98.75 138.71,99.06 138.71,99.54 139.59,100.43 140.25,100.43 140.38,100.55 140.38,101.2 140.58,101.4 140.86,101.4 141.06,101.2 141.06,100.85 141.16,100.74 141.31,100.74 141.41,100.85 141.41,101.41 141.63,101.63 141.92,101.63 142.17,101.88 142.17,102.03 142.09,102.1 140.75,102.1 140.56,102.29 140.56,102.55 140.75,102.74 141.28,102.74 141.38,102.84 141.38,102.98 141.28,103.08 140.9,103.08 140.67,103.3 140.67,105.55 142.13,107 143.83,107 143.99,107.16 143.99,109.6 144.63,110.24 144.85,110.24 144.94,110.33 144.94,110.5 144.85,110.58 144.62,110.58 144.45,110.76 144.45,111.06 144.62,111.24 144.85,111.24 144.94,111.32 144.94,111.72 144.85,111.8 144.62,111.8 144.45,111.98 144.45,112.29 144.62,112.46 144.85,112.46 144.94,112.55 144.94,112.72 144.85,112.8 144.62,112.8 144.45,112.98 144.45,113.28 144.62,113.46 144.85,113.46 144.94,113.54 144.94,113.71 144.85,113.8 144.62,113.8 144.45,113.97 144.45,114.29 144.67,114.51 144.82,114.51 144.93,114.62 144.93,114.77 144.82,114.88 144.67,114.88 144.45,115.1 144.45,117.86 143.89,118.42 143.89,121.82 144.22,122.15 144.22,125.23 144.88,125.89 144.88,127.76 v4(144.98,127.86)
SKYCAM_CSI1_D#: length 59.6
  TOP w0.152: R1127.1 145.59,127.83 v10(145.59,127.52)
  GND1 w0.089: v4(145.23,127.34) 145.41,127.52 v10(145.59,127.52)
  IN2 w0.06: v2(126.11,98.83) 126.11,98.62 126.04,98.56 126.04,97.08 v4(125.65,96.69)
  IN3 w0.084: v4(145.23,127.34) 145.05,127.16 145.05,125.84 144.38,125.17 144.38,122.08 144.05,121.75 144.05,118.49 144.61,117.93 144.61,115.17 144.74,115.04 144.88,115.04 145.09,114.84 145.09,114.55 144.88,114.35 144.74,114.35 144.61,114.22 144.61,114.04 144.69,113.96 144.92,113.96 145.1,113.78 145.1,113.48 144.92,113.3 144.69,113.3 144.61,113.21 144.61,113.05 144.69,112.96 144.92,112.96 145.1,112.78 145.1,112.48 144.92,112.3 144.69,112.3 144.61,112.22 144.61,112.05 144.69,111.97 144.92,111.97 145.1,111.79 145.1,111.26 144.92,111.08 144.69,111.08 144.61,110.99 144.61,110.83 144.69,110.74 144.92,110.74 145.1,110.56 145.1,110.26 144.92,110.08 144.7,110.08 144.15,109.53 144.15,107.09 143.9,106.84 142.2,106.84 140.84,105.48 140.84,103.37 140.96,103.24 141.35,103.24 141.55,103.04 141.55,102.77 141.35,102.58 140.82,102.58 140.73,102.49 140.73,102.36 140.82,102.27 142.16,102.27 142.33,102.09 142.33,101.82 141.98,101.47 141.7,101.47 141.57,101.34 141.57,100.78 141.38,100.58 141.1,100.58 140.9,100.78 140.9,101.13 140.8,101.24 140.65,101.24 140.54,101.13 140.54,100.49 140.32,100.26 139.66,100.26 138.87,99.48 138.87,98.99 138.46,98.59 137.98,98.59 136.81,97.42 136.81,97.35 136.27,96.81 135.39,96.81 135.01,96.43 134.75,96.43 134.56,96.24 131.43,96.24 130.17,97.49 127.01,97.49 126.85,97.33 126.2,97.33 125.99,97.13 125.99,97.02 v4(125.65,96.69)
SKYCAM_CSI1_D#_L: length 28.3
  TOP w0.152: v10(143.71,132.76) 143.71,132.95 143.11,133.55 JP1.4 ; v10(145.59,129.22) 145.59,128.91 R1127.2
  GND1 w0.089: v4(143.64,132.29) 143.8,132.44 143.8,132.68 143.72,132.76 v10(143.71,132.76) ; v10(145.59,129.22) v4(145.59,129.61)
  IN3 w0.084: v4(145.59,129.61) 145.59,130.1 145.37,130.32 145.28,130.32 145.15,130.44 145.15,130.62 145.28,130.74 146.2,130.74 146.32,130.87 146.32,131.28 146.45,131.4 146.71,131.4 146.83,131.28 146.83,131.26 147.06,131.03 147.44,131.03 150.41,134.01 154.32,134.01 154.54,134.23 154.54,134.67 154.32,134.89 149.47,134.89 149.12,134.54 146.89,134.54 146.25,133.89 144.98,133.89 143.74,132.66 143.74,132.39 v4(143.64,132.29)
SKYCAM_CSI1_D_L: length 28.3
  TOP w0.152: v10(144.74,129.22) 144.74,128.91 R1128.2 ; JP1.6 143.51,133.62 144.05,133.08 144.05,132.79 v10(144.08,132.76)
  GND1 w0.089: v4(144.16,132.29) 144.01,132.43 144.01,132.7 144.08,132.76 v10(144.08,132.76) ; v10(144.74,129.22) v4(144.74,129.6)
  IN3 w0.084: v4(144.16,132.29) 143.91,132.54 143.91,132.59 145.04,133.73 146.31,133.73 146.96,134.38 149.18,134.38 149.54,134.73 154.25,134.73 154.37,134.61 154.37,134.3 154.25,134.17 150.35,134.17 147.37,131.2 147.12,131.2 147,131.32 147,131.34 146.77,131.56 146.38,131.56 146.16,131.34 146.16,130.94 146.13,130.9 145.21,130.9 144.99,130.69 144.99,130.38 145.21,130.16 145.3,130.16 145.43,130.03 145.43,129.96 145.07,129.6 v4(144.74,129.6)
SKYCAM_CSI2_D: length 71.8
  TOP w0.152: v10(158.87,131.45) L32.4 158.4,131.45 R1133.1
  GND1 w0.089: v10(158.87,131.45) 158.56,131.45 158.45,131.55 v4(158.45,131.76)
  IN2 w0.06: v2(127.07,99.07) 127.07,99.07 127.07,97.87 127.46,97.47 127.46,96.6 127.34,96.48 127.34,96.17 127.88,95.63 128.73,95.63 129.01,95.91 129.05,95.91 v4(129.17,96.02)
  IN3 w0.084: v4(158.45,131.76) 158.45,131.83 158.59,131.97 158.6,131.97 158.73,132.1 158.75,132.1 158.94,132.29 158.94,132.71 158.7,132.96 158.02,132.96 157.78,132.72 157.78,132.43 157.7,132.35 157.43,132.35 157.36,132.43 157.36,132.78 157.18,132.96 155.41,132.96 154.93,132.48 151.06,132.48 148.67,130.1 148.67,129.29 146.78,127.4 146.78,125.35 146.03,124.6 146.03,121.52 145.56,121.05 145.56,119.22 146.14,118.65 146.14,115.92 147.02,115.03 147.02,114.13 146.6,113.72 146.6,109.07 145.71,108.17 145.71,107.19 146.42,106.48 146.42,103.18 144.88,101.64 144.88,101.25 143.13,99.5 142.48,99.5 142.08,99.11 142.08,99.1 140.51,97.53 140.51,97.2 139.69,96.39 139.69,96.01 138.69,95 136.47,95 136.23,94.77 134.31,94.77 134.21,94.86 131.26,94.86 130.15,95.97 129.66,95.97 129.63,95.95 129.24,95.95 v4(129.17,96.02)
SKYCAM_CSI2_D#: length 71.8
  TOP w0.152: R1132.1 158.37,132.3 L32.1 v10(158.87,132.3)
  GND1 w0.089: v4(158.45,132.32) 158.58,132.32 158.56,132.3 v10(158.87,132.3)
  IN2 w0.06: v4(129.6,95.59) 129.48,95.72 128.99,95.72 128.78,95.51 127.83,95.51 127.22,96.12 127.22,96.53 127.34,96.65 127.34,97.42 126.95,97.82 126.95,98.91 126.92,98.94 126.85,99.01 126.85,99.14 127.07,99.36 v2(127.07,99.57)
  IN3 w0.084: v4(158.45,132.32) 158.51,132.26 158.68,132.26 158.78,132.36 158.78,132.65 158.63,132.8 158.08,132.8 157.94,132.65 157.94,132.36 157.77,132.19 157.36,132.19 157.19,132.36 157.19,132.72 157.11,132.8 155.48,132.8 155,132.32 151.12,132.32 148.84,130.03 148.84,129.23 146.94,127.33 146.94,125.28 146.19,124.53 146.19,121.45 145.73,120.99 145.73,119.29 146.3,118.72 146.3,115.99 147.19,115.1 147.19,114.07 146.77,113.65 146.77,109 145.87,108.1 145.87,107.26 146.58,106.55 146.58,103.11 145.04,101.57 145.04,101.18 143.2,99.34 142.55,99.34 142.25,99.04 142.25,99.03 140.67,97.46 140.67,97.14 139.86,96.32 139.86,95.94 138.76,94.84 136.53,94.84 136.3,94.61 134.24,94.61 134.14,94.7 131.2,94.7 130.09,95.81 129.77,95.81 129.6,95.64 v4(129.6,95.59)
SKYCAM_CSI2_D#_L: length 16.2
  TOP w0.152: R1132.2 157.31,132.3 L32.2 v2(156.89,132.3) ; JP1.22 146.71,133.8 146.72,133.78 146.72,133.52 v2(146.72,133.51)
  IN2 w0.084: v2(146.72,133.51) 146.79,133.59 146.79,133.79 146.97,133.97 147.35,133.97 148.27,133.05 149.66,133.05 150.39,133.78 150.77,133.78 150.99,133.57 150.99,133.31 151.12,133.18 151.33,133.18 151.45,133.31 151.45,133.56 151.68,133.78 152.02,133.78 152.24,133.56 152.24,133.24 152.37,133.12 152.58,133.12 152.71,133.24 152.71,133.56 152.93,133.78 153.27,133.78 153.5,133.56 153.5,133.26 153.63,133.13 153.84,133.13 153.96,133.26 153.96,133.56 154.18,133.78 154.69,133.78 154.91,133.56 154.91,132.89 155,132.81 155.9,132.81 156.66,132.05 156.79,132.05 156.89,132.15 v2(156.89,132.3)
SKYCAM_CSI2_D_L: length 16.2
  TOP w0.152: v2(156.89,131.45) L32.3 157.29,131.45 R1133.2 ; JP1.24 147.11,133.83 147.06,133.78 147.06,133.54 147.09,133.51 v2(147.1,133.51)
  IN2 w0.084: v2(156.89,131.45) 156.89,131.78 156.79,131.89 156.6,131.89 155.83,132.65 154.93,132.65 154.75,132.83 154.75,133.49 154.62,133.62 154.25,133.62 154.13,133.49 154.13,133.19 153.9,132.97 153.56,132.97 153.34,133.19 153.34,133.49 153.21,133.62 153,133.62 152.87,133.5 152.87,133.18 152.65,132.95 152.3,132.95 152.08,133.18 152.08,133.49 151.95,133.62 151.74,133.62 151.62,133.49 151.62,133.24 151.39,133.02 151.05,133.02 150.83,133.24 150.83,133.5 150.71,133.62 150.45,133.62 149.73,132.89 148.2,132.89 147.28,133.81 147.04,133.81 146.96,133.72 146.96,133.65 v2(147.1,133.51)
SKYCAM_CSI3_D: length 76.2
  TOP w0.152: R1135.1 158.4,135.26 L33.4 158.74,135.25 158.78,135.21 v10(158.87,135.21)
  GND1 w0.089: v10(158.87,135.21) 158.82,135.16 158.3,135.16 v4(158.11,135.35)
  IN2 w0.06: v4(126.38,96.46) 126.38,96.6 126.49,96.71 126.7,96.71 126.87,96.89 126.87,97.16 126.43,97.6 v2(126.43,99.07)
  IN3 w0.084: v4(126.38,96.46) 126.59,96.67 126.79,96.67 127.21,97.09 130,97.09 131.26,95.83 135.2,95.83 135.57,96.2 136.51,96.2 136.78,96.47 137.67,96.47 139.17,97.97 139.17,98.51 139.56,98.9 139.56,99.29 139.97,99.7 141.31,99.7 142.56,100.95 142.56,101.25 143.5,102.19 144.03,102.19 145.46,103.63 145.46,105.62 144.74,106.35 144.74,108.67 145.65,109.58 145.65,115.08 145.18,115.55 145.18,118.2 144.61,118.77 144.61,121.5 145.09,121.98 145.09,125.06 145.8,125.78 145.8,128 147.49,129.69 147.49,130.28 150.66,133.45 154.56,133.45 155.48,134.38 155.48,134.63 155.15,134.97 155.15,135.08 155.27,135.2 155.39,135.2 156.31,134.28 156.58,134.28 156.78,134.47 156.78,134.75 155.85,135.67 155.85,135.79 155.97,135.91 156.09,135.91 157.06,134.94 157.37,134.94 157.62,135.2 157.62,135.43 157.23,135.82 157.23,135.97 157.27,136.01 157.55,136.01 158.11,135.45 v4(158.11,135.35)
SKYCAM_CSI3_D#: length 76.3
  TOP w0.152: R1134.1 158.37,136.11 L33.1 158.79,136.15 v10(158.87,136.15)
  GND1 w0.089: v4(158.11,135.94) 158.2,136.03 158.75,136.03 v10(158.87,136.15)
  IN2 w0.06: v2(126.43,99.57) 126.43,99.36 126.22,99.15 126.22,99 126.31,98.91 126.31,97.55 126.75,97.11 126.75,96.94 126.65,96.83 126.54,96.83 v4(126.38,96.99)
  IN3 w0.084: v4(158.11,135.94) 157.85,135.94 157.61,136.18 157.21,136.18 157.07,136.04 157.07,135.76 157.46,135.36 157.46,135.26 157.3,135.1 157.13,135.1 156.16,136.07 155.91,136.07 155.69,135.86 155.69,135.6 156.61,134.68 156.61,134.54 156.51,134.44 156.38,134.44 155.45,135.37 155.2,135.37 154.99,135.15 154.99,134.9 155.32,134.56 155.32,134.44 154.49,133.61 150.59,133.61 147.33,130.35 147.33,129.76 145.64,128.07 145.64,125.84 144.93,125.13 144.93,122.05 144.45,121.56 144.45,118.7 145.01,118.13 145.01,115.48 145.49,115.01 145.49,109.65 144.57,108.74 144.57,106.28 145.3,105.55 145.3,103.7 143.96,102.36 143.43,102.36 142.39,101.32 142.39,101.02 141.24,99.86 139.9,99.86 139.4,99.36 139.4,98.97 139.01,98.58 139.01,98.04 137.6,96.63 136.71,96.63 136.44,96.36 135.5,96.36 135.13,95.99 131.33,95.99 130.07,97.25 127.14,97.25 126.72,96.83 126.54,96.83 v4(126.38,96.99)
SKYCAM_CSI3_D#_L: length 11.5
  TOP w0.152: v2(147.96,134.73) 147.96,134.49 147.91,134.44 JP1.28 ; R1134.2 157.31,136.11 L33.2 156.86,136.11 v2(156.84,136.13)
  IN2 w0.084: v2(156.84,136.13) 156.84,135.99 156.72,135.87 156.24,135.87 155.25,134.88 149.87,134.88 149.2,135.55 148.48,135.55 148.05,135.13 148.05,134.82 v2(147.96,134.73)
SKYCAM_CSI3_D_L: length 11.5
  TOP w0.152: v2(156.84,135.22) 156.88,135.26 L33.3 157.29,135.26 R1135.2 ; v2(148.32,134.73) 148.3,134.71 148.3,134.46 148.31,134.44 JP1.30
  IN2 w0.084: v2(148.32,134.73) 148.21,134.83 148.21,135.06 148.55,135.39 149.13,135.39 149.8,134.72 155.32,134.72 156.3,135.71 156.71,135.71 156.84,135.58 v2(156.84,135.22)
SKYCAM_CSI_CLK_D: length 57
  TOP w0.152: R1094.1 142.85,127.84 v10(142.85,127.53)
  GND1 w0.089: v10(142.85,127.53) 142.85,127.53 142.89,127.53 v4(143.17,127.25)
  IN2 w0.06: v2(126.75,98.83) 126.75,97.65 127.2,97.2 127.2,96.68 126.91,96.39 126.91,96.39 126.46,95.94 125.94,95.94 125.86,95.87 v4(125.86,95.72)
  IN3 w0.084: v4(143.17,127.25) 143.31,127.25 143.52,127.04 143.52,126.75 143.74,126.53 144.2,126.53 144.32,126.41 144.32,126.25 144.2,126.13 143.88,126.13 143.66,125.91 143.66,122.45 143.33,122.12 143.33,118.19 143.87,117.65 143.87,110.32 143.42,109.87 143.42,108.97 143.29,108.85 142.42,108.85 142.2,108.63 142.2,108.31 142.42,108.09 143.29,108.09 143.41,107.96 143.41,107.69 143.29,107.56 141.9,107.56 139.98,105.64 139.98,103.56 139.7,103.28 139.7,102.45 139.39,102.14 139.39,101.15 137.33,99.09 137.33,99.01 136.67,98.34 136.29,98.34 136.27,98.37 135.37,98.37 134.95,97.94 134.95,97.53 134.23,96.82 131.64,96.82 130.39,98.06 126.75,98.06 126.58,97.89 125.56,97.89 124.99,97.32 124.99,96.26 125.44,95.82 125.76,95.82 v4(125.86,95.72)
SKYCAM_CSI_CLK_D#: length 57
  TOP w0.152: R1093.1 143.7,127.84 v10(143.7,127.53)
  GND1 w0.089: v10(143.7,127.53) 143.7,127.4 v4(143.9,127.2)
  IN2 w0.06: v4(125.86,96.22) 125.86,96.15 125.95,96.06 126.41,96.06 126.79,96.44 126.79,96.44 127.08,96.73 127.08,97.15 126.63,97.6 126.63,98.55 126.55,98.63 126.55,98.91 126.66,99.02 126.66,99.14 126.63,99.17 126.63,99.3 126.65,99.32 v2(126.75,99.32)
  IN3 w0.084: v4(125.86,96.22) 125.86,96.21 125.63,95.98 125.5,95.98 125.15,96.33 125.15,97.25 125.63,97.73 126.65,97.73 126.82,97.9 130.33,97.9 131.57,96.66 134.3,96.66 135.11,97.46 135.11,97.87 135.44,98.2 136.2,98.2 136.22,98.18 136.74,98.18 137.5,98.94 137.5,99.03 139.55,101.08 139.55,102.08 139.86,102.38 139.86,103.21 140.14,103.49 140.14,105.57 141.97,107.4 143.36,107.4 143.58,107.62 143.58,108.03 143.36,108.25 142.49,108.25 142.36,108.37 142.36,108.56 142.49,108.68 143.36,108.68 143.58,108.91 143.58,109.8 144.03,110.25 144.03,117.71 143.49,118.26 143.49,122.06 143.82,122.39 143.82,125.84 143.95,125.97 144.27,125.97 144.48,126.18 144.48,126.48 144.27,126.69 143.81,126.69 143.68,126.82 143.68,126.98 v4(143.9,127.2)
SKYCAM_CSI_CLK_D#_L: length 30.7
  TOP w0.152: JP1.16 145.51,134.41 145.55,134.45 145.55,134.71 v10(145.52,134.73) ; R1093.2 143.7,128.92 v10(143.7,129.23)
  GND1 w0.089: v10(145.52,134.73) 145.52,134.34 v4(145.46,134.28) ; v10(143.7,129.23) v4(143.7,128.84)
  IN3 w0.084: v4(145.46,134.28) 145.59,134.28 145.7,134.4 145.7,134.55 145.6,134.65 145.19,134.65 143.24,132.7 143.24,131.96 143.36,131.83 144.44,131.83 145.62,133.01 145.74,133.01 146.06,133.33 146.36,133.33 146.68,133.01 146.88,133.01 146.98,133.12 146.98,133.76 147.21,133.98 148.83,133.98 149.05,133.76 149.05,133.43 148.83,133.21 147.93,133.21 147.81,133.08 147.81,132.2 147.58,131.98 145.72,131.98 144.35,130.61 144.35,129.46 144.13,129.23 143.71,129.23 143.49,129.46 143.49,130.02 143.36,130.15 141.07,130.15 140.94,130.02 140.94,129.05 141.07,128.93 141.4,128.93 141.52,129.05 141.52,129.25 141.75,129.47 142.95,129.47 143.17,129.25 143.17,128.96 143.4,128.74 143.6,128.74 v4(143.7,128.84)
SKYCAM_CSI_CLK_D_L: length 30.7
  TOP w0.152: v10(145.9,134.73) 145.89,134.72 145.89,134.42 145.91,134.4 JP1.18 ; v10(142.85,129.23) 142.85,128.92 R1094.2
  GND1 w0.089: v10(142.85,129.23) v4(142.85,128.84) ; v10(145.9,134.73) 146.03,134.6 v4(146.03,134.28)
  IN3 w0.084: v4(142.85,128.84) 142.85,128.85 143.01,129.01 143.01,129.18 142.88,129.31 141.81,129.31 141.69,129.18 141.69,128.99 141.47,128.76 141,128.76 140.78,128.99 140.78,130.09 141,130.31 143.43,130.31 143.65,130.09 143.65,129.52 143.78,129.4 144.06,129.4 144.19,129.52 144.19,130.68 145.65,132.14 147.52,132.14 147.64,132.27 147.64,133.15 147.87,133.37 148.76,133.37 148.89,133.5 148.89,133.69 148.76,133.82 147.27,133.82 147.15,133.69 147.15,133.05 146.95,132.85 146.61,132.85 146.29,133.17 146.12,133.17 145.81,132.85 145.69,132.85 144.51,131.67 143.3,131.67 143.07,131.89 143.07,132.77 145.12,134.82 145.67,134.82 145.86,134.62 145.86,134.45 v4(146.03,134.28)
SKYCAM_I2C_CLK: length 113.3
  IN1 w0.06: v1(133.91,107.37) 134.03,107.25 134.73,107.25 134.73,107.24 134.74,107.24 135.04,106.94 135.69,106.94 135.9,106.72 136.94,106.72 137.13,106.92 137.88,106.92 v5(137.93,106.87)
  GND1 w0.089: v5(137.93,106.87) 138.18,107.12 v4(138.31,107.12)
  IN2 w0.06: v4(138.31,107.12) 138.64,107.12 138.96,106.8 139.67,106.8
  IN2 w0.084: v4(199.99,117.23) 199.5,116.73 198.89,116.73 197.46,115.3 197.46,114.94 190.25,107.73 190.25,105.88 189.51,105.15 188.91,105.15 188.86,105.09 187.23,105.09 186.29,104.15 183.08,104.15 182.55,103.62 178.05,103.62 177.04,104.63 173.06,104.63 172.34,103.9 168.63,103.9 168.31,103.58 166.02,103.58 164.7,102.27 163.18,102.27 162.74,101.84 161.45,101.84 161.04,102.24 159.36,102.24 158.71,101.59 154.08,101.59 153,102.67 152.45,102.67 152.2,102.92 150.54,102.92 149.81,103.64 148.01,103.64 146.67,104.98 146.67,105.71 144.47,107.91 141.72,107.91 140.77,106.97 140.21,106.97 140.16,107.02 139.97,107.02 139.92,106.97 139.83,106.97 139.67,106.8 ; v4(194.62,144.13) 194.19,143.7 v2(194.17,143.7)
  IN3 w0.084: v4(199.99,117.23) 199.99,117.82 196.85,120.97 195.32,120.97 193.19,123.1 193.19,125.08 191.47,126.8 191.47,131.91 191.95,132.38 191.95,135.49 193.41,136.96 193.41,143.3 193.78,143.67 194.16,143.67 v4(194.62,144.13)
  GND4 w0.089: v6(138.82,107.02) 138.41,107.02 v4(138.31,107.12)
  BOTTOM w0.152: v6(138.82,107.02) 138.77,106.97 RH73.2
SKYCAM_I2C_DATA: length 110.7
  IN1 w0.06: v1(134.9,107.37) 135.04,107.37 135.31,107.09 135.71,107.09 135.95,106.84 136.89,106.84 137.14,107.09 v3(139.38,107.09)
  GND1 w0.089: v4(139.12,107.63) 139.12,107.35 v3(139.38,107.09)
  IN2 w0.06: 193.27,143.6 193.37,143.5 193.96,143.5 194.16,143.3 v2(194.17,143.3)
  IN2 w0.084: 193.27,143.6 193.25,143.6 v4(193.1,143.75) ; v4(199.49,117.27) 198.77,117.27 196.81,115.3 196.81,114.94 189.78,107.92 189.78,106.08 189.32,105.61 188.75,105.61 188.69,105.56 187.04,105.56 186.17,104.69 182.2,104.69 181.59,104.09 178.24,104.09 177.24,105.09 172.87,105.09 172.14,104.37 168.44,104.37 168.12,104.05 165.83,104.05 164.53,102.75 158.97,102.75 158.27,102.06 154.28,102.06 153.19,103.14 152.64,103.14 152.39,103.38 150.73,103.38 149.74,104.37 148.67,104.37 144.66,108.38 141.52,108.38 140.75,107.6 139.93,107.6 139.86,107.53 139.86,107.35 139.6,107.09 v3(139.38,107.09)
  IN3 w0.084: v4(199.49,117.27) 199.49,117.65 196.63,120.51 195.13,120.51 192.73,122.91 192.73,124.89 190.98,126.63 190.98,132.07 191.48,132.57 191.48,135.69 192.95,137.15 192.95,143.6 v4(193.1,143.75)
  GND4 w0.089: v6(138.72,107.6) 139.1,107.6 v4(139.12,107.63)
