# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA_CHG: length 7.4
  TOP w0.254: PQ402.4 53.64,137.49 53.19,137.04 52.66,137.04 52.34,136.72 PQ402.1 52.34,135.18 51.86,134.7 v1(51.86,134.22)
  TOP w0.508: PR425.2 v1(50.2,124.37) ; PC431.2 56.57,122.79 PR424.1 56.75,123.96 v1(56.76,123.97)
  vias: v1(50.2,132.37) v1(50.2,130.59) v1(50.2,129.7) v1(52.89,132.37) v1(53.21,123.99) v1(53.54,124) v1(53.87,124) v1(54.2,124) v1(54.67,132.37) v1(55.28,133.73) v1(55.28,133.35) v1(55.63,133.73) v1(55.63,133.35) v1(58.48,132.23) v1(58.53,124.62) v7(53.93,129.6) v7(53.93,128.56) v7(53.93,127.52) v7(54.97,129.6) v7(54.97,128.56) v7(54.97,127.52) v7(56.01,129.6) v7(56.01,128.56) v7(56.01,127.52)
SGND4: length 5
  TOP w0.119: PR508.2 162.27,123.06 v1(162.79,123.06)
  IN1 w0.06: 164.06,122.31 164.19,122.31 164.27,122.39 164.83,122.39 165.13,122.68 165.6,122.68 165.69,122.6 166.19,122.6 v1(166.39,122.8)
  IN1 w0.089: 164.06,122.31 163.48,122.31 163.02,122.77 163.02,122.83 v1(162.79,123.06)
SGND11: length 35.3
  GND1 w0.102: v4(167.61,121.95) 167.65,122 v10(167.99,122)
  IN3 w0.084: v6(162.24,106.46) 162.25,106.46 162.38,106.59 162.38,109.06
  IN3 w0.102: v4(167.61,121.95) 167.53,122.03 167.53,122.55 167.19,122.89 166.1,122.89 165.98,122.78 165.98,122.21 166.15,122.04 166.15,120.65 165.56,120.06 165.56,118.57 164.2,117.2 164.2,114.26 164.03,114.1 164.03,113.72 164.8,112.95 164.8,111.9 164.42,111.51 163.66,111.51 163.14,110.99 163.14,109.82 162.38,109.06
  BOTTOM w0.102: PR612.1 152.75,105.06 154.09,103.72 155.34,103.72 156.61,104.99 159.65,104.99 160.03,104.61 161.65,104.61 162.39,105.34 162.39,106 162.24,106.15 v6(162.24,106.46)
SGND12: length 10
  TOP w0.102: PU500.P11 169.59,121.03 v1(170.21,120.41)
  IN1 w0.089: v2(173.34,113.57) 173.26,113.65 173.26,115.81 173.46,116.01 173.46,118.28 172.53,119.21 172.22,119.21 172.04,119.39 171.83,119.39 170.81,120.41 v1(170.21,120.41)
VBUS1_ACOK: length 267.5
  TOP w0.119: U27.N9 229.77,122.75 229.38,122.36 v1(229.38,122.26)
  TOP w0.254: PC103.1 41.31,137.81 41.31,136.84 41.99,136.15 PR130.2 42.7,136.71 43.74,136.71 44.64,135.81 ; v1(47.4,136.21) 46.85,136.76 46.26,136.76 46.13,136.89 45.07,136.89 44.64,136.46 44.64,135.81 ; 44.64,135.81 PU100.7 ; PR143.2 49.08,130.54 48.62,131 47.76,131 v1(47.68,131.07)
  IN1 w0.06: 229.34,122.26 v1(229.38,122.26)
  IN1 w0.089: v1(47.4,136.21) 47.56,136.37 47.56,136.61 47.83,136.89 47.83,140.31 46.78,141.36 v3(43.34,141.36) ; v3(227.64,122.79) 227.91,123.06 228.47,123.06 229.23,122.3 229.3,122.3 229.34,122.26
  IN1 w0.254: v1(47.68,131.07) 47.61,131.15 47.33,131.15 46.97,131.5 46.97,135.47 47.4,135.89 v1(47.4,136.21)
  IN2 w0.084: v4(222.13,145.25) 221.7,145.68 221.44,145.68 v4(220.35,146.77) ; v4(88.06,135.25) 87.83,135.47 85.26,135.47 84.98,135.75 83.55,135.75 83.04,136.25 80.09,136.25 75.94,140.41 75.94,141.21 71.84,145.31 68.09,145.31 67.85,145.55 66.82,145.55 66.51,145.24 63.46,145.24 62.34,146.36 61.45,146.36 60.36,145.27 59.32,145.27 58.91,144.86 58.43,144.86 56.16,147.12 49.1,147.12 v3(43.34,141.36) ; v3(227.64,122.79) v4(227.23,123.2)
  IN3 w0.084: v4(220.35,146.77) 220.2,146.62 207.37,146.62 206.28,145.52 198.33,145.52 196.68,147.18 194.42,147.18 191.54,144.29 191.54,143.23 189.87,141.56 189.87,138.68 188.17,136.97 180.24,136.97 177.96,134.69 176.51,134.69 176.29,134.46 173.83,134.46 172.14,136.15 164.16,136.15 163.15,135.15 160.84,135.15 160.76,135.23 159.62,135.23 159.05,135.8 159,135.8 158.23,136.57 155.58,136.57 154.35,135.34 149.32,135.34 149.19,135.2 144.96,135.2 142.63,132.87 142.63,132.23 v6(142.56,132.17) ; v4(227.23,123.2) 227.5,123.46 227.5,126.1 229.01,127.61 229.01,131.93 228.86,132.07 228.86,134.64 225.43,138.07 225.04,138.07 224.3,138.8 222.99,138.8 222.31,139.49 221.7,139.49 221.09,140.1 221.09,144.55 221.36,144.83 221.71,144.83 v4(222.13,145.25)
  GND4 w0.119: v9(87.87,135.78) 87.87,135.43 v4(88.06,135.25)
  BOTTOM w0.119: v6(142.56,132.17) 142.47,132.17 140.5,130.2 128.01,130.2 126.87,131.34 126.87,134.47 125.54,135.8 107.97,135.8 106.13,133.96 104.67,133.96 103.08,135.55 92.45,135.55 92.23,135.78 v9(87.87,135.78)
VBUS2_ACOK: length 254.8
  TOP w0.119: v1(49.36,145.37) 49.36,143.9 49.36,143.89 49.36,141.59 48.96,141.19 48.32,141.19 48.12,141 48.12,139.33 48.04,139.25 48.04,138.64 PR115.2
  TOP w0.254: PR147.2 44.96,131.61 v1(45.88,131.61) ; v1(47.33,136.81) 47.58,137.07 PR128.2 47.57,137.33 PR115.2 47.56,138.16 PC102.1 45.73,138.16 45.29,138.6 PU100.1
  IN1 w0.089: v3(226.31,146.06) 225.95,145.7 215.96,145.7 214.1,143.85 212.49,143.85 212.28,143.65 207.66,143.65 205.74,145.57 203.08,145.57 202.37,146.28 196.71,146.28 196.45,146.54 189.64,146.54 189.19,146.08 189.19,138.14 188.5,137.46 181.57,137.46 179.07,134.96 174.36,134.96 173.51,135.82 173,135.82 171.75,137.07 162.79,137.07 162.5,136.77 159.73,136.77 159.47,136.51 156.66,136.51 156.54,136.38 155.2,136.38 153.7,134.89 149.78,134.89 149.09,135.59 146.7,135.59 146.31,135.97 144.2,135.97 143.69,135.46 142.35,135.46 141.69,134.8 141.69,133.13 139.96,131.4 139.14,131.4 137.44,129.69 136.9,129.69 134.27,132.33 132.16,132.33 131.11,133.38 131.11,136.86 130.04,137.93 104.42,137.93 103.27,136.78 102.67,136.78 102.29,137.16 101.1,137.16 100.52,137.74 91.15,137.74 90.76,138.13 81.53,138.13 80.97,137.57 79.39,137.57 78.41,138.55 78.41,142.27 77.9,142.79 67.61,142.79 66.74,141.92 66.74,141.74 65.48,140.48 61.95,140.48 60.98,141.45 59,143.44 57.34,143.44 56.78,142.88 53.41,142.88 50.91,145.37 v1(49.36,145.37)
  IN1 w0.254: v1(45.88,131.61) 45.88,132.37 46.62,133.1 46.62,135.9 46.92,136.2 46.92,136.41 v1(47.33,136.81)
  IN2 w0.084: v2(235.31,125.25) 235.26,125.29 v4(235.26,125.71) ; v3(226.31,146.06) v4(226.31,145.63)
  IN3 w0.084: v4(235.26,125.71) 235.62,126.07 235.62,127.62 235.44,127.8 235.44,130.11 234.58,130.97 234.58,138.04 232.02,140.6 229.67,140.6 226.31,143.96 v4(226.31,145.63)
VCC0V9_CIO: length 3
  BOTTOM w0.356: C1324.2 27.5,33.18 26.97,33.71 v7(26.88,33.71) 26.87,33.73 C1323.2 26.87,34.96 C1325.2 26.26,35.05 v7(26.23,35.01)
VCC0V9_DP: length 3.8
  BOTTOM w0.254: C1296.2 25.48,34.47 v7(24.93,35.01)
  BOTTOM w0.305: v7(25.58,33.06) 26.05,32.59 C1299.2
  BOTTOM w0.356: C1292.2 24.4,33.19 v7(24.28,33.06) ; v7(24.93,33.06) 25.03,33.16 C1293.2
  BOTTOM w0.381: C1295.2 24.96,35.05 v7(24.93,35.01)
  vias: v6(29.6,35.91) v6(29.6,35.34) v7(27.53,35.66) v7(27.53,35.01)
VCC0V9_LVR_OUT:
  vias: v7(22.98,37.61) v7(23.63,37.61) v7(23.63,35.01) v7(23.77,44.61) v7(24.33,44.62) v7(24.28,35.01)
VCC0V9_PCIE:
  vias: v7(24.93,38.26) v7(24.93,37.61) v7(24.93,36.96) v7(24.93,36.31) v7(25.58,38.26)
VCC0V9_SVR:
  vias: v1(15.27,26.58) v1(15.28,25.69) v1(15.29,24.8) v1(15.42,27.48) v1(15.43,26.87) v1(15.43,25.97) v1(15.43,25.08) v1(15.73,27.17) v4(17.34,25.8) v4(17.67,25.47) v4(17.89,24.75) v4(17.98,25.8) v4(18.04,25.18) v4(18.35,25.52) v4(18.48,25.04) v5(16.34,26.22) v5(16.52,25.66) v5(16.57,25.98) v5(16.74,25.43) v5(16.82,25.74) v5(17.04,25.51) v5(17.29,25.27) v5(17.55,25.03) v7(22.33,36.96) v7(22.33,36.31) v7(22.33,35.66) v7(22.33,35.01) v7(24.28,34.36) v7(24.93,34.36) v16(17.75,26.28) v16(17.76,26.61) v16(18.14,26.61) v16(18.13,26.28) v16(18.52,26.61) v16(18.51,26.28) v16(18.9,26.61) v16(18.89,26.28)
VCC0V9_USB: length 1.5
  GND1 w0.254: v10(26.55,36.64) 26.56,36.64 26.83,36.91 v4(26.83,37.03) 26.82,37.03 26.55,37.29 v10(26.55,37.29)
  GND4 w0.254: v4(26.83,37.03) 26.41,37.03 v9(26.24,36.86)
VCC1V8A_TBTA_LDO: length 4.7
  IN1 w0.203: v1(7.77,47.06) 7.77,47.9 8.11,48.24 8.11,48.6 8.36,48.85 9.33,48.85 9.77,49.3 9.77,49.88 v1(9.42,50.23)
VCC1V8A_TBTB_LDO: length 4.6
  IN1 w0.254: v1(22.75,49.98) 21.83,49.98 21.16,49.31 21.16,47.94 20.58,47.35 v1(20.09,47.35)
VCC1V8D_TBTA_LDO: length 5.3
  TOP w0.508: C1336.1 10.17,55.51 v7(10.09,55.43) 10.14,55.43 10.17,55.41 9.92,55.16 U717.A2
  BOTTOM w0.508: R5685.2 12.26,54.68 11.41,55.53 10.19,55.53 v7(10.09,55.43)
VCC1V8D_TBTB_LDO: length 3.3
  TOP w0.508: U719.A2 23.25,55.06 v7(22.9,55.41) C1352.1
  BOTTOM w0.508: R5687.2 23.79,54.52 v7(22.9,55.41)
VCC3V3_ANA_PCIE: length 2
  TOP w0.102: v7(24.28,37.61) UT1.L16
  BOTTOM w0.127: v7(24.28,37.61) 23.86,38.03 23.33,38.03 23.12,38.24 C1326.2
VCC3V3_ANA_USB2: length 1
  TOP w0.102: v7(24.28,36.96) UT1.J16
  BOTTOM w0.127: C1327.2 24.15,37.09 v7(24.28,36.96)
VCC3V3_LC: length 22
  TOP w0.203: v7(26.88,33.06) 26.86,33.05 UT1.R6
  TOP w0.254: R1383.1 R1384.1 34.73,27.35 R1385.1 34.55,27.35 34.19,27.71 v7(34.19,27.79)
  IN1 w0.508: v7(34.19,27.79) 34.19,28.97 34.79,29.56 34.79,31.67 34.31,32.15 34.31,33.29 34.78,33.76 v1(34.78,36)
  IN3 w0.508: v7(34.19,27.79) 33.99,27.58 30.4,27.58 26.88,31.1 v7(26.88,33.06)
VCC3V3_PD_LDO: length 17.3
  TOP w0.254: 45.88,132.51 PR138.1
  TOP w0.305: PR133.1 47.52,140.38 PR156.2 47.52,139.14 PR115.1
  TOP w0.381: PC120.1 45.97,134.77 PU100.8
  TOP w0.508: v11(45.17,136.2) 45.24,136.2 46.16,135.29 PC120.1 47.39,135.29 PR126.1 47.4,134.53 PD103.1 PD104.1 46.64,132.51 45.88,132.51 ; PR133.1 v11(47.68,141.23)
  IN3 w0.508: v11(47.68,141.23) 45.88,141.23 45.17,140.52 v11(45.17,136.2)
VCC3V3_SX_SYS_A: length 27.9
  TOP w0.203: U717.B1 8.9,54.23 v7(8.76,54.38)
  IN2 w0.457: v7(8.66,50.96) 8.86,50.96 9.2,51.31 9.2,52.57 8.76,53.01 v7(8.76,54.38)
  IN3 w0.305: v6(19.05,48.32) 19.22,48.49 19.22,49.37 19.66,49.81 v6(19.66,50.77)
  BOTTOM w0.305: v6(19.66,50.77) 19.66,52.04 19.05,52.65 19.05,53.63 R5698.2 19.43,53.77 19.76,53.44 R5699.2
  BOTTOM w0.508: v6(19.05,48.32) 18.55,48.32 17.49,47.26 14.03,47.26 13.3,47.99 8.2,47.99 7.73,48.46 R5700.2 8.62,50.92 v7(8.66,50.96)
VCC3V3_SX_SYS_B: length 14.3
  TOP w0.254: U719.B1 22.12,53.98 21.63,54.47 21.63,54.94 v11(21.55,55.02)
  IN2 w0.508: v7(20.35,48.01) 20.66,48.32 20.66,51.05 21.19,51.58 21.19,52.39 21.44,52.64 21.44,54.92 v11(21.55,55.02)
  BOTTOM w0.305: R5731.2 19.88,55.02 v11(21.55,55.02) 21.77,54.8 R5701.2 R5730.2
VCC3V3_TBTA_LDO: length 141.8
  TOP w0.508: v10(9.75,58.66) 8.71,58.66 v1(8.69,58.67) ; v10(17.12,41.09) 17.13,41.08 17.32,41.08 17.72,40.67 U718.8 ; v2(47.71,133.56) 48.16,134.02 PD103.2
  IN1 w0.457: v7(8.66,51.71) 7.94,51.71 7.28,51.05 7.28,50 v1(6.71,49.44)
  IN1 w0.508: v3(20.81,59.28) 25.89,59.28 v3(25.94,59.33) ; v1(8.69,58.67) 8.16,59.2 6.6,59.2 v1(6.06,58.67) ; v5(38.13,109.94) 38.91,109.94 41.57,112.61 42.8,112.61 43.21,113.01 43.21,115.39 42.64,115.96 42.64,126.16 43.9,127.41 43.9,127.67 45.32,129.09 45.32,130.36 46.36,131.41 v8(46.36,131.58) ; v3(15.26,47.68) 15.03,47.68 14.69,47.34 14.69,46.45 16.57,44.57 16.57,41.56 17.04,41.09 v10(17.12,41.09)
  GND1 w0.254: v10(17.12,41.09) 17.02,41.09 v4(16.73,41.38)
  GND1 w0.508: v8(46.36,131.58) 46.36,132.04 v4(46.31,132.09) ; v4(9.85,58) 9.75,58.1 v10(9.75,58.66) ; v4(37.67,109.94) v5(38.13,109.94)
  IN2 w0.508: v4(24.45,65.62) 24.64,65.43 24.64,63.37 25.89,62.12 25.89,59.38 v3(25.94,59.33) ; v2(20.77,58.5) 20.81,58.54 v3(20.81,59.28) 19.89,60.19 10.7,60.19 9.85,59.34 v4(9.85,58) ; v4(14.8,48.13) 14.97,48.13 15.26,47.84 v3(15.26,47.68) ; v2(47.71,133.56) v4(47.71,133.08)
  IN3 w0.508: v4(46.31,132.09) 46.72,132.09 v4(47.71,133.08) ; v4(24.45,65.62) 28.6,65.62 31.67,68.69 31.67,82.36 34.72,85.4 34.72,86.49 39,90.77 v6(39,94.67)
  GND4 w0.254: v9(17.07,41.68) 17.03,41.68 v4(16.73,41.38)
  GND4 w0.508: v4(9.85,58) v9(9.85,58.59) ; v4(14.8,48.13) 14.63,47.95 v9(14.22,47.95) ; v9(37.67,109.39) v4(37.67,109.94)
  BOTTOM w0.254: C1342.1 v9(17.07,41.68) ; R214.1 R213.1 R210.1 21.14,47.91 20.18,48.87 18.42,48.87 17.35,47.8 14.37,47.8 v9(14.22,47.95) 13.7,48.47
  BOTTOM w0.508: v9(37.67,109.39) 37.67,108.06 37.89,107.85 37.89,101.83 39.12,100.59 v14(39.12,98.38) 39.12,97.75 39,97.62 v6(39,94.67)
  vias: v7(8.66,52.27)
VCC3V3_TBTA_SX: length 1.2
  GND1 w0.119: v10(9.92,51.23) 10.02,51.23 v4(10.28,51.49)
  GND4 w0.119: v4(10.28,51.49) 10.28,51.6 10.05,51.82 v9(10.05,52.12)
VCC3V3_TBTB_LDO: length 155.9
  TOP w0.508: R1454.1 v10(23.86,57.77) ; v11(47.63,131.68) 47.63,132.3 48.08,132.75 PD104.2
  GND1 w0.508: v4(23.26,57.74) 23.83,57.74 v10(23.86,57.77) ; v10(20.97,47.07) 20.97,47.22 v4(21.38,47.63) ; v4(7.53,57.23) 6.99,57.78 v10(6.92,57.78) ; v10(19.93,58.63) v4(19.93,59.05)
  IN2 w0.508: v11(41.92,137.04) 42.25,136.71 42.25,131.15 41.45,130.35 41.45,127.86 41.7,127.61 41.7,126.34 41.18,125.81 41.18,125.01 41.7,124.48 41.7,121.2 41.09,120.59 41.09,112.28 v4(41.5,111.87) ; v7(22.14,51.67) 21.29,50.82 21.29,47.72 v4(21.38,47.63)
  IN3 w0.508: v4(41.5,111.87) 41.46,111.87 40.96,111.37 40.96,110.71 39.48,109.23 v4(38.82,109.23) ; 27.34,52.99 30.71,52.99 32.32,54.61 32.32,65.48 30.83,66.98 ; v6(39.62,94.68) 39.62,90.53 35.33,86.24 35.33,85.15 32.28,82.11 32.28,68.44 30.83,66.98 ; 30.83,66.98 28.85,65.01 23.49,65.01 23.03,65.46 23.03,67.64 22.08,68.59 20.92,68.59 20.39,68.05 18.6,68.05 18.14,67.6 15.75,67.6 10.89,62.73 6.6,62.73 5.58,61.72 5.58,59.19 v4(7.53,57.23)
  GND4 w0.381: v4(38.82,109.23) 38.82,109.23 v9(38.41,108.83)
  BOTTOM w0.305: R5701.1 21.77,52.19 v7(21.8,52.15)
  BOTTOM w0.381: R5760.2 25.22,52.86 R5701.1
  BOTTOM w0.508: v11(47.63,131.68) 47.69,131.68 47.57,131.55 45.93,131.55 42.25,135.24 42.25,136.71 v11(41.92,137.04) ; v9(38.41,108.83) 38.41,108.19 38.5,108.1 38.5,102.08 39.76,100.82 39.76,97.52 39.62,97.38 v6(39.62,94.68)
VCC3V3_TBTB_SX: length 1.3
  GND1 w0.119: v10(23.25,50.98) 23.23,50.95 23.23,50.94 23.06,50.77 v4(23.06,50.21)
  GND4 w0.119: v9(23.34,50.53) 23.34,50.49 v4(23.06,50.21)
VCC5V0_SYS: length 1.6
  TOP w0.254: v7(26.84,50.77) 27.05,50.98 U719.H10 ; v7(13.51,51.02) 13.71,51.23 U717.H10
  BOTTOM w0.102: v7(28.34,55.01) v14(28.91,55.01)
  vias: v7(14.9,55.49) v7(15.32,55.11) v7(28.35,55.58)
VCCGT_SENSE: length 64.4
  GND1 w0.254: v10(72.56,114.79) v4(72.56,115.3)
  IN2 w0.152: v2(119.99,100.55) 119.53,100.55 119.09,101 117.01,101 v4(116.86,100.85) 115.55,100.85 115.21,100.51 111.48,100.51 111.02,100.96 109.95,100.96 109.9,100.92 109.9,100.89 109.88,100.87
  IN2 w0.254: v4(94.32,112.81) 94.82,112.81 96.75,110.88 96.75,107.68 98.8,105.63 98.8,100.86 99.69,99.97 100.13,99.97 100.93,99.17 104.08,99.17 104.36,98.89 105.78,98.89 106.34,99.45 106.34,100.43 106.78,100.87 109.88,100.87
  IN3 w0.254: v4(72.56,115.3) 72.56,114.66 73.6,113.62 75.96,113.62 76.85,114.51 83.09,114.51 84.21,113.39 86.67,113.39 87.79,112.28 93.63,112.28 94.16,112.81 v4(94.32,112.81)
  GND4 w0.152: v4(116.86,100.85) 116.61,100.59 v9(116.57,100.59)
  BOTTOM w0.102: RC139.2 116.63,100.94 v13(117.07,101.38)
VCCGT_SENSE_1: length 5.5
  TOP w0.254: v1(72.56,113.88) 72.82,113.62 PU800.D1 ; v1(73.45,115.91) PR908.1
  IN1 w0.254: v1(72.56,113.88) 72.56,114.27 72.17,114.67 72.17,115.02 73.05,115.91 v1(73.45,115.91)
VCCIO_SENSE: length 46.6
  GND1 w0.06: v4(129.27,108.1) 129.27,108.14 129.13,108.27 v10(128.98,108.27)
  IN2 w0.06: 133.04,112.68 132.96,112.6 132.53,112.6 130.79,110.85 130.79,109.25 130.2,108.66 129.75,108.66 129.29,108.21 129.29,108.13 v4(129.27,108.1)
  IN2 w0.102: 133.04,112.68 133.81,113.44 134.02,113.44 135.76,115.18 135.76,115.79 137.14,117.18 137.14,118.91 137.86,119.63 137.86,120.59 137.73,120.73 137.73,122.92 138.14,123.34 138.14,124.04 138.78,124.67 139.33,124.67 139.71,125.06 146.28,125.06 146.67,124.67 147.89,124.67 148.22,124.35 148.22,124.34 148.66,123.9 148.94,123.9 149.29,123.55 149.54,123.55 150.6,122.49 150.6,122.24 152.18,120.66 158.8,120.66 159.32,121.17 159.32,122 v2(159.11,122.21)
  GND4 w0.06: v4(129.27,108.1) 129.27,108.31 v9(129.05,108.52)
  BOTTOM w0.119: RC97.2 129.05,108.16 v9(129.05,108.52)
VCCPRIM_VID0: length 132
  IN1 w0.06: 232.57,120.94 232.57,121.31 232.38,121.5 232.06,121.5 v1(231.81,121.75) ; 139.81,112.55 139.73,112.55 139.61,112.43 139.32,112.14 138.78,112.14 138.72,112.07 138.21,112.07 v3(138.06,111.92)
  IN1 w0.089: 232.57,120.94 232.57,119.83 233.81,118.59 v3(233.81,117.51) ; 139.81,112.55 140.43,112.55 140.77,112.89 143.36,112.89 143.97,112.28 143.99,112.28 144.5,111.77 145.53,111.77 145.94,111.36 146.6,111.36 149.25,108.71 149.25,108.09 149.56,107.77 149.56,105.26 151.2,103.62 151.37,103.62 153.98,101.01 154.7,101.01 154.94,100.77 156.89,100.77 157.13,101.01 158.73,101.01 159.09,100.65 163.91,100.65 164.11,100.85 167.22,100.85 167.51,101.13 179.37,101.13 179.81,100.69 180.83,100.69 181.36,100.15 185.23,100.15 185.44,100.36 185.44,100.51 185.93,101 188.33,101 188.56,101.23 189.61,101.23 190.59,102.21 191.31,102.21 191.94,102.83 191.94,103.09 192.4,103.55 192.4,104.29 192.92,104.82 192.92,105.71 193.85,106.64 193.85,108.01 198.63,112.8 200.28,112.8 203.9,116.42 203.9,116.79 204.68,117.57 206.16,117.57 207.86,119.27 208.31,119.27 209.57,120.52 211.06,120.52 211.85,121.31 212.72,121.31 213.67,122.26 215.71,122.26 216.32,122.86 217.36,122.86 218.99,124.49 220.37,124.49 221.77,123.09 221.77,122.94 224.86,119.85 225.27,119.85 v3(225.34,119.77)
  IN2 w0.06: v3(138.06,111.92) 137.52,111.39 137.14,111.39 136.56,110.8 136.23,110.8 135.66,110.24 135.05,110.24 134.59,109.79 133.72,109.79 133.47,109.54 133.43,109.54 133.32,109.42 133.26,109.42 132.9,109.42 132.78,109.3 v2(132.44,109.3)
  IN2 w0.084: v3(233.81,117.51) 233.56,117.26 232.88,117.26 232.6,117.53 232.6,117.89 232.33,118.15 230.45,118.15 230.06,117.77 227.7,117.77 226.29,119.17 225.61,119.17 225.34,119.44 v3(225.34,119.77)
VCCPRIM_VID1: length 161.2
  IN1 w0.06: 139.73,112.36 139.39,112.02 138.83,112.02 138.77,111.95 138.51,111.95 138.25,111.69 137.95,111.69 137.55,112.1 136.79,112.1 v3(136.4,111.72)
  IN1 w0.081: 218.84,124.07 218.98,124.21
  IN1 w0.089: 139.73,112.36 140.51,112.36 140.84,112.7 143.28,112.7 143.87,112.1 143.9,112.1 144.42,111.58 144.86,111.58 145.26,111.17 146.52,111.17 148.98,108.71 148.98,108.09 149.37,107.69 149.37,105.18 151.12,103.43 151.29,103.43 153.91,100.82 154.62,100.82 155.27,100.17 156.37,100.17 156.5,100.3 158.64,100.3 158.81,100.46 163.99,100.46 164.17,100.64 167.29,100.64 167.58,100.94 179.29,100.94 179.73,100.5 180.75,100.5 181.28,99.96 185.31,99.96 185.67,100.32 186.79,100.32 187.26,100.8 188.4,100.8 188.64,101.04 189.69,101.04 190.67,102.02 191.39,102.02 192.13,102.76 192.13,103.01 192.59,103.47 192.59,104.22 193.11,104.74 193.11,105.63 194.06,106.58 194.25,106.58 195.14,107.47 195.14,108.89 198.84,112.58 200.38,112.58 203.86,116.06 204.92,116.06 207.94,119.08 208.39,119.08 209.65,120.33 211.14,120.33 211.92,121.12 212.81,121.12 213.7,122 215.73,122 216.12,122.4 217.17,122.4 218.84,124.07 ; v5(219.65,124.21) 218.98,124.21 218.98,124.21
  GND1 w0.119: v4(219.69,124.8) 219.68,124.79 219.68,124.24 v5(219.65,124.21)
  IN2 w0.06: v3(136.4,111.72) 136.18,111.49 135.49,111.49 134.88,110.88 133.9,110.88 133.08,110.07 133.08,110.01 132.75,109.67 v2(132.66,109.67)
  IN2 w0.084: v2(234.81,125.75) 234.81,127.32 233.09,129.04 233.09,130.21 231.56,131.74 231.56,132.13 231.21,132.48 230.4,132.48 229.89,132.98 229.89,135.27 228.72,136.44 228.72,141.06 227.54,142.24 224.93,142.24 223.88,143.29 222.18,143.29 222.05,143.16 220.99,143.16 220.43,143.72 v4(216.72,143.72)
  IN3 w0.084: v4(216.72,143.72) 216.72,143.19 216.09,142.56 216.09,138.39 216.55,137.93 216.55,132.72 219.69,129.57 v4(219.69,124.8)
VCCSA_SENSE: length 105.4
  GND1 w0.254: v4(127.13,100.08) 127.36,100.31 v2(127.4,100.31) ; v10(67.11,106.4) v4(66.39,106.4)
  GND3 w0.102: v4(98.29,104.07) 98.23,104.13 97.61,104.13 96.92,103.44 96.92,100.58 98.91,98.59 100.2,98.59 100.62,99 101.15,99 101.2,98.95 102.28,98.95 102.77,98.46 106.66,98.46 106.86,98.66 109.28,98.66 110.62,100.01 115.78,100.01 117,98.79 125.84,98.79 v4(127.13,100.08)
  IN3 w0.254: v4(66.39,106.4) 66.59,106.4 67.14,106.94 67.14,110.23 65.63,111.74 65.63,113.3 66.91,114.58 66.91,118.09 70.3,121.49 74.18,121.49 74.4,121.71 77.51,121.71 81.11,125.31 84.39,125.31 86.16,123.53 94.72,123.53 95.23,123.02 95.23,115.6 96.73,114.1 96.73,105.09 97.75,104.07 v4(98.29,104.07)
  GND4 w0.102: v9(127.13,99.46) v4(127.13,100.08)
VCCSA_SENSE_1: length 9.2
  TOP w0.254: PR1024.1 66.22,106.37 v2(66.22,105.51) 66.64,105.51 66.65,105.52 PC1005.1
  IN2 w0.203: v2(71.62,109.95) 71.37,109.95 71.05,109.63
  IN2 w0.254: v2(66.22,105.51) 66.84,106.12 66.84,106.37 68.81,108.34 69.76,108.34 71.05,109.63
VCCSENSE: length 66.7
  GND1 w0.254: v10(75.23,114.79) 75.23,114.91 v4(75.01,115.12) ; v10(125.78,100.06) 125.7,100.06 v4(125.5,99.86)
  GND3 w0.102: v4(125.5,99.86) 125.45,99.8 117.15,99.8 116.21,100.74 106.64,100.74 105.87,99.98 105.87,99.47 105.65,99.25 102.99,99.25 102.57,99.67 101.67,99.67 101.03,100.3 99.18,100.3 98.55,100.94 98.55,101.94 98.14,102.34 97.63,102.34 v4(97.56,102.42)
  IN3 w0.254: v4(97.56,102.42) 95.23,104.75 95.23,113.34 93.86,114.71 88.68,114.71 86.98,116.42 82.96,116.42 82.28,115.73 75.32,115.73 75.01,115.42 v4(75.01,115.12)
  GND4 w0.102: v9(125.62,99.22) 125.5,99.34 v4(125.5,99.86)
VCCSENSE_1: length 6.3
  TOP w0.254: PR821.1 PC809.1 76.08,115.51 75.75,115.18 75.75,114.38 75.24,113.88 v1(75.23,113.88)
  IN1 w0.254: v1(75.23,113.88) 75.23,113.59 74.3,112.66 73.48,112.66 73.22,112.39 v1(73.22,111.95)
VDDTAB3: length 6.5
  TOP w0.381: PR230.1 70.35,127.81 PC229.1 70.35,125.85 70.67,125.53 PU206.3
  TOP w0.508: PR222.1 PR221.2 68.83,128.23 69.03,128.02 PR230.1
VDDTAB4: length 7.9
  TOP w0.305: PU206.6 67.88,125.53 68.27,125.92 68.27,126.39 67.89,126.77 67.01,126.77 66.49,127.29 PC228.1 66.19,127.74 66.33,127.88
  TOP w0.508: PR256.2 66.24,129.33 PR220.2 67.37,129.21 PR221.1 66.67,128.23 66.33,127.88
VIN9: length 8.8
  TOP w0.254: PC601.1 169.14,130.03 169.14,129.17 168.97,128.99 168.97,127.63 169.19,127.41 169.19,126.65 169.19,126.65 PU500.A10 PU500.B10
  TOP w0.508: PC600.1 171.43,130.59 PC645.1 170.75,130.54 PC601.1 169.65,131.84 PL600.2
VIN12: length 1.9
  TOP w0.254: 168,119.82 168.39,120.21 PU500.P8 PU500.N8
VINTAB:
  vias: v4(114.26,87.08) v4(114.89,87.08) v4(115.8,87.35) v7(72.65,141.97) v7(72.88,141.36) v7(72.88,140.75) v7(73.35,140.38) v7(73.37,141.65) v7(73.37,141.04) v7(92.18,82.75) v7(92.74,82.75) v7(93.3,82.75) v7(93.68,85.56) v7(93.86,82.75) v7(94.24,85.56) v7(94.8,85.56) v7(95.36,85.56) v7(114.34,82.14) v7(114.92,82.14) v7(115.49,82.14) v10(114.05,87.42) v10(114.53,87.36) v10(114.78,87.55) v10(115.27,86.95) v10(115.42,87.47) v10(115.83,86.9) v14(94.14,124.06)
VSSGT_SENSE: length 63.4
  GND1 w0.254: v10(73.45,114.79) v4(73.45,115.34)
  IN2 w0.152: v2(119.68,100.83) 119.55,100.83 119.17,101.21 116.53,101.21 v4(116.49,101.25) 116.3,101.06 115.46,101.06 115.12,100.72 111.56,100.72 111.11,101.18 110.21,101.18 110.09,101.29
  IN2 w0.254: 110.09,101.29 110,101.38 106.57,101.38 105.84,100.64 105.84,99.66 105.57,99.4 104.57,99.4 104.29,99.68 101.14,99.68 100.34,100.48 99.9,100.48 99.31,101.07 99.31,105.84 97.26,107.89 97.26,111.09 95.04,113.32 v4(94.32,113.32)
  IN3 w0.254: v4(73.45,115.34) 73.45,114.7 74.02,114.13 75.75,114.13 76.64,115.02 83.3,115.02 84.42,113.9 86.88,113.9 88,112.78 93.42,112.78 93.95,113.32 v4(94.32,113.32)
  GND4 w0.152: v9(116.28,100.9) 116.49,101.12 v4(116.49,101.25)
  BOTTOM w0.102: RC141.2 v13(115.84,101.75)
  BOTTOM w0.254: RC141.2 116.25,100.87 v9(116.28,100.9)
VSSGT_SENSE_1: length 1.6
  TOP w0.254: PR914.1 73.22,113.65 PU800.C1
VSSIO_SENSE: length 49.7
  IN2 w0.06: 133.2,112.56 133.12,112.47 132.61,112.47 130.91,110.78 130.91,108.72 v4(130.56,108.38) 130.54,108.35 130.38,108.35 130.19,108.54 129.8,108.54 129.65,108.39 129.65,107.98 129.47,107.81 129.37,107.81 129.24,107.68 129.01,107.68 v2(128.98,107.71)
  IN2 w0.102: 133.2,112.56 133.84,113.19 134.07,113.19 135.99,115.11 135.99,115.74 137.35,117.1 137.35,118.83 138.07,119.55 138.07,120.68 137.93,120.82 137.93,122.84 138.35,123.25 138.35,123.95 138.86,124.47 139.41,124.47 139.8,124.85 146.2,124.85 146.58,124.47 147.81,124.47 148.01,124.26 148.01,124.26 148.58,123.7 148.85,123.7 149.2,123.35 149.45,123.35 150.38,122.42 150.38,122.17 152.1,120.45 158.88,120.45 159.52,121.09 159.52,122.51 159.95,122.94 160.92,122.94 v2(161.19,123.22)
  GND4 w0.06: v9(130.64,108.73) 130.56,108.65 v4(130.56,108.38)
  BOTTOM w0.06: RC98.1 130.5,108.59 v9(130.64,108.73)
VSSSA_SENSE: length 106.4
  GND1 w0.254: v2(127.72,100.55) 127.72,100.55 v4(127.72,100.03) ; v10(67.1,107.31) 67.08,107.29 v4(66.57,107.29)
  GND3 w0.102: v4(98.27,104.61) 98.15,104.49 97.47,104.49 96.56,103.58 96.56,100.43 98.89,98.1 106.81,98.1 107.01,98.31 109.42,98.31 110.77,99.65 115.63,99.65 116.85,98.43 125.99,98.43 127.59,100.03 v4(127.72,100.03)
  IN3 w0.254: v4(98.27,104.61) 97.93,104.61 97.24,105.3 97.24,114.32 95.74,115.81 95.74,123.23 94.93,124.04 86.37,124.04 84.6,125.81 80.9,125.81 77.33,122.25 74.16,122.25 73.91,122 70.09,122 66.4,118.3 66.4,114.79 65.12,113.51 65.12,111.53 66.63,110.02 66.63,107.35 v4(66.57,107.29)
  GND4 w0.102: v4(127.72,100.03) 127.72,99.49 v9(127.69,99.46)
VSSSA_SENSE_1: length 7
  IN1 w0.089: v1(71.22,109.95) 71.22,109.97 71,110.19 70.45,110.19 70.12,109.86 69.8,109.86 69.78,109.84
  IN1 w0.254: 69.78,109.84 69.63,109.69 68.04,109.69 67.62,109.27 67.62,109.08 67.27,108.72 66.72,108.72 66.5,108.5 66.5,108.19 66.2,107.88 v1(66.2,107.29)
VSSSENSE: length 71.5
  GND1 w0.254: v2(126.43,100.06) 126.43,100.07 126.68,100.31 v4(126.7,100.31) ; v10(74.34,114.79) 74.34,115.04 v4(74.47,115.17)
  GND3 w0.102: v4(126.7,100.31) 126.47,100.31 125.61,99.45 117,99.45 116.06,100.39 106.79,100.39 106.23,99.83 106.23,99.32 105.8,98.89 102.84,98.89 102.42,99.31 101.52,99.31 100.89,99.94 99.03,99.94 98.19,100.79 98.19,101.79 97.99,101.99 97.63,101.99 v4(97.56,101.91)
  IN3 w0.254: v4(97.56,101.91) 97.78,101.91 98.09,102.22 98.09,102.61 95.74,104.96 95.74,113.62 94.14,115.22 88.89,115.22 87.19,116.92 82.71,116.92 82.02,116.24 75.11,116.24 74.47,115.59 v4(74.47,115.17)
  GND4 w0.102: v4(126.7,100.31) 126.7,99.49 v9(126.35,99.13)
VSSSENSE_1: length 2.7
  IN1 w0.203: 72.82,112.45 v1(72.82,111.95)
  IN1 w0.254: v1(74.34,113.88) 74.34,113.64 73.83,113.13 73.73,113.03 73.4,113.03 72.82,112.45
+AMP_AVDD1: length 10.9
  TOP w0.119: LA19.1 211.82,122.84 v7(212.32,122.33)
  TOP w0.203: UA2.42 208.23,121.37 208.32,121.47 210.28,121.47 CA110.1 ; UA2.43 209.05,121.77 209.61,122.33 210.98,122.33
  TOP w0.381: CA109.1 211.41,121.36 CA110.1
  TOP w0.508: CA109.1 LA19.1 211.49,122.84 210.98,122.33
+BATT: length 1.2
  BOTTOM w0.119: v7(82,88.81) v13(82,89.44) ; v7(79.69,88.78) v13(79.69,89.31)
  vias: v7(80.24,88.78) v7(80.83,88.78) v7(81.44,88.81) v7(83.83,88.81) v7(84.39,88.81) v7(84.97,88.81) v7(150.45,88.81) v7(151,89.36) v7(151.1,88.81) v7(151.56,89.37) v7(151.68,88.82) v7(152.12,89.37) v7(152.24,88.82) v7(152.69,89.19)
+EDP_COM: length 2.5
  TOP w0.254: 121.08,96.95 121.06,96.95 120.63,97.55 UC1.A50
  TOP w0.508: RC4.1 121.77,95.63 121.37,96.4 121.08,96.95
+INV_PWR_SRC:
  vias: v7(183.66,102.66) v7(183.93,97.04) v7(183.93,96.45) v7(184.25,102.67) v14(183.98,99.86)
+IO_OUT: length 5.8
  TOP w0.254: U16.E7 193.13,142.9 192.74,143.29 192.74,143.52 192.38,143.87 192.02,143.87 C108.1 191.05,144.84 v7(190.82,144.84) 190.41,145.24 RH78.1 RH79.1
  BOTTOM w0.127: v7(190.82,144.84) 190.85,144.84 v14(191.55,145.54)
+LCDVDD: length 4.5
  TOP w0.381: v1(181.87,96.95) RC240.2
  IN1 w0.33: v7(178.19,97.19) 178.38,97 180.71,97 180.94,97.23 181.59,97.23 v1(181.87,96.95)
  vias: v7(174.91,98.99) v7(175.52,98.99) v7(177.58,97.19) v14(173.97,101.89)
+ODR_PWR: length 9.5
  IN1 w1.016: 28.09,83.55 28.09,83.7 27.58,84.21 25.86,84.21 25.42,84.65 23.46,84.65 23.02,85.1
  IN3 w0.762: 20.26,84.68 20.19,84.62
  IN3 w1.016: 16.71,85.01 16.72,85 19.81,85 20.19,84.62
  vias: v1(22.18,85.59) v1(22.19,85.19) v1(22.21,84.7) v1(27.76,82.84) v1(27.98,82.63) v1(27.97,82.3) v7(15.68,85.83) v7(16.24,85.76) v7(21.19,84.97) v7(21.22,84.39)
+PBATT: length 84.9
  TOP w0.508: v7(52.48,123.86) 52.48,123.21 PR422.2
  IN1 w0.508: v7(52.48,123.86) 50.02,123.86 49.66,124.21 49.66,131.05 48.99,131.72 48.99,134.05 48.7,134.35 48.7,134.92 49.4,135.62 49.4,136.06 51.92,138.59 55.78,138.59 v1(56.98,137.4)
  BOTTOM w0.508: v7(78.7,85.77) v14(76.95,87.52) 75.74,88.73 64.9,88.73 57.59,96.05 51.9,96.05 51.3,96.64 51.3,113.33 52.48,114.51 v7(52.48,123.86)
+PD_VBUS_A: length 34.3
  TOP w0.508: v10(33.18,63.9) 34.14,63.9 34.68,63.37 PD106.2
  GND1 w0.508: v10(33.18,63.9) 32.68,64.4 v4(31.71,64.4)
  IN3 w0.508: v4(31.71,64.4) 31.41,64.7 30.4,64.7 29.46,63.76 29.46,56.85 29.14,56.54 v6(29.14,54.43)
  BOTTOM w0.508: v7(12.64,55.34) 13.52,54.47 15.79,54.47 16.86,55.53 21.18,55.53 21.66,56.02 23.39,56.02 23.75,55.65 27.29,55.65 27.74,55.21 27.74,54.78 28.09,54.43 v6(29.14,54.43)
+PD_VBUS_B: length 8.3
  TOP w0.508: PD105.2 33.45,62.92 32.87,62.35 28.15,62.35 27.96,62.16 25.66,62.16
  vias: v2(24.77,62.14) v2(25.14,62.14) v2(25.71,55.37) v2(26.03,55.38)
+PWR_SRC_AC:
  vias: v7(54.55,114.5) v7(54.55,115.57) v7(55.19,114.53) v7(55.78,114.52) v7(56.45,117.79) v7(56.37,114.48) v7(67.28,134.13) v7(67.25,133.57) v7(67.57,134.64) v7(67.84,133.56) v7(67.9,135.15) v7(67.88,134.16)
+RTCBATT: length 99.7
  TOP w0.508: v10(229.56,143.18) 229.76,142.97 R716.2 229.77,142.53 C1425.1 230.63,142.2 230.87,141.96 239.68,141.96 240.39,142.66 240.39,145.14 239.82,145.72 JRTC1.1
  GND1 w0.508: v4(228.44,143.1) 229.48,143.1 v10(229.56,143.18)
  IN2 w0.381: v2(169.59,122) 169.93,121.66 170.06,121.66 171.22,120.51 v4(172.14,120.51)
  GND4 w0.508: v9(172.51,121.18) 172.51,120.87 v4(172.14,120.51) ; v4(228.44,143.1) v9(228.44,141.98)
  BOTTOM w0.508: v9(228.44,141.98) 226.76,141.98 226.14,142.6 226.14,145.41 225.25,146.3 207.77,146.3 206.78,145.32 202.79,145.32 202.09,144.61 202.09,143.18 202.24,143.02 202.24,140.56 202.58,140.22 202.58,137.61 201.24,136.27 v14(199.87,136.27) 197.67,136.27 193.53,132.13 192.53,132.13 191.32,130.92 191.32,129.24 189.51,127.44 187.72,127.44 186.98,126.69 186.98,124.67 184.54,122.23 183.22,120.91 178.43,120.91 178.16,121.18 v9(172.51,121.18)
+RTCVCC: length 469.4
  TOP w0.254: v1(143.62,117.98) 142.79,117.98 CLRP4.1 ; v1(130.47,107.71) UC1.AT19
  TOP w0.381: PR742.1 157.55,129.64 157.98,129.21 160.83,129.21 161.17,128.86 v10(161.17,128.71) ; RH42.1 141.5,116.2 RH64.1 142.45,117.15 142.45,117.63 CLRP4.1
  TOP w0.508: v7(165.31,99.76) 164.7,99.76 164.52,99.93 164.52,101.76 165.49,102.73 165.49,104.75 165.69,104.95 165.69,105.85 165.31,106.23 165.31,107.17 v7(166.45,108.31) ; PR719.2 v1(175.18,116.9) ; v2(228.04,146.7) 228.04,145.05 227.64,144.65 R5758.1 227.64,143.18 C715.1 ; R156.1 237.9,130.18 v7(237.9,130.82)
  IN1 w0.254: v5(173.21,122.61) 173.12,122.7 172.4,122.7 172.12,122.42 172.12,121.56 172.49,121.19 172.49,120.97 173.43,120.02 173.43,119.9 175.16,118.17 175.16,116.92 v1(175.18,116.9) ; v1(130.47,107.71) v5(130.47,107.96)
  IN1 w0.508: v5(147.83,118.22) 147.76,118.3 147.21,118.3 147,118.51 144.15,118.51 v1(143.62,117.98)
  GND1 w0.203: v5(130.47,107.96) v4(130.47,107.51)
  GND1 w0.381: v4(160.61,128.33) 160.99,128.71 v10(161.17,128.71)
  GND1 w0.508: v4(16.88,16.48) 16.87,16.47 v10(16.87,15.95) ; v5(147.83,118.22) v4(148.27,118.22) ; v4(173.89,122.82) 173.72,122.82 173.51,122.61 v5(173.21,122.61)
  IN2 w0.508: v2(228.04,146.7) v4(229.2,146.7)
  GND2 w0.254: v4(135.9,111.97) 135.16,111.97 132.82,109.63 132.82,108.75 132.19,108.11 131.86,108.11 131.26,107.51 v4(130.47,107.51)
  IN3 w0.381: v6(161.32,114.54) 161.27,114.54 160.49,115.32 160.49,119.82 159.95,120.35 159.95,126.14 159.26,126.83 159.26,128.61 159.54,128.89 160.05,128.89 v4(160.61,128.33)
  IN3 w0.508: v6(108.73,79.75) 108.85,79.87 134.3,79.87 137.12,82.69 140.61,82.69 v6(141.9,83.98) ; v6(161.32,114.54) 161.32,114.18 161.25,114.11 161.25,110.15 v6(161.22,110.12) ; v6(46.21,80.29) 45.46,80.29 45.24,80.51 45.21,80.51 43.5,82.22 39.33,82.22 37.27,80.16 37.27,48.04 v6(36.46,47.23) ; v6(227.67,147.94) 227.96,147.94 v4(229.2,146.7) 229.84,146.06 229.84,144.55 231.06,143.33 233.39,143.33 234.37,142.35 234.37,140.91 234.93,140.36 237.29,140.36 237.68,139.97 237.68,139.44 238.14,138.97 238.33,138.97 239.92,137.38 239.92,135.3 237.83,133.21 v6(237.83,132.94)
  GND4 w0.254: v4(135.9,111.97) 136.02,112.1 v9(136.28,112.1)
  GND4 w0.508: v4(148.27,118.22) v9(148.7,118.22) ; v4(173.89,122.82) v9(173.89,122.25) ; v4(16.88,16.48) v9(16.88,16.9)
  BOTTOM w0.254: CC33.1 136.26,112.1 v9(136.28,112.1) 136.38,112.2 137.37,112.2 137.95,111.62 140.24,111.62 140.39,111.77 142.3,111.77 145.67,115.15 150.83,115.15 154.24,111.74 159.8,111.74 161.22,110.32 v6(161.22,110.12)
  BOTTOM w0.508: v6(161.32,114.54) 161.37,114.59 161.37,116.29 160.94,116.72 160.94,119.46 161.75,120.28 ; v6(227.67,147.94) 227.65,147.95 225.61,147.95 224.91,147.25 221.82,147.25 221.52,146.95 207.55,146.95 206.53,145.92 202.36,145.92 201.85,145.42 199.41,142.98 199.41,140.86 197.97,139.42 197.97,137.44 193.28,132.74 192.28,132.74 190.68,131.15 190.68,129.47 189.26,128.05 187.47,128.05 186.37,126.94 186.37,125.03 183.98,122.64 183.22,122.64 182.1,121.52 178.68,121.52 177.96,122.25 v14(175.83,122.25) v9(173.89,122.25) 173.89,123.05 171.25,125.69 166.63,125.69 163.51,122.56 163.51,122.03 161.75,120.28 ; v7(165.31,99.76) 165.31,100.05 165.75,100.49 166.5,100.49 166.86,100.13 166.86,88.02 165.22,86.38 164.64,86.38 163.23,87.79 156.64,87.79 154.3,90.12 150.1,90.12 145.3,85.32 143.24,85.32 v6(141.9,83.98) ; v9(16.88,16.9) 18.78,16.9 22.13,20.25 24.56,20.25 28.21,23.91 28.21,25.97 32.81,30.56 33.94,30.56 36.65,33.27 36.65,47.04 v6(36.46,47.23) ; 161.75,120.28 161.75,120.96 161.04,121.67 159.92,121.67 157.83,119.59 152.89,119.59 151.52,118.22 v9(148.7,118.22) ; v7(237.9,130.82) 237.9,132.86 v6(237.83,132.94) ; v6(108.73,79.75) 103.77,79.75 103.23,80.28 v6(46.21,80.28) ; v6(161.22,110.12) 162.49,108.85 164.78,108.85 165.31,108.31 v7(166.45,108.31)
+RTCVCC_EC: length 27.5
  TOP w0.305: R156.2 236.89,130.23 237.26,130.6 R1061.1 237.26,131.43 R1081.1
  TOP w0.381: R1081.1 237.2,131.71 237.66,132.16 R182.1
  TOP w0.508: R5588.2 226.69,132.42 226.46,132.19 v7(226.46,131.8) ; R156.2 236.79,129.98 v2(236.79,128.56)
  IN1 w0.254: v10(235.31,126.25) 235.31,126.93 235.51,127.13
  IN1 w0.508: v2(236.79,128.56) 235.51,127.28 235.51,127.13
  GND1 w0.254: v4(235.21,126.65) 235.31,126.55 v10(235.31,126.25)
  IN2 w0.508: v4(237.66,130.27) 237.66,129.46 236.79,128.58 v2(236.79,128.56)
  IN3 w0.508: v6(237.37,129.84) 237.66,130.13 v4(237.66,130.27)
  GND4 w0.254: v9(235.77,126.32) 235.44,126.65 v4(235.21,126.65)
  BOTTOM w0.254: C188.1 235.34,126.32 v9(235.77,126.32)
  BOTTOM w0.508: v7(226.46,131.8) 226.46,132.49 228.31,134.34 230.37,134.34 231.09,135.06 231.81,135.06 232.68,134.18 232.68,134.11 234.75,132.04 234.75,131.86 236.77,129.84 v6(237.37,129.84)
+SD_VDD2: length 14.2
  IN1 w1.016: 22.94,81.31 25.11,81.31 25.98,82.18 26.51,82.18
  IN3 w1.016: 20.22,81.24 16.81,81.24 15.37,82.68 11,82.68 10.65,82.33
  vias: v1(22.07,82.18) v1(22.09,81.71) v1(22.08,81.21) v1(27.1,82.8) v1(27.29,82.56) v1(27.49,82.3) v7(4.55,83.35) v7(5.06,82.84) v7(8.62,82.2) v7(9.38,82.2) v7(21.32,82.08) v7(21.32,81.49)
+SIM_PWR: length 70.3
  TOP w0.508: D6.5 24.72,69.67 C81.1 v1(24.7,68.75) ; v7(18.98,66.86) 18.98,65.98 18.22,65.22 5.63,65.22 5.41,65.45 JSIM1.1
  IN1 w0.508: v7(18.98,66.86) 19.28,66.86 20.97,68.55 22.76,68.55 23.23,68.08 24.02,68.08 v1(24.7,68.75)
  IN2 w0.508: v7(18.98,66.86) 18.54,67.31 18.54,85.68 20.69,87.84 20.69,96.27 v4(20.06,96.9)
  IN3 w0.508: v6(19.78,97.51) 19.78,97.18 v4(20.06,96.9)
  BOTTOM w0.508: JNGFF1.28 24.05,104.05 26.84,101.25 26.84,100.71 26.12,99.98 24.11,99.98 21.63,97.51 v6(19.78,97.51)
+V_DDR_0_DQ_VREF: length 46.2
  TOP w0.508: R8.1 106.75,125.33 C6.1 106.15,125.48 105.7,125.94 103.68,125.94 102.1,124.37 100.06,124.37 v2(99.8,124.11)
  IN2 w0.203: v2(119.53,107.04) 119.53,107.03
  IN2 w0.254: 119.53,107.03 119.7,106.86 119.7,106.78 v4(119.72,106.76)
  IN2 w0.508: v4(97.49,115.6) 97.49,119.4 98.41,120.31 98.41,122.72 v2(99.8,124.11)
  IN3 w0.508: v6(105.59,110.55) 106.05,110.09 111.94,110.09 115.27,106.76 119.72,106.76 v4(119.72,106.76)
  GND4 w0.508: v4(97.49,115.6) 98.01,115.08 v9(99.23,115.08)
  BOTTOM w0.508: v6(105.59,110.55) 100.06,110.55 99.23,111.37 v9(99.23,115.08)
+V_DDR_1_DQ_VREF: length 24.4
  TOP w0.508: v1(119.92,128.38) 120.49,128.95 R15.1
  IN1 w0.508: v1(119.92,128.38) 120.01,128.29 v3(120.01,127.45)
  GND1 w0.254: v4(119.41,109.24) 119.41,109.17 119.64,108.94 v2(119.67,108.94)
  IN2 w0.254: v2(119.67,108.94) 119.41,109.19 v4(119.41,109.24)
  IN2 w0.508: v4(117.66,120.84) 118.34,121.52 118.34,125.7 120.01,127.36 v3(120.01,127.45)
  IN3 w0.508: v4(119.41,109.24) 119.41,109.37 115.8,112.98 115.8,119.26 117.38,120.84 v4(117.66,120.84)
+V_DDR_VREF_CA: length 16.9
  TOP w0.508: v7(106.61,111.26) 106.84,111.03 R9.1 106.84,109.74 C7.1
  IN2 w0.254: v4(119.75,107.41) 119.75,107.43 119.53,107.65 v2(119.53,107.69)
  IN3 w0.508: v4(119.75,107.41) 119.75,107.42 119.34,107.83 116.03,107.83 112.6,111.26 v7(106.61,111.26)
+V_VDDQ_VTT: length 15.9
  TOP w0.102: PU500.E3 PU500.D2
  TOP w0.254: PU500.D2 PU500.D1 165.45,125.2 165.16,125.49 165.16,126.04 163.94,127.26 v7(163.94,127.49)
  TOP w0.508: v2(160.76,134.21) 161.28,134.73 161.28,135.02 PC631.1 PC632.1
  IN2 w0.508: v2(160.76,134.21) 161.55,134.21 v4(161.58,134.18)
  IN3 w0.508: v4(161.58,134.18) 161.58,133.56 163,132.14 163,127.77 163.28,127.49 v7(163.94,127.49)
  BOTTOM w0.102: v14(164.22,128.02) 163.94,127.75 v7(163.94,127.49)
+VR_CAP: length 2
  TOP w0.254: U27.H1 232.09,126.97 232.09,127.78 C196.1
AC_DIS: length 271.8
  TOP w0.254: v2(40.72,124.49) 40.72,124.16 41.03,123.86 41.78,123.86 42.01,123.63 42.01,123.55 PR118.1 42.51,123.66 42.51,123.86 42.89,124.24 v1(43.12,124.24) ; PR131.1 42.89,121.36 v10(43.12,121.59)
  IN1 w0.089: v1(235.31,124.25) 235.5,124.44 236.53,124.44 236.92,124.83 236.92,125.76 236.76,125.93 236.76,127.11 238.33,128.68 238.33,129.18 238.83,129.68 238.83,129.99 238.55,130.27 237.8,130.27 237.41,130.67 237.41,132.77 236.79,133.4 235.28,133.4 234.85,133.83 234.85,135 233.81,136.04 233.01,136.04 232.32,136.72 231.46,136.72 230.13,138.05 229.9,138.05 229.51,138.44 224.26,138.44 223.82,138.87 223.13,138.87 222.94,138.67 220.95,138.67 220.7,138.93 216.14,138.93 215.73,138.52 214.38,138.52 213.92,138.98 210.55,138.98 209.93,138.36 208.75,138.36 208.58,138.2 207.83,138.2 207.16,137.53 207.16,135.75 206.52,135.12 206.52,135.03 205.86,134.36 204.13,134.36 202.32,132.56 195.97,132.56 195.79,132.38 193.36,132.38 193,132.01 192.08,132.01 189.53,129.46 188.31,129.46 186.56,127.71 186.56,126.09 184.75,124.27 183.43,124.27 182.84,123.68 182.84,123.03 182.38,122.57 179.16,122.57 179.04,122.69 179.04,125.32 179.02,125.34 179.02,127.86 178.27,128.61 176.01,128.61 175.9,128.5 173.77,128.5 173.22,129.04 172.57,129.04 170.69,130.92 167.83,130.92 167.18,130.27 165.63,130.27 165.12,130.78 163.29,130.78 162.69,131.38 162.53,131.38 162.19,131.73 161.33,131.73 v5(161.13,131.53)
  IN1 w0.254: v10(43.12,121.59) 43.53,121.99 43.53,124.05 43.34,124.24 v1(43.12,124.24)
  GND1 w0.119: v5(161.13,131.53) 161.26,131.53 v4(161.46,131.73)
  IN2 w0.084: v2(40.72,124.49) 40.72,124.64 40.6,124.76 40.6,126.06 41.12,126.58 41.12,127.35 40.59,127.88 40.59,139.23 48.69,147.33 57.92,147.33 58.52,147.93 66.91,147.93 69.15,145.68 72.57,145.68 76.31,141.94 76.31,140.56 79.88,136.99 91.15,136.99 91.58,136.56 92.62,136.56 92.79,136.38 99.82,136.38 v4(100.71,135.49)
  GND3 w0.119: v4(161.46,131.73) 160.58,131.73 159.52,130.67 155.98,130.67 154.34,132.3 150.08,132.3 148.94,131.15 148.94,130.15 145.61,126.83 142.32,126.83 142.17,126.98 141.69,126.98 141.39,126.68 140.96,126.68 140.74,126.9 139.15,126.9 138.37,127.69 134.42,127.69 133.72,126.99 128.28,126.99 122.82,132.45 122.82,133.24 122.19,133.87 120.33,133.87 119.97,133.51 110.72,133.51 110.24,133.99 107.05,133.99 106.91,133.85 101.89,133.85 100.71,135.02 v4(100.71,135.49)
AC_PRESENT: length 113.8
  TOP w0.119: v1(224.06,126.75) 224.06,123.4 224.95,122.51 226.56,122.51 226.76,122.31 228.49,122.31 228.56,122.37 228.56,122.63 229.18,123.25 U27.N8
  IN1 w0.089: v1(224.06,126.75) 223.98,126.84 218.9,126.84 218.74,126.99 217.78,126.99 217.55,127.22 215.14,127.22 214.73,126.81 211.09,126.81 209.9,125.62 209.9,124.8 209.25,124.14 207.39,124.14 206.72,123.47 205.82,123.47 205.7,123.35 205.7,122.84 205.34,122.49 204.91,122.49 204.68,122.26 204.68,121.84 204.31,121.47 203.87,121.47 203.66,121.27 203.66,120.78 203.34,120.45 202.46,120.45 201.84,119.84 200.32,119.84 199.78,120.38 198.71,120.38 196.73,118.4 196.73,116.19 191.13,110.59 191.13,109.19 190.22,108.28 190.22,106.86 188.7,105.34 188.23,105.34 186.73,103.84 182.82,103.84 182.46,103.48 179.67,103.48 179.42,103.23 172.55,103.23 172.14,103.64 167.9,103.64 167.72,103.82 165.28,103.82 165.13,103.67 164.25,103.67 163.82,104.1 162.68,104.1 162.25,103.67 158.02,103.67 156.63,105.06 154.11,105.06 153.3,105.88 153.3,108.95 151.72,110.52 149.86,110.52 148.93,111.46 v3(148.93,111.84)
  IN2 w0.084: v3(148.93,111.84) 148.72,111.84 v4(148.56,112.01)
  IN3 w0.076: v6(148.18,111.93) 148.48,111.93 v4(148.56,112.01)
  BOTTOM w0.089: T37.1 144.62,112.29 147.82,112.29 v6(148.18,111.93)
  BOTTOM w0.119: RH58.2 142.64,111.03 RH115.2 143.28,110.94 T37.1
AC_PRESENT_R: length 12.4
  IN2 w0.06: 136.23,112.89 136.05,112.71 135.54,112.71 134.34,111.51 133.68,111.51 133.03,110.86 132.79,110.86 132.26,110.33 132.26,110.2 v2(132.23,110.16)
  IN2 w0.084: 136.23,112.89 136.71,113.37 v4(136.71,113.39)
  IN3 w0.076: v6(137.14,111.84) 137.17,111.87 137.17,112.68 136.99,112.86 136.99,113.11 v4(136.71,113.39)
  BOTTOM w0.119: RH58.1 141.31,111.27 137.79,111.27 137.19,111.87 137.17,111.87 v6(137.14,111.84)
ACCEL_INT1#: length 164.2
  TOP w0.119: v2(232.37,106.68) 232.37,106.93 231.87,107.42 231.87,107.87 231.41,108.33 R399.1
  IN2 w0.06: v2(132.87,110.66) 133,110.66 133.73,111.39 134.4,111.39 135.59,112.58 136.18,112.58 136.6,113.01 136.82,113.01 136.94,113.13
  IN2 w0.084: v2(232.37,106.68) 232.69,106.68 234.55,108.54 237.34,108.54 v4(238.94,110.14) ; 136.94,113.13 137.27,113.46 137.57,113.46 139.61,115.5 140.42,115.5 141.28,116.37 141.28,116.53 142.11,117.36 142.11,118.01 145.91,121.81 146.73,121.81 146.89,121.65 149.38,121.65 151.61,119.42 160.67,119.42 161.63,120.39 162.87,120.39 163.22,120.03 164.44,120.03 165.85,118.62 166.67,118.62 167,118.29 174.92,118.29 176.3,119.67 176.3,120.17 177.33,121.21 184.63,121.21 186.22,122.8 189.61,122.8 193.61,126.8 193.61,128.63 194.27,129.29 194.8,129.29 195.99,130.48 200.89,130.48 204.43,134.02 204.43,135.06 207.19,137.81 215.44,137.81 216.45,138.82 219.55,138.82 v4(219.87,138.5)
  IN3 w0.084: v6(219.98,118.4) 223.09,121.51 223.09,124.08 223.47,124.46 223.47,133.46 224.05,134.03 224.05,136.25 223.67,136.63 222.53,136.63 220.98,138.18 220.19,138.18 v4(219.87,138.5) ; v4(238.94,110.14) v6(238.94,112.33)
  BOTTOM w0.119: v6(219.98,118.4) 221.55,116.83 222.94,116.83 223.72,117.61 226.11,117.61 226.88,116.83 230.83,116.83 234.12,113.55 235.76,113.55 236.13,113.19 238.08,113.19 v6(238.94,112.33)
ACCEL_INT1#_L: length 62.2
  TOP w0.119: U20.11 224.82,106.4 225.17,106.05 228.87,106.05 230.19,107.37 R395.1 R391.1 230.8,108.52 231.39,109.1 v2(231.41,109.1)
  IN2 w0.084: v2(231.41,109.1) 232.58,109.1 232.77,108.91 236.58,108.91 v4(237.78,110.1)
  IN3 w0.084: v6(223.65,136.27) 223.53,136.14 223.53,134.42 223.1,134 223.1,124.62 222.72,124.24 222.72,122.31 219.25,118.83 v6(219.25,117.83) ; v4(237.78,110.1) v6(237.78,112.33)
  BOTTOM w0.119: v6(219.25,117.83) 220.69,116.39 223.13,116.39 223.9,117.17 225.93,117.17 226.7,116.39 230.65,116.39 233.93,113.11 235.58,113.11 235.94,112.75 237.36,112.75 v6(237.78,112.33) ; v6(223.65,136.27) JSER.7
ACCEL_INT2#: length 137.2
  TOP w0.06: UC1.BD2 136.98,110.26 v1(137.23,110.02)
  TOP w0.119: v2(232.52,107.59) 231.77,108.34 231.77,109.42 231.36,109.83 R400.1
  IN1 w0.06: 140.87,110.35 140.47,110.35 140.21,110.09 138.11,110.09 138.08,110.07 137.28,110.07 v1(137.23,110.02)
  IN1 w0.089: v3(145.6,109.79) 145.37,110.01 145.02,110.01 144.39,110.64 143.61,110.64 143.48,110.76 142.19,110.76 142.06,110.63 141.58,110.63 141.3,110.35 140.87,110.35
  IN2 w0.084: v2(232.52,107.59) 233.34,107.59 234.47,108.73 236.94,108.73 v4(238.36,110.14) ; v4(221.68,120.61) 216.83,120.61 215.88,119.66 213.43,119.66 211.02,117.25 209.8,117.25 208.68,118.37 200.2,118.37 199.69,117.86 198.62,117.86 196.17,115.41 196.17,115.05 189.26,108.14 189.26,106.89 188.45,106.08 186.82,106.08 185.98,105.24 178.09,105.24 177.53,105.8 175.93,105.8 175.26,106.46 174.23,106.46 173.57,105.8 172.57,105.8 171.85,105.08 168.14,105.08 167.82,104.76 165.53,104.76 164.24,103.46 159.77,103.46 159.01,104.22 153.09,104.22 152.83,104.48 151.96,104.48 151.24,105.2 150.72,105.2 147.5,108.42 147.5,108.92 146.89,109.53 145.85,109.53 v3(145.6,109.79)
  IN3 w0.084: v6(219.66,118.13) 219.66,118.59 v4(221.68,120.61) ; v4(238.36,110.14) 238.36,112.33 v6(238.37,112.34)
  BOTTOM w0.119: v6(219.66,118.13) 221.17,116.61 223.04,116.61 223.81,117.39 226.02,117.39 226.79,116.61 230.74,116.61 234.03,113.33 235.67,113.33 236.03,112.97 237.75,112.97 v6(238.37,112.34)
ACCEL_INT2#_L: length 63.2
  TOP w0.119: U20.12 225.25,106.46 225.44,106.27 228.78,106.27 229.83,107.32 229.83,110.38 229.95,110.5 R396.1 R392.1 v2(231.36,110.5)
  IN2 w0.084: v4(237.19,110.14) 236.73,110.14 235.68,109.1 232.85,109.1 231.45,110.5 v2(231.36,110.5)
  IN3 w0.084: v6(218.88,117.46) 218.88,118.72 222.54,122.38 222.54,124.32 222.92,124.69 222.92,134.08 223.34,134.5 223.34,136.07 v6(223.15,136.27) ; v4(237.19,110.14) v6(237.19,112.31)
  BOTTOM w0.119: v6(237.19,112.31) 236.06,112.31 235.49,112.89 233.84,112.89 230.56,116.17 226.61,116.17 225.84,116.95 223.99,116.95 223.22,116.17 220.16,116.17 v6(218.88,117.46) ; JSER.6 v6(223.15,136.27)
ACTIV_LED: length 141.1
  TOP w0.119: Q343.1 202.71,140.68 v2(202.72,140.66) ; JDMIC1.8 v2(87.27,132.94)
  IN2 w0.084: v4(142.03,127.37) 142.14,127.37 143.02,126.49 145.22,126.49 147.03,128.3 149.79,128.3 149.97,128.48 153.2,128.48 154.18,127.5 158.68,127.5 160.23,129.05 161.35,129.05 161.58,129.29 162.4,129.29 162.59,129.09 167.06,129.09 167.17,129.2 171.47,129.2 172.5,128.16 176.25,128.16 176.66,128.57 177.57,128.57 178.2,127.94 178.2,126.38 180.54,124.04 184.84,124.04 185.47,124.67 188.81,124.67 190.07,125.93 190.07,129.55 192.68,132.15 193.65,132.15 195.6,134.1 195.6,134.92 197.27,136.59 200.77,136.59 202.93,138.74 202.93,140.46 v2(202.72,140.66) ; v2(87.27,132.94) 87.16,133.06 87.16,133.82 v4(87.19,133.85)
  IN3 w0.084: v4(87.19,133.85) 87.88,133.15 92.57,133.15 93.07,133.65 95.49,133.65 96.78,132.35 99.31,132.35 99.49,132.53 100.17,132.53 101.68,134.04 104.58,134.04 104.73,133.89 106.17,133.89 107.07,132.99 109.44,132.99 110.13,132.3 114.25,132.3 114.96,131.58 115.97,131.58 116.08,131.47 120.1,131.47 121.08,130.49 121.8,130.49 124.74,127.55 133.18,127.55 133.68,128.06 139.73,128.06 140.08,127.71 141.8,127.71 142.03,127.48 v4(142.03,127.37)
  GND4 w0.119: v4(142.03,127.37) v15(142.03,126.89)
ACTIV_LED_L: length 4.5
  TOP w0.119: Q343.3 202.06,144.77 202.28,144.99 202.89,144.99 203.32,145.42 R5712.2 203.32,146.42 R66.2 203.33,146.74 C1408.1 R5711.1
ALERT_B: length 1.7
  TOP w0.089: PR838.1 69.57,111.79 70.1,111.26 70.32,111.26 70.42,111.16 PU800.K4
ALLSYS_PWRGD: length 219.7
  TOP w0.119: v1(232.7,133.27) 232.94,133.27 233.7,132.51 233.7,131.59 R176.1
  IN1 w0.06: 171.81,124.48 171.48,124.48 171.32,124.32 170.8,124.32 170.44,123.96 170.06,123.96 169.79,123.69 169.79,123.5 169.69,123.4 168.28,123.4 168.19,123.31 168.19,123.12 168.18,123.11 168.07,123 167.79,123 v2(167.59,123.2)
  IN1 w0.089: v1(73.01,106.38) 74.72,104.67 v1(75.67,104.67) 77.32,106.32 77.32,109.53 81.51,113.72 87.2,113.72 88.03,114.55 94.59,114.55 94.75,114.71 94.75,116.92 93.86,117.81 93.86,123.11 94.26,123.51 95.84,123.51 96.49,124.16 96.49,125.06 100.07,128.63 100.29,128.63 100.44,128.78 v8(100.44,129.14) ; v1(232.7,133.27) 232.95,133.52 232.95,134.02 231.01,135.96 231.01,136.64 229.99,137.65 229.76,137.65 229.35,138.06 223.15,138.06 222.91,138.29 221.08,138.29 220.83,138.04 220.06,138.04 219.75,138.36 216.37,138.36 215.97,137.95 214.14,137.95 213.68,138.41 210.8,138.41 208.67,136.28 208.49,136.28 207.09,134.88 207.09,134.79 205.37,133.07 204.02,133.07 203.89,132.94 203.89,130.56 203.4,130.07 202.73,130.07 202.54,129.88 200.89,129.88 200.71,130.07 194.88,130.07 194.53,129.73 193.36,129.73 192.88,129.24 192.24,129.24 190.25,127.25 190.25,127.06 188.83,125.64 188.27,125.64 185.73,123.09 185.73,121.37 184.42,120.07 183.22,120.07 183.05,119.9 179.8,119.9 179.4,120.3 178.07,120.3 177.5,120.87 175.71,120.87 174.99,121.59 174.99,122.63 173.3,124.32 172.72,124.32 172.56,124.48 171.81,124.48
  GND1 w0.119: v8(100.44,129.14) 100.59,129.14 v4(100.87,128.86)
  IN2 w0.06: 165.75,123.06 165.83,123.06 165.9,123 166.25,123 166.31,122.94 166.58,122.94 166.83,123.2 v2(167.59,123.2)
  IN2 w0.084: 165.75,123.06 165.48,123.06 164.41,121.99 163.62,121.99 162.92,122.69 160,122.69 159.71,122.4 159.71,120.77 159.11,120.16 152.11,120.16 150.17,122.11 150.17,122.36 149.37,123.16 149.12,123.16 148.77,123.5 148.49,123.5 148.11,123.88 147.78,123.88 147.58,123.68 146.66,123.68 145.81,124.53 142.19,124.53 v4(141.83,124.17)
  GND3 w0.119: v4(142.36,119.95) 142.63,119.95 143.01,119.57 143.01,118.51 141.45,116.96 139.69,116.96 137.92,118.73 129.56,118.73 129.1,118.27 123.23,118.27 122.18,119.32 122.18,120.68 119.7,123.15 118.65,123.15 117.42,124.38 113,124.38 112.01,125.37 103.19,125.37 101.66,126.91 101.66,128.07 v4(100.87,128.86)
  IN3 w0.084: v4(141.83,124.17) 141.83,122.17 142.31,121.69 142.31,120 v4(142.36,119.95)
ALWON: length 95.8
  TOP w0.119: R1062.2 233.95,128.98 R184.2 233.58,129.74 234.09,130.25 234.09,132.43 232.85,133.68 v1(232.63,133.68) 230.35,133.68 230.02,133.35 227.29,133.35 D22.2 ; v1(193.91,128.33) 193.91,128.23 194.29,127.85 R208.2 194.37,127.91 194.37,128.63 194.27,128.73 U31.3
  IN1 w0.06: v1(169.19,122) 169.2,122 169.4,121.8 169.68,121.8 169.79,121.69 169.79,121.44 170.44,120.79 171.15,120.79
  IN1 w0.089: 171.15,120.79 171.51,120.79 173.97,118.33 173.97,117.71 175.51,116.17 175.78,116.17 175.98,116.37 175.98,117.61 177.87,119.51 183.65,119.51 183.83,119.69 184.6,119.69 186.11,121.19 186.11,122.86 188.34,125.09 188.92,125.09 192.59,128.76 193.17,128.76 193.61,128.33 v1(193.91,128.33) 193.91,128.56 194.34,129 198.32,129 199.01,129.69 200.55,129.69 200.73,129.5 202.88,129.5 203.01,129.63 204.04,129.63 205.78,131.37 206.35,131.37 208.94,133.96 208.94,135.99 210.95,138 212.61,138 213.09,137.52 221.58,137.52 221.91,137.85 222.77,137.85 223.12,137.49 228.97,137.49 229.68,136.78 230.28,136.78 230.75,136.31 230.75,135.95 232.63,134.07 v1(232.63,133.68)
