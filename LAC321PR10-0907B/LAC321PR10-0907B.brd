# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_CA_1_0: length 21.8
  IN2 w0.06: 129.07,116.76 129.07,116.19 129.07,115.82 128.68,115.43 128.18,115.43 127.76,115.85 127.41,115.85 127.41,115.85 126.07,115.85 124.7,114.49 124.7,111.35 124.83,111.22 124.83,110.91 v2(124.82,110.9)
  IN2 w0.076: v2(131.24,120.42) 131.76,120.93 131.76,122.75 131.1,123.41 130.39,123.41 130.04,123.06 130.04,122.58 128.52,121.06 128.52,120.84 128.79,120.58 128.79,119.51 129.16,119.14 129.16,118.66 129.02,118.52 129.02,118.29 129.02,118.29 129.02,118.11 129.02,118.11 129.07,118.06 129.07,116.76
M_B_CA_1_1: length 20.8
  IN2 w0.06: 129.25,116.73 129.25,116.71 129.22,116.68 129.22,116.66 129.21,116.66 129.21,116.25 129.22,116.24 129.22,115.77 128.74,115.3 128.12,115.3 127.7,115.72 127.36,115.72 127.36,115.72 126.13,115.72 124.86,114.45 124.86,111.47 125.05,111.27 125.05,110.85 124.82,110.62 v2(124.82,110.41)
  IN2 w0.076: v2(131.24,120.92) 131.61,121.28 131.61,122.64 131.02,123.23 130.44,123.23 130.21,123 130.21,122.52 129.55,121.86 129.55,120.36 129.66,120.26 129.66,117.99 129.68,117.97 129.68,117.74 129.25,117.31 129.25,116.73
M_B_CA_1_2: length 20.6
  IN2 w0.06: v2(124.82,109.92) 124.82,109.92 125.18,109.92 125.63,110.36 125.86,110.36 125.99,110.49 125.99,110.74 125.97,110.75 125.97,110.75 125.92,110.81 125.91,110.82 125.91,111.06 126.04,111.2 126.04,112.95 126.12,113.03 126.12,114.64 126.44,114.97 126.51,115.04 126.79,115.04 126.79,115.04 126.97,115.04 126.97,115.04 127.29,115.04 127.63,114.69 127.63,114.48 127.24,114.09 127.24,113.84 126.82,113.42 126.82,112.92 126.94,112.8 126.98,112.8 127.27,112.8 129.05,114.57 129.05,114.58 130.87,116.4 130.87,116.71 130.59,116.99
  IN2 w0.076: 130.59,116.99 130.59,118.14 130.72,118.27 130.72,120.06 130.77,120.11 130.77,120.12 130.91,120.25 130.92,120.25 131.02,120.35 131.02,121.19 v2(131.24,121.42)
M_B_CA_1_3: length 20.7
  IN2 w0.06: 130.44,116.93 130.72,116.65 130.72,116.44 130.02,115.75 130,115.75 128.9,114.65 128.9,114.64 128.87,114.61 128.75,114.61 128.63,114.74 128.42,114.74 128.36,114.68 128.36,114.57 128.54,114.4 128.54,114.29 128.47,114.23 128.36,114.23 128.2,114.39 128.2,114.64 128.16,114.67 128.06,114.67 127.96,114.58 127.96,114.35 128.22,114.09 128.22,113.98 128.16,113.91 128.03,113.91 127.85,114.08 127.74,114.08 127.65,114 127.65,113.89 127.8,113.74 127.8,113.56 127.68,113.43 127.57,113.43 127.51,113.49 127.41,113.49 127.3,113.38 127.3,113.28 127.36,113.22 127.36,113.1 127.19,112.93 127,112.93 126.96,112.97 126.96,113.32 127.42,113.79 127.42,114.04 127.8,114.42 127.8,114.76 127.39,115.17 127.13,115.17 126.46,115.17 126.39,115.1 125.87,114.58 125.87,114.33 125.98,114.21 125.98,113.12 125.89,113.03 125.89,111.28 125.78,111.17 125.78,111.04 125.78,111.03 125.78,110.77 125.78,110.77 125.78,110.66 v2(125.79,110.66)
  IN2 w0.076: 130.44,116.93 130.44,118.2 130.55,118.31 130.55,120.22 v2(130.74,120.42)
M_B_CA_1_4: length 19.5
  IN1 w0.061: v18(130.97,116.94) 130.95,116.96 130.95,117.02 130.85,117.12 130.85,117.25 130.62,117.48 130.53,117.48 130.46,117.4 130.46,117.09 130.38,117.01 130.23,117.01 130.15,117.09 130.15,117.42 130.07,117.49 129.88,117.49 129.78,117.39 129.78,117.13 129.86,117.05 129.87,117.05 130,116.92 130,116.73 129.99,116.72 129.99,116.71 129.68,116.4 129.68,115.97 129.78,115.87 129.91,115.87 129.99,115.95 129.99,116.06 129.9,116.15 129.9,116.26 130,116.37 130.11,116.37 130.21,116.27 130.31,116.27 130.49,116.45 v18(130.49,116.57)
  IN2 w0.06: 130.49,116.65 130.29,116.86 ; v2(126.11,109.92) 126.11,109.92 126.47,109.92 126.65,110.1 126.65,110.39 126.75,110.49 126.75,111.74 127.3,112.29 127.3,112.57 131.02,116.3
  IN2 w0.076: v2(130.74,120.92) 130.74,120.74 130.37,120.36 130.37,118.44 130.29,118.36 130.29,117.45 130.29,117.45 130.29,116.86 ; 131.02,116.3 131.02,116.86 130.97,116.91 v18(130.97,116.94) ; v18(130.49,116.57) 130.49,116.65
M_B_CA_1_5: length 16.2
  IN1 w0.061: v18(130.85,118) 131,118.15 131,118.79 130.93,118.87 130.75,118.87 130.65,118.76 130.65,118.15 130.55,118.05 130.27,118.05 130.04,118.28 129.63,118.28 129.53,118.18 129.53,117.95 v18(129.45,117.87)
  IN2 w0.06: 131.51,116.22 127.77,112.48 127.77,112.37 127.66,112.26 127.27,111.87 127.27,110.86 v2(127.07,110.66)
  IN2 w0.076: 131.51,116.22 131.51,117.42 131.12,117.8 131.04,117.8 v18(130.85,118) ; v2(129.24,120.92) 129.32,120.84 129.32,120.26 129.47,120.1 129.47,117.9 v18(129.45,117.87)
M_B_CA_1_6: length 21.8
  IN1 w0.061: v18(130.71,122.31) 130.71,122.67 130.56,122.83 130.19,122.83 129.52,122.16 129.52,121.62 129.31,121.42 v1(129.24,121.42)
  IN2 w0.06: v2(125.14,110.16) 125.18,110.16 125.58,110.56 125.58,110.74 125.65,110.81 125.65,110.81 125.66,110.82 125.66,110.99 125.66,111.1 125.46,111.3 125.46,111.6 125.29,111.78 125.29,114.21 126.39,115.31 127.19,115.31 127.47,115.31 127.9,114.88 127.92,114.88 127.92,114.87 128.93,114.87 129.94,115.88 130.21,116.16 130.21,116.71 130.13,116.79
  IN2 w0.076: v18(130.71,122.31) 130.71,122.36 131.07,122.72 131.3,122.72 131.43,122.59 131.43,122.04 131.03,121.64 130.65,121.64 130.65,121.64 130.62,121.64 130.49,121.51 130.49,121.31 130.38,121.19 130.34,121.19 130.34,121.19 130.2,121.19 130.02,121.02 130.02,121.01 130.02,120.82 130.02,120.82 130.02,120.74 130.09,120.67 130.09,120.66 130.13,120.62 130.13,120.62 130.19,120.56 130.19,118.54 130.13,118.48 130.13,117.51 130.13,116.79
M_B_CA_1_7: length 22.1
  IN1 w0.061: v1(128.74,120.42) 128.74,120.59 128.99,120.84 128.99,120.98 129.18,121.17 129.32,121.17 129.34,121.19 129.54,121.4 129.55,121.4 129.96,121.81 129.96,121.82 129.97,121.82 129.97,122.34 130.12,122.5 130.39,122.5 130.47,122.42 130.47,121.77 130.6,121.65 130.87,121.65 131.01,121.79 131.01,122.31 v18(131.18,122.48)
  IN2 w0.06: v2(125.46,110.9) 125.33,111.03 125.33,111.53 125.16,111.7 125.16,112.19 125.15,112.2 125.15,114.26 125.16,114.27 125.16,114.29 126.31,115.45 127.24,115.45 127.55,115.45 127.98,115.02 128.86,115.02 130.06,116.22 130.06,116.65
  IN2 w0.076: v18(131.18,122.48) 131.18,122.04 131,121.86 130.26,121.86 129.85,121.45 129.85,120.68 130.01,120.52 130.01,118.62 129.98,118.59 129.98,117.58 129.98,117.58 129.98,116.73 130.06,116.65
M_B_CA_1_8: length 15.7
  IN1 w0.061: v18(130.85,117.57) 130.75,117.67 130.11,117.67 130.04,117.75 130.04,118 129.96,118.08 129.81,118.08 129.73,118 129.73,117.75 129.6,117.62 129.35,117.62 129.22,117.74 129.22,118.24 v18(129.25,118.26)
  IN2 w0.06: 131.3,116.27 131.17,116.13 127.56,112.52 127.56,112.35 126.95,111.74 126.95,111.33 126.87,111.25 126.87,110.04 v2(126.75,109.92)
  IN2 w0.076: v2(128.75,120.93) 129.02,120.66 129.02,119.57 129.31,119.27 129.31,118.33 v18(129.25,118.26) ; 131.3,116.27 131.3,117.37 131.1,117.57 v18(130.85,117.57)
M_B_CA_1_9: length 21
  IN1 w0.061: v18(130.88,122.99) 130.12,122.99 129.28,122.14 129.1,122.14 129,122.04 129,121.25 128.9,121.15 128.79,121.15 128.74,121.21 128.74,121.41 v1(128.74,121.42)
  IN2 w0.06: 129.43,116.71 129.43,116.7 129.35,116.62 129.35,116.61 129.34,116.6 129.34,116.3 129.35,116.3 129.35,115.7 128.81,115.16 128.04,115.16 127.62,115.58 127.3,115.58 126.22,115.58 125.01,114.37 125.01,111.62 125.21,111.43 125.21,110.72 v2(125.14,110.66)
  IN2 w0.076: 129.43,116.71 129.43,117.24 129.83,117.64 129.83,120.44 129.7,120.57 129.7,121.78 129.91,121.98 130.16,121.98 130.41,122.24 130.41,122.77 130.63,122.99 v18(130.88,122.99)
M_B_CK_DDR0_DN: length 14.6
  IN1 w0.06: v1(125.14,111.64) UC1.BK36 125.14,111.85 125.34,112.05 125.34,112.22 125.26,112.3 125.26,115.37 v18(125.33,115.44)
  IN1 w0.069: v1(129.74,120.42) 129.65,120.32 129.65,119.72 129.44,119.51 128.81,119.51 128.45,119.15 128.45,119 128.54,118.91 v3(128.54,118.89)
  IN2 w0.06: v18(125.33,115.44) 125.33,115.66 125.6,115.93 125.6,116.38 125.76,116.54 125.97,116.54 126.06,116.46 126.06,116.31 126.34,116.02 127.8,116.02 127.81,116.02 128.16,115.66 128.61,115.66 128.88,115.92 128.87,116.21 128.79,116.29 128.71,116.37 128.71,116.43 128.72,116.45 128.72,116.46
  IN2 w0.091: 128.72,116.46 128.72,116.63 128.68,116.67 128.59,116.76 128.59,117.26 128.41,117.44 128.41,118.76 v3(128.54,118.89)
M_B_CK_DDR0_DP: length 14.7
  IN1 w0.06: v18(125.16,115.84) 125.17,115.83 125.17,115.59 125.1,115.53 125.1,115.28 125.14,115.24 125.14,112.13 v1(125.14,112.13)
  IN1 w0.069: v3(128.17,118.88) 128.32,119.03 128.32,119.21 128.75,119.64 129.38,119.64 129.52,119.77 129.52,120.51 129.74,120.73 v1(129.74,120.92)
  IN2 w0.06: 128.57,116.46 128.57,116.34 128.7,116.21 128.75,116.16 128.75,115.97 128.57,115.78 128.21,115.78 127.89,116.11 127.85,116.14 126.39,116.14 126.18,116.36 126.18,116.51 126.02,116.66 125.71,116.66 125.48,116.43 125.48,115.98 125.34,115.84 v18(125.16,115.84)
  IN2 w0.091: 128.57,116.46 128.57,116.56 128.5,116.63 128.5,116.64 128.44,116.69 128.44,117.2 128.26,117.38 128.26,118.8 v3(128.17,118.88)
M_B_CK_DDR1_DN: length 23.8
  IN1 w0.06: v18(126.76,116.73) 126.69,116.66 126.69,116.55 126.81,116.43 126.81,115.32 126.63,115.14 126.63,115.09 126.63,114.44 126.71,114.36 v18(126.91,114.36)
  IN2 w0.06: v2(126.43,110.16) 126.43,110.37 126.51,110.46 126.63,110.57 126.63,110.74 126.58,110.79 126.58,112.61 126.68,112.7 126.68,113.57 126.96,113.85 126.96,114.09 126.93,114.12 126.93,114.34 v18(126.91,114.36)
  IN2 w0.091: v18(126.76,116.73) 126.63,116.73 126.59,116.77 126.59,116.9 126.7,117.01 126.73,117.01 126.89,117.17 126.89,117.42 126.72,117.59 126.47,117.59 126.3,117.76 126.3,119.08 125.51,119.86 125.51,121.53 125.7,121.72 125.7,123.7 127.49,125.49 128.17,125.49 128.28,125.38 128.28,125.18 128.19,125.09 127.44,125.09 126.47,124.12 126.09,123.74 126.09,123.04 126.25,122.87 126.53,122.87 127.07,123.42 v2(127.24,123.42)
M_B_CK_DDR1_DP: length 23.7
  IN1 w0.06: v18(126.52,116.39) 126.69,116.22 126.69,115.37 126.51,115.19 126.51,115.04 126.51,114.39 126.66,114.25 126.66,114.09 v18(126.63,114.06)
  IN2 w0.06: v18(126.63,114.06) 126.67,114.09 126.77,114.09 126.84,114.02 126.84,113.9 126.56,113.62 126.56,112.75 126.46,112.66 126.46,110.69 v2(126.43,110.66) ; 126.54,116.42 126.52,116.4
  IN2 w0.091: 126.52,116.4 v18(126.52,116.39) ; v2(126.74,123.42) 126.74,123.3 126.46,123.02 126.32,123.02 126.24,123.1 126.24,123.67 126.56,123.99 126.62,124.05 126.75,124.05 126.94,123.86 127.09,123.86 127.19,123.96 127.19,124.09 126.97,124.31 126.97,124.4 127.5,124.94 128.25,124.94 128.43,125.12 128.43,125.44 128.23,125.64 127.43,125.64 125.55,123.76 125.55,121.78 125.36,121.59 125.36,119.8 126.14,119.01 126.14,117.69 126.4,117.44 126.66,117.44 126.74,117.36 126.74,117.23 126.67,117.16 126.63,117.16 126.43,116.96 126.43,116.71 126.56,116.58 126.56,116.44 126.54,116.42
M_B_CKE0: length 18.7
  IN1 w0.06: v1(126.11,112.38) 126.07,112.42 126.07,112.89 126.22,113.04 126.22,113.51 126.15,113.58 126.15,115.36 126.36,115.57
  IN1 w0.061: 126.36,115.57 126.4,115.61 126.4,115.94 126.15,116.19 126.15,116.88 126.42,117.15 126.67,117.15 126.76,117.24 126.76,117.37 126.87,117.48 126.87,117.68 127.01,117.82 127.09,117.82 127.17,117.9 127.17,118.03 127.12,118.08 126.95,118.08 126.87,118.15 126.87,118.35 127.1,118.58 127.2,118.58 127.26,118.52 128.06,118.52 128.19,118.65 128.37,118.65 128.51,118.52 128.61,118.52 128.79,118.69 128.79,119.25 128.86,119.32 129,119.32 129.07,119.25 129.07,118.92 129.15,118.84 129.26,118.84 129.33,118.92 129.33,119.19 129.45,119.31 129.56,119.31 129.64,119.24 129.64,118.93 129.73,118.84 129.96,118.84 130.1,118.98 130.1,119.08 129.78,119.4 129.78,119.52 129.86,119.6 129.96,119.6 130.29,119.27 130.4,119.27 130.47,119.35 130.47,119.57 130.19,119.85 130.01,119.85 129.85,120.02 129.85,120.13 129.96,120.23 130.11,120.23 130.65,119.7 130.82,119.7 131,119.88 131,120.52 130.85,120.67 130.62,120.67 130.52,120.77 130.52,120.82 130.52,120.82 130.52,121.01 130.52,121.01 130.52,121.07 130.42,121.18 130.3,121.18 130.24,121.12 v2(130.24,120.92)
M_B_CKE1: length 18.1
  IN1 w0.06: v1(126.43,111.64) 126.43,111.85 126.51,111.93 126.51,111.93 126.63,112.05 126.63,112.05 126.67,112.09 126.67,112.18 126.55,112.3 126.55,112.46 126.58,112.49 126.58,113.4 127.95,114.77 127.95,114.88 127.88,114.95 127.62,114.95
  IN1 w0.061: v2(130.24,121.42) 130.24,121.39 130.09,121.24 130.01,121.24 129.94,121.31 129.91,121.31 129.85,121.37 129.85,121.48 130.02,121.66 130.34,121.66 130.52,121.48 130.52,121.3 130.65,121.18 131.41,121.18 131.65,120.93 131.65,120.82 131.57,120.74 131.41,120.74 131.37,120.71 131.37,120.6 131.47,120.51 131.59,120.51 131.66,120.44 131.66,120.38 131.54,120.26 131.41,120.26 131.28,120.13 131.28,119.93 130.01,118.66 128.97,118.66 128.92,118.61 128.92,118.61 128.21,117.9 127.93,117.9 127.85,117.82 127.85,117.67 127.93,117.6 128.2,117.6 128.28,117.52 128.28,117.21 127.85,116.78 127.85,116.09 127.89,116.04 127.89,115.85 127.76,115.72 127.49,115.72 127.42,115.66 127.42,115.54 127.5,115.47 127.98,115.47 128.04,115.41 128.04,115.28 127.98,115.21 127.55,115.21 127.47,115.14 127.47,115.03 127.55,114.95 127.62,114.95
M_B_CKE2: length 17.9
  IN1 w0.06: v18(127.16,117.59) 127.16,117.54 127.34,117.36 127.34,116.35 126.96,115.97 126.96,114.9 v18(126.88,114.82)
  IN1 w0.061: v18(128.72,123.35) 128.58,123.49 128.58,123.49 128.42,123.64 128.03,123.64 127.31,122.92 v1(127.24,122.92)
  IN2 w0.06: v2(126.11,110.9) 126.19,110.99 126.19,112.89 126.26,112.97 126.26,114.51 126.57,114.82 v18(126.88,114.82)
  IN2 w0.076: v18(127.16,117.59) 127.16,117.64 126.51,118.3 126.51,120.02 126.68,120.19 126.91,120.19 126.98,120.26 126.98,120.56 126.17,121.37 126.17,122.14 127.09,123.06 128.43,123.06 v18(128.72,123.35)
M_B_CKE3: length 17.5
  IN1 w0.06: v2(127.07,111.15) 127.43,111.15 127.6,111.31 127.6,111.48 127.39,111.68 127.39,112 127.39,112 127.39,112.27 127.39,112.27 127.39,112.55 127.61,112.76 127.61,113.43 128.96,114.78 128.96,115.07 129.03,115.14
  IN1 w0.061: 129.03,115.14 129.53,115.64 129.53,115.75 129.45,115.83 129.17,115.83 129.1,115.9 129.1,116.05 129.17,116.13 129.45,116.13 129.53,116.21 129.53,117.21 129.2,117.54 v18(128.66,117.54) ; v1(127.74,122.92) 127.74,123.03 127.9,123.18 128.36,123.18 128.49,123.06 128.49,122.83 128.34,122.68 128.06,122.68 128,122.61 128,121.34 127.8,121.15 127.55,121.15 127.47,121.07 127.47,119.53 127.62,119.38 127.86,119.38 v18(128.05,119.57)
  IN2 w0.076: v18(128.05,119.57) 128.14,119.57 128.51,119.2 128.55,119.2 128.63,119.12 128.77,118.99 128.77,118.79 128.66,118.68 v18(128.66,117.54)
M_B_CS0_N: length 28.4
  IN1 w0.06: v1(127.07,112.13) 127.09,112.15 127.09,112.5 127.05,112.54 127.05,113.13 127.05,113.26 127.06,113.27 127.06,113.28 128.19,114.41 128.2,114.41 128.47,114.68 128.47,115.71 128.47,115.71 128.47,115.78
  IN1 w0.061: 128.47,115.78 128.47,115.98 128.5,116.01 128.5,116.2 128.43,116.27 128.43,117.15 128.44,117.15 128.44,117.45 128.44,117.58 128.43,117.59 128.43,117.78 129.14,118.48 130.09,118.48 131.52,119.92 131.52,120.01 131.82,120.3 131.82,121.03 131.52,121.32 131.52,121.51 131.65,121.64 131.66,121.64 131.67,121.65 131.85,121.65 131.99,121.79 131.99,122.66 130.47,124.18 130.06,124.18 129.83,123.95 129.83,123.71 128.94,122.82 128.94,122.55 128.99,122.5 v18(128.99,122.34) 129.25,122.34 130.13,123.23 131.04,123.23 131.48,122.79 131.48,121.76 131.38,121.66 131.12,121.66 130.87,121.42 v2(130.74,121.42)
  IN2 w0.076: v18(128.99,122.34) 129.22,122.34 129.53,122.65 129.53,123.28 129.66,123.41 129.81,123.41 129.88,123.34 129.88,122.64 129.31,122.07 128.87,122.07 128.47,122.46 127.79,122.46 v2(127.74,122.42)
M_B_CS1_N: length 31
  IN1 w0.06: v1(126.11,111.4) UC1.BJ33 126.11,111.61 126.19,111.69 126.31,111.8 126.31,111.97 126.31,111.97 126.19,112.09 126.19,112.18 126.31,112.3 126.31,112.46 126.25,112.52 126.25,112.88 126.34,112.97 126.34,113.58 126.3,113.62 126.3,115.28 126.55,115.53 126.55,116.02 126.3,116.27 126.3,116.7
  IN1 w0.061: v1(126.74,122.92) 126.86,122.92 127.1,123.16 127.32,123.16 128.01,123.84 128.01,124.07 128.11,124.17 128.34,124.17 128.94,124.78 129.05,124.78 129.14,124.69 129.14,124.52 128.51,123.89 128.51,123.77 128.64,123.64 128.91,123.64 129.06,123.49 129.06,123.23 128.69,122.86 128.69,122.24 128.47,122.02 128.47,121.72 128.44,121.68 ; v18(127.11,116.5) 127.19,116.57 127.19,116.83 127.04,116.98 126.48,116.98 126.3,116.8 126.3,116.7 ; 128.44,121.68 128.51,121.61 128.51,121.35 128.41,121.25 128.41,121.15 128.51,121.05 128.51,120.98 128.43,120.9 128.21,120.9 128.14,120.83 128.14,120.71 128.21,120.64 128.41,120.64 128.49,120.56 128.49,120.29 128.62,120.16 129.2,120.16 129.28,120.25 129.28,120.34 129.21,120.41 129.1,120.41 129.02,120.49 129.02,120.59 129.09,120.66 129.37,120.66 129.47,120.77 129.47,121.01 129.62,121.15 129.88,121.15 130.01,121.03 130.01,120.76 130.1,120.66 130.37,120.66 130.52,120.51 130.52,120.51 130.52,120.32 130.65,120.19 130.65,120.19 130.81,120.03 130.81,119.94 130.75,119.88 130.7,119.88 130.24,120.34 v1(130.24,120.42) ; 128.44,121.68 128.33,121.68 128.18,121.53 128.18,121.3 127.98,121.1 127.98,119.86 128.04,119.8 128.14,119.8 128.2,119.86 128.2,120.08 128.26,120.14 128.41,120.14 128.49,120.06 128.49,119.68 127.93,119.12 127.93,118.76 127.84,118.67 127.72,118.67 127.62,118.76 127.62,118.89 127.52,118.99 126.89,118.99 126.81,118.92 126.81,118.81 126.87,118.76 127.35,118.76 v18(127.37,118.77)
  IN2 w0.076: v18(127.11,116.5) 127.07,116.54 127.07,117.16 127.47,117.57 127.47,117.69 127.62,117.85 127.62,117.86 127.63,117.87 127.63,118.05 127.62,118.06 127.62,118.2 127.44,118.38 127.44,118.7 v18(127.37,118.77)
M_B_DQ_0: length 19
  IN2 w0.06: 124.55,114.24 124.55,111.26 124.62,111.2 124.62,110.16 124.4,109.81 124.3,109.71 124.07,109.71 123.81,109.81 123.64,109.81 v2(123.53,109.92)
  IN2 w0.076: 124.55,114.24 124.16,114.64 124.16,117.89 125.08,118.81 125.08,121.63 125.31,121.86 125.31,123.87 127.24,125.8 127.37,125.8 127.49,125.92 v2(127.74,125.92)
M_B_DQ_1: length 19
  IN2 w0.06: 124.37,114.17 124.37,111.27 124.5,111.15 124.5,110.24 v2(124.17,109.92)
  IN2 w0.076: 124.37,114.17 123.99,114.55 123.99,118 124.91,118.92 124.91,121.71 125.13,121.94 125.13,123.95 127.14,125.95 127.31,125.95 127.51,126.15 127.85,126.15 128.09,125.92 v2(128.24,125.92)
M_B_DQ_2: length 22.2
  IN2 w0.06: v2(123.53,110.9) UC1.BG41 123.53,113.76 122.87,114.42
  IN2 w0.076: v2(128.24,126.92) 128.49,127.16 128.49,127.58 128.39,127.67 128.04,127.67 127.91,127.81 127.52,127.81 127.37,127.65 126.95,127.65 126.76,127.85 125.61,127.85 124.82,127.06 124.82,125.22 124.02,124.42 124.02,122.37 123.81,122.17 123.81,119.5 122.87,118.56 122.87,114.42
M_B_DQ_3: length 18.7
  IN2 w0.06: 123.81,114.6 123.81,114.5 124.22,114.09 124.22,111.24 124.38,111.09 124.38,110.61 v2(124.17,110.41)
  IN2 w0.076: 123.81,114.6 123.81,118.1 124.73,119.02 124.73,121.89 124.96,122.12 124.96,124.03 127.06,126.13 127.27,126.13 127.44,126.3 128.13,126.3 v2(128.24,126.42)
M_B_DQ_4: length 24.5
  IN2 w0.06: v2(123.21,110.66) 123.21,113.63 122.47,114.37
  IN2 w0.076: 122.47,114.37 122.47,118.69 123.41,119.63 123.41,122.22 123.61,122.42 123.61,124.61 124.3,125.3 124.3,127.02 125.59,128.31 128.46,128.31 129.36,127.42 129.36,127.02 129.25,126.92 v2(128.74,126.92)
M_B_DQ_5: length 24.4
  IN2 w0.06: 122.67,114.39 123.38,113.69 123.38,111.07 123.33,111.02 123.33,110.99 123.33,110.99 123.33,110.82 123.41,110.74 123.41,110.74 123.41,110.57 123.29,110.46 123.21,110.37 v2(123.21,110.16)
  IN2 w0.076: v2(128.74,127.42) 128.74,127.33 129,127.08 129.15,127.08 129.21,127.14 129.21,127.36 128.42,128.14 125.66,128.14 124.57,127.05 124.57,125.28 123.81,124.53 123.81,122.4 123.61,122.19 123.61,119.58 122.67,118.64 122.67,114.39
M_B_DQ_6: length 19
  IN2 w0.06: v2(124.17,110.9) 124.09,110.98 124.09,111.18 124.07,111.21 124.07,114.04 123.64,114.47 123.64,114.52
  IN2 w0.076: v2(128.74,126.42) 128.71,126.42 128.46,126.66 128.16,126.66 127.96,126.45 127.38,126.45 127.23,126.31 126.96,126.31 126.85,126.18 124.78,124.1 124.78,122.19 124.55,121.96 124.55,119.12 123.64,118.2 123.64,114.52
M_B_DQ_7: length 21.5
  IN2 w0.06: v2(123.53,110.41) 123.53,110.62 123.73,110.82 123.73,111.01 123.67,111.07 123.67,113.86 123.08,114.45
  IN2 w0.076: 123.08,114.45 123.08,118.48 124.02,119.42 124.02,122.14 124.22,122.34 124.22,124.37 125.05,125.2 125.05,127.04 125.24,127.22 125.68,127.22 126.13,127.68 126.56,127.68 126.73,127.5 127.43,127.5 127.59,127.66 127.84,127.66 128.09,127.42 v2(128.24,127.42)
M_B_DQ_8: length 30
  IN2 w0.06: v2(122.89,109.92) 122.53,109.92 122.36,110.08 122.36,110.25 122.44,110.32 122.44,110.33 122.44,110.49 122.37,110.56 122.37,110.57 122.36,110.57 122.36,110.74 122.37,110.75 122.43,110.8 122.43,110.8 122.44,110.82 122.44,110.99 122.43,111 122.43,113.13 122.41,113.15 122.41,113.26 122.39,113.28 122.39,113.3
  IN2 w0.076: 122.39,113.3 121.45,114.24 121.45,119.02 121.63,119.2 121.63,125.72 125.13,129.23 129.94,129.23 131.38,127.78 131.71,127.78 132,127.5 132,127.16 v2(132.24,126.92)
M_B_DQ_9: length 34.5
  IN2 w0.06: 121.6,112.85 121.68,112.77 121.68,111.16 121.67,111.14 121.67,110.86 121.6,110.79 121.6,110.48 v2(121.92,110.16)
  IN2 w0.076: 121.6,112.85 120.46,113.99 120.46,119.37 120.72,119.63 120.72,123.99 120.74,124.02 120.74,126.17 124.69,130.12 130.42,130.12 131.84,128.69 132.02,128.69 133.12,127.59 133.12,126.68 132.62,126.18 132.14,126.18 132.04,126.28 131.89,126.28 v2(131.74,126.42)
M_B_DQ_10: length 29.4
  IN2 w0.06: v2(122.89,110.9) UC1.BG43 122.89,113.49
  IN2 w0.076: 122.89,113.49 122.04,114.34 122.04,118.87 122.21,119.04 122.21,125.55 125.38,128.72 129.56,128.72 130.63,127.64 130.63,126.58 130.64,126.58 130.64,126.24 130.73,126.15 130.88,126.15 130.94,126.2 130.94,126.56 131.03,126.66 131.14,126.66 131.14,126.66 131.34,126.66 131.35,126.66 131.36,126.66 131.49,126.53 131.49,125.69 131.55,125.63 131.67,125.63 131.75,125.71 131.75,125.91 v2(131.74,125.92)
M_B_DQ_11: length 28.6
  IN2 w0.06: v2(122.24,110.9) 122.27,110.93 122.27,113.09 122.27,113.09 122.27,113.19 122.24,113.23
  IN2 w0.076: v2(132.24,127.42) 132.17,127.49 132.17,127.53 132.15,127.56 132.15,127.56 131.74,127.96 131.48,127.96 130.04,129.41 125.04,129.41 121.45,125.82 121.45,119.27 121.25,119.07 121.25,114.22 122.24,113.23
M_B_DQ_12: length 33.3
  IN2 w0.06: v2(122.24,109.92) 122.24,110.12 121.95,110.42 121.87,110.42 121.72,110.57 121.72,110.74 121.78,110.8 121.79,110.81 121.79,111.09 121.84,111.15 121.84,112.83 121.78,112.9
  IN2 w0.076: v2(132.24,126.42) 132.88,126.67 132.97,126.76 132.97,127.51 131.97,128.52 131.77,128.52 130.34,129.94 124.76,129.94 120.89,126.07 120.89,119.53 120.64,119.27 120.64,114.04 121.78,112.9
M_B_DQ_13: length 29.3
  IN2 w0.06: v2(122.89,110.41) 123.01,110.53 123.01,110.74 123.09,110.82 123.09,110.99 123.07,111 123.07,113.54 122.26,114.34
  IN2 w0.076: 122.26,114.34 122.26,118.79 122.42,118.94 122.42,125.49 125.47,128.54 129.48,128.54 130.48,127.54 130.48,126.52 130.49,126.52 130.49,125.15 130.58,125.06 130.91,125.06 130.98,125.13 130.98,125.84 131.06,125.92 v2(131.24,125.92)
M_B_DQ_14: length 30.5
  IN2 w0.06: v2(122.24,110.41) 122.24,110.62 122.04,110.82 122.04,110.83 122.04,111.01 122.14,111.1 122.14,113.03 122.14,113.03 122.14,113.1 122.09,113.15
  IN2 w0.076: 122.09,113.15 121.05,114.19 121.05,119.17 121.27,119.4 121.27,125.92 124.94,129.58 130.14,129.58 131.57,128.15 131.85,128.15 132.49,127.52 132.49,127.18 v2(132.74,126.92)
M_B_DQ_15: length 30.2
  IN2 w0.06: 121.93,113.02 122,112.96 122,111.14 121.92,111.05 121.92,110.66 v2(121.92,110.66)
  IN2 w0.076: v2(132.75,127.42) 132.64,127.53 132.64,127.58 131.9,128.32 131.68,128.32 130.24,129.76 124.85,129.76 121.1,126.01 121.1,119.47 120.84,119.22 120.84,114.12 121.93,113.02
M_B_DQ_16: length 11.4
  IN1 w0.06: 131.43,117.48 131.43,116.87 127.85,113.29 127.85,112.67 127.72,112.53 UC1.BM28 v1(127.72,112.13)
  IN1 w0.061: 131.43,117.48 131.43,117.57 131.35,117.65 131.35,118.94 131.38,118.97 131.38,118.97 131.73,119.32 131.73,119.32 132.2,119.79 132.2,119.99 132.5,120.28 132.5,121.01 132.24,121.26 v1(132.24,121.42)
M_B_DQ_17: length 12.6
  IN1 w0.06: v1(128.04,112.38) 128.09,112.43 128.09,113.14 131.74,116.79 131.74,117.48
  IN1 w0.061: 131.74,117.48 131.74,117.54 131.76,117.57 131.76,117.82 131.72,117.87 131.72,118.88 131.85,119.01 131.86,119.01 132.25,119.41 132.59,119.41 133,119.82 133,120 133.15,120.16 133.36,120.16 133.49,120.28 133.49,120.99 133.33,121.15 133.16,121.15 133,121.31 133,121.67 v1(132.74,121.92)
M_B_DQ_18: length 12.4
  IN1 w0.06: 131.29,117.38 131.29,116.92 129.09,114.73 129.09,114.73 127.73,113.36 127.73,112.72 127.51,112.5 127.51,112.32 127.51,112.32 127.51,112.04 127.63,111.93 127.63,111.73 v1(127.72,111.64)
  IN1 w0.061: 131.29,117.38 131.29,117.44 131.17,117.56 131.17,119.02 132.01,119.86 132.01,121.52 132.24,121.75 v1(132.24,121.92)
M_B_DQ_19: length 14.3
  IN1 w0.06: 132.86,117.48 132.86,116.85 128.89,112.88 128.89,112.79 128.68,112.58 128.68,112.27 128.68,111.89 v1(128.68,111.89)
  IN1 w0.061: 132.86,117.48 132.86,117.54 133.22,117.91 133.38,117.91 134.57,119.1 134.57,119.33 134.84,119.6 134.84,121.69 134.51,122.01 133.96,122.01 133.83,122.15 133.67,122.15 133.5,122.32 133.5,122.32 133.41,122.42 v1(133.24,122.42)
M_B_DQ_20: length 12.8
  TOP w0.127: UC1.BN25 v1(128.68,112.87)
  IN1 w0.06: 132.68,117.56 132.68,116.86 v1(128.68,112.87)
  IN1 w0.061: 132.68,117.56 132.68,117.62 133.15,118.1 133.32,118.1 134.4,119.18 134.4,119.41 134.66,119.66 134.66,121.61 134.45,121.82 133.84,121.82 v1(133.74,121.92)
M_B_DQ_21: length 13.4
  IN1 w0.06: 131.59,117.58 131.59,116.83 127.97,113.22 127.97,112.6 127.84,112.46 127.84,112.3 127.96,112.18 127.96,111.97 v1(128.04,111.89)
  IN1 w0.061: v1(132.74,122.42) 132.74,122.26 132.49,122 132.49,121.31 132.65,121.15 132.85,121.15 133,120.99 133,120.31 132.85,120.16 132.64,120.16 132.51,120.03 132.51,119.89 132.45,119.83 132.45,119.82 131.79,119.17 131.79,119.17 131.53,118.91 131.53,117.73 131.59,117.67 131.59,117.58
M_B_DQ_22: length 14.7
  IN1 w0.06: v1(128.68,111.4) 128.68,111.6 128.89,111.81 128.89,111.94 128.88,111.95 128.88,111.97 128.8,112.05 128.8,112.23 128.82,112.25 128.82,112.52 129.02,112.72 129.02,112.81 133,116.8 133,117.44
  IN1 w0.061: v1(133.74,122.42) 133.88,122.42 134.1,122.19 134.61,122.19 135.02,121.79 135.02,119.55 134.73,119.27 134.73,118.99 133.45,117.7 133.27,117.7 133,117.44
M_B_DQ_23: length 14.7
  IN1 w0.06: v1(128.04,111.4) 128.4,111.4 128.44,111.44 128.56,111.56 128.56,111.72 128.47,111.82 128.47,111.96 128.56,112.05 128.56,112.22 128.52,112.26 128.52,112.55 128.47,112.6 128.47,112.94 128.61,113.08 128.67,113.08 132.5,116.91 132.5,117.7
  IN1 w0.061: v1(133.24,121.92) 133.27,121.92 133.55,121.64 134.35,121.64 134.48,121.51 134.48,119.74 134.22,119.48 134.22,119.24 133.24,118.26 133.06,118.26 132.5,117.7
M_B_DQ_24: length 18.7
  IN1 w0.06: v1(129.01,112.13) UC1.BM24 129.01,112.5 129.17,112.66 129.17,112.77 129.83,113.43 130.1,113.43 132.89,116.22 133.05,116.22 133.85,117.01 134.19,117.01
  IN1 w0.061: 134.19,117.01 135.24,117.01 135.45,117.21 135.45,121.68 134.87,122.26 134.87,123.22 134.56,123.52 133.68,123.52 133.52,123.67 133.15,123.67 132.99,123.84 132.99,123.99 132.82,124.16 132.57,124.16 132.48,124.25 132.48,124.51 132.24,124.75 v1(132.24,124.92)
M_B_DQ_25: length 21.7
  IN1 w0.06: v1(129.01,111.64) 129.36,111.64 129.41,111.6 129.41,111.6 129.54,111.46 129.54,111.46 129.57,111.44 129.57,111.44 129.73,111.44 129.75,111.46 129.76,111.46 129.93,111.64 130.05,111.64 130.17,111.76 130.17,111.8 130.17,111.81 130.17,111.97 130.17,112.13 130.29,112.25 130.29,112.25 131.33,113.29 131.38,113.29 131.39,113.31 131.39,113.31 133.29,115.2 133.61,115.2 134.28,115.87 134.35,115.87
  IN1 w0.061: v1(133.24,125.92) 133.48,126.15 134.33,126.15 134.88,125.59 134.88,125.05 136.21,123.72 136.21,122.9 136.67,122.44 136.67,116.71 135.83,115.87 134.35,115.87
M_B_DQ_26: length 19.5
  IN1 w0.06: 134.25,116.18 134.13,116.18 133.43,115.48 133.22,115.48 131.29,113.55 131.29,113.55 131.28,113.53 131.23,113.53 130.07,112.38 v1(129.97,112.38)
  IN1 w0.061: 134.25,116.18 135.66,116.18 136.31,116.83 136.31,122.24 135.82,122.73 135.82,123.58 134.52,124.89 134.52,125.48 134.33,125.66 133,125.66 v1(132.74,125.92)
M_B_DQ_27: length 23.1
  IN1 w0.06: v1(129.33,111.4) 129.33,111.19 129.58,110.94 129.72,110.94 129.98,111.19 130.03,111.19 130.04,111.2 130.06,111.2 130.24,111.38 130.24,111.47 130.41,111.64 130.41,112.01 130.85,112.45 130.84,112.46 131.44,113.05 131.48,113.05 131.49,113.07 131.49,113.07 133.37,114.94 133.78,114.94 134.4,115.57 134.47,115.57
  IN1 w0.061: 134.47,115.57 136.03,115.57 137.05,116.58 137.05,122.6 136.57,123.07 136.57,123.96 135.24,125.3 135.24,125.79 134.39,126.65 133.47,126.65 v1(133.24,126.42)
M_B_DQ_28: length 19
  IN1 w0.06: v1(129.33,111.89) 129.33,112.1 129.53,112.3 129.53,112.3 129.53,112.56 129.79,112.82 129.81,112.82 129.98,112.82 133.08,115.92 133.19,115.92 133.97,116.71 134.27,116.71
  IN1 w0.061: 134.27,116.71 135.42,116.71 135.78,117.06 135.78,121.94 135.28,122.44 135.28,123.33 133.95,124.66 133.13,124.66 132.99,124.8 132.99,125.02 132.98,125.02 132.84,125.17 132.84,125.18 132.74,125.28 v1(132.74,125.42)
M_B_DQ_29: length 19
  IN1 w0.06: v1(129.33,112.38) UC1.BN23 129.33,112.74 129.84,113.25 130.12,113.25 132.94,116.07 133.14,116.07 133.92,116.86 134.25,116.86
  IN1 w0.061: 134.25,116.86 135.32,116.86 135.6,117.14 135.6,121.81 135.06,122.35 135.06,123.26 134.64,123.69 134.15,123.69 134,123.84 134,124.04 133.88,124.16 133.15,124.16 132.99,124.32 132.99,124.55 132.88,124.66 132.67,124.66 132.66,124.67 132.64,124.67 132.5,124.82 132.5,124.83 132.49,124.85 132.49,125.02 132.38,125.12 132.38,125.28 v1(132.24,125.42)
M_B_DQ_30: length 20.7
  IN1 w0.06: v1(129.97,111.4) 130,111.4 130.29,111.69 130.29,112.02 130.29,112.08 131.39,113.17 131.43,113.17 131.44,113.19 131.44,113.19 133.32,115.06 133.68,115.06 134.34,115.72 134.4,115.72
  IN1 w0.061: v1(133.74,126.42) 134.33,126.42 135.06,125.68 135.06,125.18 136.38,123.86 136.38,123.01 136.84,122.55 136.84,116.63 135.93,115.72 134.4,115.72
M_B_DQ_31: length 19.3
  IN1 w0.06: 134.27,116.02 134.21,116.02 133.52,115.34 133.25,115.34 131.34,113.43 131.34,113.43 131.33,113.41 131.28,113.41 130.17,112.3 130.17,112.3 130.05,112.18 130.05,112.18 130.05,111.97 v1(129.97,111.89)
  IN1 w0.061: v1(133.74,125.92) 134.32,125.92 134.72,125.51 134.72,124.94 136.04,123.62 136.04,122.79 136.49,122.34 136.49,116.76 135.75,116.02 134.27,116.02
M_B_DQ_32: length 26.4
  IN1 w0.06: 122.24,113.6 v1(122.24,112.38)
  IN1 w0.061: v1(130.74,126.92) 130.5,127.16 130.5,127.98 129.32,129.16 124.51,129.16 121.3,125.95 121.3,117.16 121.34,117.13 121.34,116.13 121.02,115.81 121.02,115.56 121.34,115.24 121.34,114.92 122.24,114.02 122.24,113.6
M_B_DQ_33: length 28.5
  IN1 w0.06: 121.83,113.93 121.83,113.3 121.72,113.19 121.72,112.8 121.92,112.6 UC1.BM46 v1(121.92,112.13)
  IN1 w0.061: v1(130.74,126.42) 131.01,126.68 131.01,127.99 129.46,129.54 124.38,129.54 120.94,126.1 120.94,116.99 121.02,116.91 121.02,116.32 120.7,116 120.7,115.33 120.99,115.03 120.99,114.83 121.83,113.99 121.83,113.93
M_B_DQ_34: length 25.5
  IN1 w0.06: v1(122.89,111.89) 123.01,112.01 123.01,112.22 123.09,112.3 123.09,112.56 123.16,112.63 123.16,113.69
  IN1 w0.061: v1(130.74,125.92) 130.5,126.16 130.5,126.52 130.36,126.66 130.07,126.66 129.97,126.76 129.97,127.04 129.85,127.15 127.68,127.15 127.5,127.33 127.5,127.73 126.99,128.24 124.78,128.24 122.21,125.67 122.21,116.06 122.12,115.96 122.12,115.28 123.12,114.27 123.12,113.73 123.16,113.69
M_B_DQ_35: length 29.9
  IN1 w0.06: v1(121.92,111.64) 121.81,111.64 121.6,111.84 121.6,111.93 121.6,111.94 121.6,112 121.6,112.53 121.44,112.68 121.44,113.28 121.5,113.33 121.5,113.86 120.69,114.67 120.69,114.8 120.69,114.8
  IN1 w0.061: v1(131.24,126.92) 131.47,127.14 131.47,128.05 129.63,129.89 124.17,129.89 120.61,126.33 120.61,116.76 120.67,116.7 120.67,116.48 120.36,116.17 120.36,115.14 120.69,114.8
M_B_DQ_36: length 24.1
  IN1 w0.06: 123.01,113.61 123.04,113.58 123.04,112.68 122.89,112.53 v1(122.89,112.38)
  IN1 w0.061: v1(130.24,126.92) 130.24,127.05 129.86,127.44 129.59,127.44 129.37,127.66 128.65,127.66 128.39,127.92 128.39,128.13 128.1,128.42 124.71,128.42 122.02,125.73 122.02,116.47 122.02,116.47 122.02,116.08 121.96,116.02 121.96,115.19 122.95,114.2 122.95,113.68 123.01,113.61
M_B_DQ_37: length 27.1
  IN1 w0.06: v1(122.24,111.89) 122.24,112.1 122.04,112.3 122.04,112.65 122.12,112.73 122.12,113.26 122.03,113.35 122.03,113.6
  IN1 w0.061: v1(130.74,127.42) 130.74,128.01 129.41,129.34 124.43,129.34 121.12,126.03 121.12,117.06 121.19,117 121.19,116.24 120.85,115.9 120.85,115.45 121.19,115.12 121.19,114.86 122.03,114.01 122.03,113.6
M_B_DQ_38: length 29.1
  IN1 w0.06: 121.68,113.91 121.68,113.32 121.58,113.22 121.58,112.72 121.73,112.57 121.73,112.23 121.72,112.22 121.72,112.05 121.73,112.04 121.73,111.99 121.85,111.87 121.98,111.87 122.24,111.6 v1(122.24,111.4)
  IN1 w0.061: 121.68,113.91 120.84,114.75 120.84,114.9 120.54,115.21 120.54,116.1 120.87,116.43 120.87,116.78 120.77,116.88 120.77,126.21 124.28,129.72 129.55,129.72 131.24,128.02 v1(131.24,127.42)
M_B_DQ_39: length 26.4
  IN1 w0.06: 122.42,113.6 122.42,113.26 122.36,113.2 122.36,112.54 122.44,112.46 122.44,112.3 122.36,112.22 122.36,112.05 122.44,111.97 122.44,111.81 122.42,111.78 122.42,111.78 122.36,111.72 122.36,111.56 122.53,111.4 v1(122.89,111.4)
  IN1 w0.061: v1(130.24,127.42) 130,127.66 130,128.03 129.04,128.98 124.56,128.98 121.49,125.91 121.49,115 121.53,114.96 121.53,114.95 122.42,114.06 122.42,113.6
M_B_DQ_40: length 19.8
  IN1 w0.06: 123.33,114.28 123.33,113.03 123.3,113 123.3,112.6 123.21,112.51 123.21,112.51 123.21,112.25 123.21,112.25 v1(123.21,112.13)
  IN1 w0.061: 123.33,114.28 123.33,114.39 122.57,115.16 122.57,117.92 122.98,118.33 122.98,120.19 123.14,120.35 123.14,125.74 123.97,126.57 123.97,127.04 124.95,128.03 126.63,128.03 v1(127.24,127.42)
M_B_DQ_41: length 19.1
  IN1 w0.06: v1(123.53,112.38) 123.57,112.42 123.57,112.78 123.64,112.85 123.64,114.46
  IN1 w0.061: v1(127.24,126.92) 126.99,127.17 126.62,127.17 126.5,127.29 126.5,127.5 126.35,127.65 125.12,127.65 124.35,126.88 124.35,126.42 123.47,125.54 123.47,120.17 123.36,120.06 123.36,118.2 122.87,117.72 122.87,115.36 123.64,114.6 123.64,114.46
M_B_DQ_42: length 18.2
  IN1 w0.06: 124.5,115.04 124.5,113.59 124.52,113.58 124.52,112.61 124.5,112.59 124.5,112.25 124.5,111.93 124.37,111.81 124.26,111.69 124.18,111.69 123.89,111.4 v1(123.53,111.4)
  IN1 w0.061: v1(127.24,125.92) 126.98,126.18 126.85,126.18 126.84,126.18 126.64,126.18 126.64,126.18 126.59,126.18 126.41,126.37 125.88,126.37 124.58,125.06 124.58,119.7 124.42,119.55 124.42,117.29 123.99,116.86 123.99,116.2 124.14,116.05 124.14,115.64 124.41,115.38 124.5,115.28 124.5,115.04
M_B_DQ_43: length 17
  IN1 w0.06: v1(124.17,112.38) 124.23,112.44 124.23,114.94
  IN1 w0.061: 124.23,114.94 124.23,115.02 124.11,115.14 123.81,115.44 123.81,115.89 123.69,116.02 123.69,117.01 124.07,117.39 124.07,119.78 124.2,119.91 124.2,125.21 125.67,126.67 126.99,126.67 v1(127.24,126.42)
M_B_DQ_44: length 19.6
  IN1 w0.06: 123.48,114.36 123.48,112.95 123.45,112.92 123.45,112.59 123.33,112.47 123.33,112.46 123.33,112.3 123.33,112.3 123.38,112.25 123.38,112.24 123.41,112.22 123.41,112.05 123.29,111.93 123.21,111.85 v1(123.21,111.64)
  IN1 w0.061: v1(126.74,127.42) 126.74,127.56 126.47,127.83 125.02,127.83 124.17,126.98 124.17,126.51 123.29,125.63 123.29,120.25 123.15,120.11 123.15,118.26 122.72,117.82 122.72,115.26 123.48,114.5 123.48,114.36
M_B_DQ_45: length 18.6
  IN1 w0.06: 123.79,114.61 123.79,112.79 123.71,112.72 123.71,112.48 123.73,112.46 123.73,112.3 123.53,112.1 v1(123.53,111.89)
  IN1 w0.061: v1(126.74,126.92) 126.6,126.92 126.34,127.18 126.11,127.18 125.96,127.32 125.08,127.32 124.55,126.79 124.55,126.33 123.64,125.42 123.64,120.08 123.53,119.98 123.53,118.13 123.03,117.62 123.03,115.49 123.79,114.72 123.79,114.61
M_B_DQ_46: length 16.8
  IN1 w0.06: 124.37,114.97 124.37,113.6 124.38,113.59 124.38,112.09 v1(124.17,111.89)
  IN1 w0.061: 124.37,114.97 124.37,115.14 123.97,115.54 123.97,115.97 123.84,116.1 123.84,116.93 124.25,117.34 124.25,119.68 124.38,119.81 124.38,125.13 125.77,126.52 126.64,126.52 v1(126.74,126.42)
M_B_DQ_47: length 17.1
  IN1 w0.06: v1(124.17,111.4) 124.18,111.4 124.54,111.4 124.7,111.56 124.7,111.73 124.62,111.81 124.62,111.97 124.63,111.98 124.63,112.29 124.62,112.3 124.62,112.46 124.63,112.47 124.63,112.52 124.65,112.54 124.65,113.52 124.65,115.07
  IN1 w0.061: v1(126.74,125.92) 126.64,126.02 126.54,126.02 126.36,126.2 125.97,126.2 124.76,124.99 124.76,119.62 124.6,119.46 124.6,117.19 124.17,116.76 124.17,116.27 124.32,116.13 124.32,115.72 124.53,115.5 124.65,115.39 124.65,115.07
M_B_DQ_48: length 14.9
  IN2 w0.06: v2(127.72,110.66) 127.69,110.69 127.69,111.71 128.1,112.12 128.11,112.12 128.24,112.25 128.24,112.26 132.06,116.08 132.06,116.2
  IN2 w0.076: 132.06,116.2 132.06,117.57 131.26,118.37 131.26,119.22 132.22,120.19 132.33,120.19 132.49,120.34 132.49,121.07 132.6,121.18 132.6,121.68 132.65,121.74 132.76,121.74 132.82,121.67 132.82,121 v2(132.74,120.92)
M_B_DQ_49: length 15.6
  IN2 w0.06: 131.48,115.94 131.48,115.89 131.45,115.86 131.45,115.86 130.73,115.13 127.91,112.31 127.91,112.31 127.85,112.26 127.72,112.12 127.71,112.12 127.42,111.82 127.42,110.83 127.37,110.78 127.37,110.51 127.71,110.16 v2(127.72,110.16)
  IN2 w0.076: v2(132.24,120.92) 132.24,121.14 132.44,121.34 132.44,121.66 132.28,121.82 132.16,121.82 131.99,121.64 131.99,120.76 130.9,119.68 130.9,118.28 131.71,117.47 131.71,116.17 131.48,115.94
M_B_DQ_50: length 11.9
  IN2 w0.06: v2(128.68,110.9) 128.69,110.91 128.69,111.47 129.53,112.31 129.53,112.31 129.59,112.37 133.14,115.92 133.14,116.3
  IN2 w0.076: 133.14,116.3 133.14,118.23 132.77,118.6 132.77,119.25 133.74,120.23 v2(133.74,120.42)
M_B_DQ_51: length 13.5
  IN2 w0.06: v2(128.04,109.92) 128.04,110.12 127.92,110.24 127.92,110.25 127.8,110.36 127.79,110.36 127.72,110.44 127.63,110.44 127.5,110.57 127.5,110.74 127.55,110.79 127.55,111.76 128.05,112.26 128.1,112.31 128.1,112.31 131.89,116.1 131.89,116.23
  IN2 w0.076: 131.89,116.23 131.89,117.51 131.08,118.32 131.08,119.35 132.15,120.42 v2(132.24,120.42)
M_B_DQ_52: length 14.8
  IN2 w0.06: v2(128.04,110.9) UC1.BG27 128.04,111.67 132,115.63 132,115.63 132.36,115.99 132.36,115.99 132.4,116.04 132.4,116.36
  IN2 w0.076: v2(133.24,120.92) 133.39,120.92 133.57,121.1 133.57,121.47 133.5,121.54 133.09,121.54 133,121.45 133,120.35 132.2,119.55 132.09,119.55 131.56,119.02 131.56,118.52 132.4,117.69 132.4,116.36
M_B_DQ_53: length 12.9
  IN2 w0.06: v2(128.04,110.41) 127.92,110.52 127.92,110.56 127.93,110.57 127.93,110.73 127.84,110.82 127.84,110.84 127.82,110.85 127.82,111.55 127.9,111.63 127.9,111.73 131.86,115.68 131.86,115.69 132.23,116.06 132.23,116.19
  IN2 w0.076: v2(132.74,120.42) 132.74,120.38 132.12,119.75 132.04,119.75 131.41,119.12 131.41,118.45 132.23,117.63 132.23,116.19
M_B_DQ_54: length 14.2
  IN2 w0.06: 132.59,116.2 132.59,116.03 132.49,115.94 132.49,115.94 132.13,115.57 132.13,115.57 128.68,112.12 128.68,112.12 128.24,111.68 128.24,111.67 128.23,111.66 128.23,111.02 128.24,111 128.24,110.84 128.24,110.84 128.24,110.82 128.16,110.74 128.16,110.57 128.24,110.49 128.24,110.47 128.25,110.46 128.25,110.43 128.24,110.42 128.24,110.33 128.16,110.25 128.16,110.23 128.16,110.08 128.28,109.96 128.44,109.96 128.56,110.08 128.56,110.25 128.56,110.29 v2(128.68,110.41)
  IN2 w0.076: v2(133.24,120.42) 133.24,120.36 132.2,119.32 132.12,119.32 131.71,118.92 131.71,118.6 132.59,117.73 132.59,116.2
M_B_DQ_55: length 13.8
  IN2 w0.06: 133.31,116.38 133.31,115.9 129.67,112.26 128.86,111.45 128.86,111.01 128.88,110.99 128.88,110.82 128.79,110.73 128.79,110.59 128.88,110.49 128.88,110.32 128.81,110.25 128.81,110.24 128.68,110.12 v2(128.68,109.92)
  IN2 w0.076: 133.31,116.38 133.31,118.36 132.99,118.68 132.99,119.15 134.01,120.17 134.01,120.84 133.93,120.92 v2(133.74,120.92)
M_B_DQ_56: length 20.8
  IN2 w0.06: v2(129.01,110.66) 129.01,110.66 129.01,111.05 128.99,111.07 128.99,111.34 129.91,112.26 133.84,116.19 133.84,116.4
  IN2 w0.076: 133.84,116.4 133.84,118.45 134.58,119.2 134.58,121.58 133.3,122.87 133.3,122.94 132.94,123.3 132.89,123.3 132.88,123.31 132.67,123.31 132.49,123.49 132.49,123.49 132.47,123.51 132.47,123.51 132.34,123.64 132.15,123.64 132.15,123.64 131.73,123.64 130.94,124.43 130.94,124.58 130.94,124.58 130.94,124.77 130.94,124.77 131.31,125.14 131.84,125.14 131.84,125.13 132.22,125.13 132.48,124.88 132.48,124.68 v2(132.74,124.42)
M_B_DQ_57: length 21.9
  IN2 w0.06: 134.02,116.43 134.02,116.14 129.13,111.25 129.13,110.82 129.2,110.75 129.2,110.74 129.21,110.74 129.21,110.57 129.11,110.48 129.11,110.27 v2(129.01,110.16)
  IN2 w0.076: v2(133.74,123.92) 133.58,123.92 133.34,124.16 133.1,124.16 132.86,123.92 132.73,123.92 132.63,124.02 132.27,124.02 131.98,124.32 131.98,124.58 131.89,124.66 131.59,124.66 131.49,124.56 131.49,124.26 131.58,124.16 131.7,124.16 132.04,123.82 132.45,123.82 132.63,123.64 133.31,123.64 133.31,123.64 133.34,123.64 133.47,123.51 133.47,122.95 134.76,121.66 134.76,119.07 134.02,118.33 134.02,116.43
M_B_DQ_58: length 16.8
  IN2 w0.06: 134.7,115.77 134.42,115.49 134.41,115.49 131.17,112.25 131.12,112.25 130.81,111.94 130.8,111.94 129.97,111.1 UC1.BG21 v2(129.97,110.9)
  IN2 w0.076: v2(133.74,124.42) 133.96,124.42 134.99,123.39 134.99,122.73 135.65,122.06 135.65,118.53 134.91,117.8 134.91,115.98 134.7,115.77
M_B_DQ_59: length 20.8
  IN2 w0.06: v2(129.33,109.92) 129.69,109.92 129.84,109.76 129.84,109.76 129.89,109.72 130.06,109.72 130.17,109.83 130.17,110 130.17,110.06 130.17,110.08 130.41,110.32 130.41,110.62 130.53,110.73 130.53,111.03 134.58,115.08 134.59,115.08 134.61,115.11 134.75,115.11 135.14,115.49
  IN2 w0.076: v2(133.24,124.91) 133.65,125.32 133.87,125.32 135.52,123.67 135.52,122.98 136.18,122.32 136.18,118.2 135.44,117.46 135.44,115.79 135.14,115.49
M_B_DQ_60: length 17.9
  IN2 w0.06: v2(129.33,110.41) 129.43,110.51 129.43,110.72 129.53,110.82 129.53,110.99 129.53,111.25 130.53,112.26 134.37,116.09 134.37,116.43
  IN2 w0.076: v2(133.24,124.42) 133.38,124.42 133.64,124.16 133.99,124.16 134.38,123.77 134.38,123.66 134.3,123.58 134.08,123.58 134,123.51 134,122.93 135.12,121.81 135.12,118.81 134.37,118.07 134.37,116.43
M_B_DQ_61: length 16.1
  IN2 w0.06: v2(129.33,110.9) UC1.BG23 129.33,111.24 134.19,116.1 134.19,116.4
  IN2 w0.076: v2(133.24,123.92) 133.37,123.79 133.4,123.79 133.76,123.43 133.76,122.92 134.94,121.74 134.94,118.94 134.19,118.19 134.19,116.4
M_B_DQ_62: length 18.7
  IN2 w0.06: v2(129.97,109.92) 129.97,110.07 130.29,110.4 130.29,110.67 130.29,110.69 130.39,110.79 130.39,111.14 131.11,111.86 131.16,111.86 133.88,114.58 133.89,114.58 134.53,115.21 134.53,115.21 134.58,115.26 134.66,115.26 135.01,115.62
  IN2 w0.076: v2(133.74,124.92) 133.77,124.95 133.99,124.95 135.34,123.59 135.34,122.91 136.01,122.24 136.01,118.31 135.24,117.54 135.24,115.85 135.01,115.62
M_B_DQ_63: length 19.7
  IN2 w0.06: v2(129.97,110.41) 130.16,110.6 130.16,110.75 130.26,110.85 130.26,111.14 130.27,111.16 130.27,111.19 131.06,111.98 131.09,111.98 133.82,114.71 133.83,114.71 134.47,115.35 134.47,115.35 134.54,115.41 134.56,115.41 134.69,115.55
  IN2 w0.076: 134.69,115.55 135.07,115.92 135.07,117.67 135.83,118.43 135.83,122.17 135.16,122.83 135.16,123.52 134.02,124.66 133.09,124.66 132.98,124.56 132.98,124.28 132.88,124.18 132.48,124.18 v2(132.24,124.42)
M_B_DQS_DN_0: length 20.4
  IN1 w0.069: v18(125.96,125.63) 125.97,125.64 125.98,125.64 126,125.66 126.15,125.66 126.16,125.66 126.42,125.66 126.57,125.51 128.42,125.51 128.83,125.92 v1(129.24,125.92)
  IN2 w0.06: v2(123.85,110.16) 123.85,110.38 123.89,110.42 123.9,110.42 124.06,110.58 124.06,110.73 123.97,110.82 123.97,111.11 123.92,111.16 123.92,113.96 123.45,114.43 123.45,114.49
  IN2 w0.091: 123.45,114.49 123.45,118.33 124.36,119.23 124.36,122.02 124.59,122.26 124.59,124.21 125.81,125.43 125.81,125.57 125.89,125.64 125.94,125.64 v18(125.96,125.63)
M_B_DQS_DN_1: length 28.3
  IN2 w0.06: v2(122.56,110.16) 122.56,110.37 122.65,110.46 122.65,110.46 122.76,110.57 122.76,110.74 122.71,110.79 122.71,110.79 122.68,110.82 122.68,111.09 122.72,111.13 122.72,112.77 122.72,113.21 122.71,113.22 122.71,113.24
  IN2 w0.091: v2(131.74,126.92) 131.73,126.94 131.17,126.94 130.88,127.22 130.88,127.78 129.78,128.89 125.28,128.89 121.99,125.59 121.99,119.08 121.82,118.92 121.82,114.32 121.9,114.24 121.9,114.23 122.7,113.43 122.7,113.4 122.71,113.38 122.71,113.24
M_B_DQS_DN_2: length 15.8
  IN1 w0.06: 132.13,116.96 128.69,113.52 128.64,113.52 128.21,113.09 128.21,112.5 128.25,112.47 128.25,112.3 128.16,112.22 128.16,112.05 128.28,111.93 128.28,111.93 128.35,111.87 128.35,111.65 v1(128.36,111.64)
  IN1 w0.069: 132.13,116.96 132.13,116.96 132.22,117.05 132.22,117.85 132.47,118.09 132.92,118.55 133.13,118.55 133.28,118.7 133.28,118.79 v18(133.25,118.82)
  IN2 w0.091: v2(132.24,122.92) 132.4,122.92 132.64,123.15 132.82,123.16 132.93,123.05 133.01,122.98 133.13,122.86 133.13,122.41 134.36,121.18 134.36,119.65 133.67,118.97 133.63,118.97 133.63,118.97 133.44,118.97 133.44,118.97 133.41,118.97 v18(133.25,118.82)
M_B_DQS_DN_3: length 18.9
  IN1 w0.06: v1(129.65,112.13) UC1.BM22 129.65,112.51 129.84,112.7 130.04,112.7 131.13,113.79 131.19,113.79 133.15,115.75 133.29,115.75 133.7,116.16 133.7,116.17
  IN1 w0.069: 133.7,116.17 134.04,116.51 135.52,116.51 136,116.99 136,122.09 135.5,122.59 135.5,123.42 134.17,124.76 134.17,124.98 133.97,125.18 133.12,125.18 133.06,125.23 133.06,125.36 133.12,125.42 v1(133.24,125.42)
M_B_DQS_DN_4: length 26.2
  IN1 w0.06: 122.77,113.47 122.78,113.46 122.78,113.45 122.88,113.35 122.88,112.76 122.85,112.73 122.85,112.72 122.69,112.56 122.69,112.3 122.75,112.23 122.75,112.23 122.76,112.22 122.76,112.05 122.75,112.04 122.75,112.04 122.69,111.97 122.69,111.76 v1(122.56,111.64)
  IN1 w0.069: 122.77,113.47 122.7,113.54 122.7,114.24 121.81,115.13 121.81,116.17 121.83,116.2 121.83,125.8 124.64,128.61 128.76,128.61 128.94,128.42 v18(128.94,128.26)
  IN2 w0.091: v2(130.24,125.92) 130.24,126 130,126.25 130,126.34 129.68,126.65 129.68,127.41 129.48,127.62 129.37,127.73 129.08,128.01 129.08,128.11 129.08,128.13 128.95,128.26 v18(128.94,128.26)
M_B_DQS_DN_5: length 20.8
  IN1 w0.06: 123.89,114.88 123.95,114.81 123.95,112.72 123.85,112.62 123.85,112.14 v1(123.85,112.13)
  IN1 w0.069: v18(125.74,126.93) 125.74,126.96 125.53,127.17 125.19,127.17 125.11,127.1 124.74,126.73 124.74,126.26 123.83,125.35 123.83,120.03 123.73,119.93 123.73,118.02 123.19,117.49 123.19,115.58 123.24,115.53 123.42,115.35 123.89,114.88
  IN2 w0.091: v18(125.74,126.93) 125.6,126.93 125.51,126.84 125.51,126.84 125.48,126.81 125.48,126.52 125.54,126.46 125.62,126.38 125.73,126.38 125.8,126.45 125.8,126.62 125.88,126.69 126.03,126.69 126.11,126.62 126.11,126.45 126.18,126.38 126.37,126.38 126.92,126.93 127.1,126.93 127.18,127.01 127.18,127.1 127.25,127.17 127.41,127.17 127.48,127.1 127.48,127.01 127.52,126.96 127.56,126.93 127.65,126.93 127.66,126.92 v2(127.74,126.92)
M_B_DQS_DN_6: length 15.5
  IN1 w0.069: v1(133.24,121.42) 133.41,121.42 133.64,121.18 133.93,121.18 133.99,121.12 133.99,121.1 134.01,121.09 134.01,119.79 133.76,119.55 133.51,119.55 133.33,119.55 132.77,118.99 132.3,118.99 v18(132.24,119.05)
  IN2 w0.06: 132.95,115.98 132.95,115.95 128.48,111.49 128.48,111.1 128.48,111.1 128.48,110.82 128.56,110.75 128.56,110.74 128.56,110.57 128.44,110.46 128.44,110.46 128.36,110.38 v2(128.36,110.16)
  IN2 w0.091: v18(132.24,119.05) 132.24,118.86 132.95,118.15 132.95,115.99 132.95,115.98
M_B_DQS_DN_7: length 18.3
  IN1 w0.069: v1(132.24,123.92) 132.51,123.65 132.51,123.32 132.66,123.17 132.84,123.17 133.02,122.99 133.02,122.84 133.02,122.84 133.02,122.82 133.15,122.69 133.17,122.69 133.21,122.65 133.82,122.65 134.22,123.05 134.43,123.05 134.59,122.89 v18(134.59,122.81)
  IN2 w0.06: 134.46,115.96 134.45,115.95 134.45,115.94 129.65,111.14 129.65,110.66 v2(129.65,110.66)
  IN2 w0.091: v18(134.59,122.81) 134.58,122.81 134.58,122.64 134.66,122.56 134.66,122.55 135.31,121.89 135.31,118.69 134.57,117.95 134.57,116.62 134.57,116.62 134.57,116.07 134.46,115.96
M_B_DQS_DP_0: length 20.5
  IN1 w0.069: v1(129.24,126.42) 129.24,126.25 129.04,126.05 128.78,126.05 128.37,125.64 126.63,125.64 126.47,125.79 126.26,125.79 v18(126.08,125.97)
  IN2 w0.06: v2(123.85,110.66) 123.85,110.66 123.85,111.06 123.8,111.11 123.8,113.91 123.3,114.41 123.3,114.49
  IN2 w0.091: v18(126.08,125.97) 125.96,125.97 125.66,125.66 125.66,125.49 124.44,124.27 124.44,122.32 124.2,122.09 124.2,119.29 123.3,118.39 123.3,114.49
M_B_DQS_DP_1: length 28.2
  IN2 w0.06: v2(122.56,110.66) 122.56,111.14 122.6,111.18 122.6,112.82 122.6,112.82 122.6,113.16 122.56,113.2
  IN2 w0.091: v2(131.74,127.42) 131.78,127.38 131.78,127.27 131.59,127.09 131.23,127.09 131.04,127.29 131.04,127.85 129.84,129.04 125.22,129.04 121.83,125.65 121.83,119.14 121.67,118.98 121.67,114.25 121.74,114.18 121.74,114.17 122.32,113.6 122.54,113.37 122.54,113.33 122.56,113.32 122.56,113.2
M_B_DQS_DP_2: length 15.9
  IN1 w0.06: 132.24,116.88 132.19,116.83 132.18,116.83 128.74,113.4 128.69,113.4 128.33,113.04 128.33,112.55 128.39,112.5 128.39,112.16 v1(128.36,112.13)
  IN1 w0.069: v18(133.54,119.19) 133.54,119.18 133.5,119.15 133.5,118.75 133.43,118.68 133.43,118.67 133.18,118.42 132.98,118.42 132.35,117.8 132.35,117 132.24,116.88
  IN2 w0.091: v2(132.74,122.92) 132.74,122.72 132.63,122.6 132.02,122.6 131.95,122.53 131.95,122.42 132.04,122.33 132.34,122.33 132.41,122.26 132.41,122.21 132.49,122.14 132.64,122.14 132.72,122.21 132.72,122.26 132.8,122.33 132.99,122.33 134.2,121.12 134.2,119.72 133.68,119.19 v18(133.54,119.19)
M_B_DQS_DP_3: length 18.7
  IN1 w0.06: v1(129.65,111.64) 129.65,111.85 129.87,112.07 129.87,112.2 129.77,112.3 129.77,112.46 129.89,112.58 130.09,112.58 131.17,113.67 131.24,113.67 133.2,115.63 133.34,115.63 133.81,116.11 133.82,116.11 133.83,116.11
  IN1 w0.069: v1(133.74,125.42) 133.81,125.35 133.98,125.35 134.3,125.03 134.3,124.81 135.63,123.48 135.63,122.64 136.13,122.14 136.13,116.93 135.57,116.38 135.57,116.38 134.09,116.38 133.83,116.11
M_B_DQS_DP_4: length 26.1
  IN1 w0.06: 122.68,113.38 122.76,113.29 122.76,112.81 122.73,112.78 122.73,112.77 122.57,112.61 122.56,112.61 122.56,112.25 122.54,112.23 122.54,112.15 v1(122.56,112.13)
  IN1 w0.069: v18(129.32,128.28) 129.27,128.28 128.98,128.56 128.81,128.74 124.59,128.74 121.7,125.85 121.7,116.25 121.68,116.23 121.68,115.08 122.57,114.18 122.57,113.49 122.68,113.38
  IN2 w0.091: v18(129.32,128.28) 129.33,128.27 129.33,128.27 129.23,128.17 129.23,128.08 129.47,127.83 129.89,127.42 130.06,127.42 130.14,127.34 130.14,127.19 130.06,127.12 129.91,127.12 129.83,127.04 129.83,126.71 130.13,126.42 v2(130.24,126.42)
