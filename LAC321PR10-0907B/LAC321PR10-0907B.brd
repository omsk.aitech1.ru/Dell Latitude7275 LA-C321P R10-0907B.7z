# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ILEDB: length 9.5
  TOP w0.119: R66.1 202.34,146.43 v1(201.92,146.01)
  IN1 w0.089: v1(201.92,146.01) 200.59,144.67 198.94,144.67 196.07,141.8 195.63,141.8 195.47,141.96 195.22,141.96 v2(194.97,141.7)
ILIM4: length 7.4
  TOP w0.119: PC518.1 PR506.1 159.96,123.03 v2(160.38,123.45)
  IN2 w0.06: v2(165.99,123.2) 165.86,123.33 165.72,123.33
  IN2 w0.084: v2(160.38,123.45) 160.53,123.6 162.34,123.6 162.46,123.49 163.2,123.49 163.43,123.25 164.37,123.25 164.45,123.33 165.72,123.33
ILIM5: length 3.1
  TOP w0.119: v1(168.13,127.92) PR515.1
  IN1 w0.06: v1(168.39,126) 168.38,126 168.36,126.02 168.36,127.69 168.26,127.8
  IN1 w0.089: 168.26,127.8 v1(168.13,127.92)
ILIM6: length 7.7
  TOP w0.119: PC549.1 v2(174.94,119.99) 175.67,119.99 PR520.1
  IN2 w0.06: 171.05,122.52 170.83,122.3 170.49,122.3 v2(170.39,122.4)
  IN2 w0.084: v2(174.94,119.99) 174.89,119.93 173.53,119.93 172.91,120.55 172.91,121.98 172.4,122.49 172.17,122.49 171.93,122.73 171.26,122.73 171.05,122.52
INV_PWM_R: length 12.8
  TOP w0.119: JLVDS1.18 184.15,94.49 183.54,95.1 181.95,95.1 MC2.1 180.91,95.92 180.57,96.25 180.57,97.42 v2(180.62,97.46) ; D3.1 179.25,100.69 R32.1 178.94,100.44 178.66,100.16 178.66,99.54 179.02,99.17 v2(179.02,98.94)
  IN2 w0.084: v2(179.02,98.94) 179.59,98.37 179.59,97.37 179.75,97.21 180.34,97.21 180.6,97.46 v2(180.62,97.46)
IRQ_SERIRQ: length 122.2
  TOP w0.076: v1(137.68,113.72) 137.68,113.72 137.39,113.72 137.01,113.34 134.27,113.34 133.79,112.86 133.79,112.31 UC1.BN8
  IN1 w0.06: v1(137.68,113.72) 138.05,114.09 138.75,114.09 138.96,114.3 139.52,114.3 139.81,114.59
  IN1 w0.089: v1(230.81,124.75) 230.57,124.51 229.96,124.51 229.85,124.62 229.26,124.62 229,124.88 227.25,124.88 225.66,126.47 223.89,126.47 223.71,126.65 218.82,126.65 218.67,126.8 217.7,126.8 217.47,127.03 215.22,127.03 214.81,126.62 211.17,126.62 210.09,125.54 210.09,124.65 209.4,123.95 207.76,123.95 206.52,122.72 205.89,122.72 205.51,122.34 205.51,121.89 205.29,121.67 204.83,121.67 204.49,121.33 204.49,120.84 204.3,120.66 203.81,120.66 203.47,120.32 203.47,119.9 203.23,119.65 198.52,119.65 196.92,118.05 196.92,116.1 191.32,110.5 191.32,109.11 190.98,108.78 190.98,107.84 190.42,107.29 190.42,106.79 188.78,105.15 188.31,105.15 186.81,103.65 182.9,103.65 182.54,103.29 179.75,103.29 179.5,103.04 172.47,103.04 172.06,103.45 167.68,103.45 167.54,103.59 165.33,103.59 165.21,103.48 157.94,103.48 156.56,104.86 154.04,104.86 153.09,105.81 153.09,108.85 151.62,110.32 149.79,110.32 148.12,112 148.12,112.96 147.15,113.92 146.27,113.92 146.06,114.14 146.06,114.73 v1(145.94,114.84) 145.93,114.85 145.93,115.07 145.38,115.62 143.79,115.62 143.74,115.67 143.36,115.67 143.15,115.46 142.52,115.46 141.93,114.87 140.84,114.87 140.63,114.66 139.88,114.66 139.81,114.59
ISH_I2C0_SCL: length 180.8
  TOP w0.152: v10(218.81,108.61) 219.35,108.61 219.48,108.73 U20.2
  IN1 w0.06: v1(134.41,100.92) 134.61,100.92 134.81,100.72 135.13,100.72 135.88,99.98 136.43,99.98 137.17,99.23 137.34,99.23 137.53,99.05 139.19,99.05 140,98.24 140.06,98.24
  IN1 w0.089: v5(140.26,98.24) 140.06,98.24
  GND1 w0.089: v10(218.81,108.61) v4(218.42,108.61) ; v4(140.65,98.15) 140.56,98.24 v5(140.26,98.24)
  IN2 w0.084: v4(218.42,108.61) 217.96,108.61 217.05,107.7 211.76,107.7 v4(211,108.45) ; v4(218.01,141) 216.86,141 216.8,141.07 213.93,141.07 213.55,140.69 204.97,140.69 204.6,140.32 203.59,140.32 202.95,140.95 202.29,140.95 201.99,140.65 201.99,139.14 201.63,138.79 195.89,138.79 194.9,137.8 194.16,137.8 190.21,133.85 190.21,132.59 189.26,131.64 178.84,131.64 177.84,130.64 172.87,130.64 172.27,131.24 164.15,131.24 163.82,130.91 161.09,130.91 160.68,130.51 160.68,130.34 160.24,129.9 159.87,129.9 158.33,128.36 154.54,128.36 153.56,129.34 150.2,129.34 v4(149.71,129.83)
  IN3 w0.084: v6(147.55,103.52) 147.55,104.15 147.69,104.29 147.69,105.93 150.45,108.69 150.45,110.21 150.7,110.47 151.13,110.47 151.62,110.96 151.62,113.93 150.67,114.88 150.67,117.57 150.36,117.88 150.36,121.33 149.9,121.79 149.9,124.87 150.54,125.51 150.54,125.83 150.09,126.27 150.09,129.45 v4(149.71,129.83) ; v4(218.01,141) 218.01,139.21 219.74,137.49 v6(220.49,137.49) 220.53,137.44 220.53,135.09 221.61,134.01 221.61,125.24 219.54,123.17 219.54,121.76 218.08,120.3 218.08,118.53 216.96,117.41 v6(216.96,117.14)
  GND4 w0.089: v4(211,108.45) 211,109.22 v9(210.99,109.23) ; v4(140.65,98.15) 140.65,98.14 v9(140.91,97.87)
  BOTTOM w0.152: JSER.1 220.65,138.13 220.49,137.97 v6(220.49,137.49) ; v9(210.99,109.23) 212.43,109.23 214.67,111.48 214.67,114.84 216.34,116.51 216.62,116.51 216.96,116.85 v6(216.96,117.14) ; v6(147.55,103.52) 148.24,102.83 148.24,102.27 147.45,101.48 146.83,101.48 145.35,100 145.35,98.35 144.88,97.87 v9(140.91,97.87) 140.86,97.87 140.58,98.15 139.77,98.15 RH130.1
ISH_I2C0_SDA: length 180.5
  TOP w0.152: U20.4 219.91,107.87 219.83,107.79 v10(218.75,107.79)
  GND1 w0.089: v4(218.37,107.78) 218.38,107.79 v10(218.75,107.79)
  IN2 w0.06: v4(137.27,99.86) 137.19,99.78 136.19,99.78 135.79,100.19 134.57,100.19 133.91,100.84 v2(133.91,100.92)
  IN2 w0.084: v4(217.58,141.47) 217.52,141.4 216.81,141.4 212.04,141.4 210.95,142.5 204.05,142.5 203.83,142.72 201.48,142.72 201.1,142.35 198.24,142.35 197.39,141.5 197.39,140.77 194.91,138.29 194.17,138.29 187.86,131.98 178.7,131.98 177.7,130.98 173.16,130.98 172.56,131.58 164.01,131.58 163.68,131.25 160.95,131.25 160.34,130.65 160.34,130.48 160.1,130.24 159.73,130.24 158.19,128.7 154.68,128.7 153.7,129.68 150.6,129.68 v4(150.59,129.69) ; v4(210.46,108.45) 210.46,108.34 211.46,107.34 217.43,107.34 217.89,107.79 218.36,107.79 v4(218.37,107.78)
  IN3 w0.084: v4(150.59,129.69) 150.98,129.29 150.98,126.14 150.92,126.08 150.92,125.38 150.24,124.7 150.24,121.93 150.7,121.47 150.7,118.05 151.05,117.7 151.05,116.56 152.85,114.75 152.85,108.68 152.11,107.93 150.18,107.93 148.03,105.79 148.03,104.15 147.91,104.03 147.91,103.4 v6(147.5,103) ; v6(216.45,116.98) 216.62,116.81 217.07,116.81 217.35,117.09 217.35,117.33 218.42,118.39 218.42,120.16 219.88,121.62 219.88,123.03 221.95,125.1 221.95,134.15 221.19,134.91 221.19,137.35 v6(221.05,137.49) 221.05,137.57 220.78,137.84 219.88,137.84 218.73,139 218.73,140.9 218.16,141.47 v4(217.58,141.47)
  GND4 w0.089: v4(210.46,108.45) 210.46,109.2 v9(210.41,109.25) ; v9(138.87,99.4) 138.41,99.86 v4(137.27,99.86)
  BOTTOM w0.152: v6(216.45,116.98) 216.23,116.98 214.27,115.01 214.27,111.64 212.36,109.74 210.89,109.74 v9(210.41,109.25) ; v6(147.5,103) 147.5,102.78 144.95,100.22 144.95,98.54 144.68,98.28 141.36,98.28 141.04,98.6 140.2,98.6 139.86,98.94 RH131.1 139.59,99.11 139.38,99.32 138.94,99.32 v9(138.87,99.4) ; JSER.2 221.15,137.58 v6(221.05,137.49)
ISH_I2C1_SCL: length 6.3
  TOP w0.152: v1(137.88,100) 139.96,100 140.33,100.36 RH93.1
  IN1 w0.06: v1(134.9,101.57) 135.26,101.57 135.91,100.92 136.33,100.92 137.26,100 v1(137.88,100)
ISH_I2C1_SDA: length 5.2
  IN2 w0.06: v4(134.83,101.17) 134.59,101.41 134.59,101.42 134.55,101.46 134.35,101.65 133.5,101.65 v2(133.42,101.57)
  IN3 w0.084: v6(136.3,101.51) 136.1,101.3 135.03,101.3 134.9,101.17 v4(134.83,101.17)
  BOTTOM w0.152: RH92.1 137.67,100.24 136.4,101.51 v6(136.3,101.51)
JACK_PLUG#: length 9.6
  TOP w0.119: RA24.2 23.18,25.26 23.18,26.14 23.44,26.4 24.12,26.4 RA23.2 24.44,26.06 24.44,24.8 CA32.1 25.62,23.62 28.29,23.62 28.91,23.01 UA1.9
JTAG_CLK: length 63.4
  TOP w0.152: JDEG1.4 210.23,145.51 210.45,145.3 v1(210.45,144.88)
  IN1 w0.089: v3(235.16,141.79) 234.94,141.79 234.01,142.72 231.57,142.72 228.84,145.45 228.84,146.36 227.01,148.19 224.63,148.19 224.26,147.82 214.72,147.82 213.4,146.5 211.94,146.5 210.45,145 v1(210.45,144.88) ; v3(240.56,123.72) 239.38,122.54 236.9,122.54 236.65,122.79 236.42,122.79 236.26,122.64 235.84,122.64 235.72,122.51 234.55,122.51 234.32,122.75 v10(234.31,122.75)
  IN2 w0.084: v3(240.56,123.72) 240.68,123.72 240.7,123.74 242.1,123.74 243.02,124.67 243.02,126.1 243.63,126.71 243.63,131.17 242.65,132.15 241.22,132.15 239.47,133.9 238.65,133.9 235.85,136.7 235.85,138.45 235.18,139.12 v4(235.18,141.38) 235.18,141.77 v3(235.16,141.79)
  GND4 w0.089: v4(235.18,141.38) v15(234.65,141.38)
JTAG_RST#: length 9.2
  TOP w0.06: U27.B10 235.56,122 236.38,122 236.39,122
  TOP w0.119: R181.1 240.26,119.64 R178.2 239.62,119.63 C197.1 238.47,120.01 238.47,121.62 238.68,121.83 238.68,122.63 238.51,122.79 237.03,122.79 236.84,122.6 236.84,122.11 236.73,122 236.39,122
JTAG_TDI: length 69.4
  TOP w0.152: v1(211.59,144.88) 211.59,145.17 211.23,145.53 JDEG1.2
  IN1 w0.089: v1(234.31,122.25) 234.58,121.98 234.58,121.11 236.3,119.39 v3(236.98,119.39) ; v3(237.33,141.78) 236.52,140.97 234.61,140.97 233.71,141.87 231.27,141.87 228,145.14 228,145.85 226.47,147.38 224.99,147.38 224.43,146.82 215.33,146.82 214.1,145.59 212.66,145.59 211.95,144.88 v1(211.59,144.88)
  IN2 w0.084: v3(237.33,141.78) v4(237.33,141.12) 237.33,137.31 239.02,135.62 241.38,135.62 242.29,134.7 242.84,134.7 245.1,132.44 245.1,126.09 244.5,125.49 244.5,124.05 242.69,122.24 241.34,122.24 241.06,121.96 239.13,121.96 238.6,121.44 238.6,120.57 237.42,119.39 v3(236.98,119.39)
  GND4 w0.089: v4(237.33,141.12) v15(237.83,141.12)
JTAG_TDO: length 66.7
  TOP w0.152: v1(209.86,144.88) 209.73,145.01 JDEG1.5
  IN1 w0.089: v1(234.81,122.25) 235.05,122 235.66,122 235.98,121.67 237.88,121.67 237.91,121.64 238.84,121.64 238.87,121.67 239.79,121.67 v3(240.94,122.83) ; v3(236.4,141.83) 235.9,142.34 235.06,142.34 234.15,143.24 231.71,143.24 229.38,145.57 229.38,146.49 227.21,148.66 224.44,148.66 224.07,148.29 214.52,148.29 213.2,146.97 211.73,146.97 209.86,145.11 v1(209.86,144.88)
  IN2 w0.084: v3(236.4,141.83) v4(236.4,141.13) 236.4,140.5 236.66,140.24 236.66,137.03 238.75,134.94 241.1,134.94 242.01,134.03 242.56,134.03 244.43,132.16 244.43,126.37 243.83,125.77 243.83,124.33 242.41,122.91 241.03,122.91 v3(240.94,122.83)
  GND4 w0.089: v15(236.54,141.64) 236.4,141.5 v4(236.4,141.13)
JTAG_TMS: length 63.1
  TOP w0.152: JDEG1.3 210.73,145.56 211.02,145.27 v1(211.02,144.88) ; U27.A10 235.88,122.32 v1(236.43,122.32)
  IN1 w0.089: v1(211.02,144.88) 212.17,146.03 213.88,146.03 215.18,147.33 224.46,147.33 224.85,147.72 226.61,147.72 228.34,145.99 228.34,145.28 231.41,142.21 233.85,142.21 234.76,141.31 235.43,141.31 v3(235.92,141.8) ; v1(236.43,122.32) 236.45,122.32 236.74,122.03 238.01,122.03 238.05,121.99 238.63,121.99 238.68,122.03 239.58,122.03 240.37,122.82 240.45,122.82 v3(240.9,123.27)
  IN2 w0.084: v3(235.92,141.8) 235.64,141.53 v4(235.64,141.16) 235.64,139.32 236.32,138.64 236.32,136.89 238.84,134.37 239.66,134.37 240.86,133.16 242.95,133.16 244.09,132.02 244.09,126.51 243.49,125.91 243.49,124.47 242.29,123.27 v3(240.9,123.27)
  GND4 w0.089: v15(235.72,140.66) 235.64,140.73 v4(235.64,141.16)
JUSBC1_GND: length 3.5
  BOTTOM w0.102: v13(10.19,26.83) 9.07,25.71 JUSBC1.2
JUSBC2_GND:
  vias: v1(11,12.48) v1(11.02,12.09) v1(11.03,11.69) v1(13.44,13.34) v1(13.48,13.9) v1(13.74,13.62) v14(10.42,10.65)
KEYSSA_DP_PWR_EN: length 205.6
  TOP w0.119: U721.3 91.65,102.35 91.83,102.52 93.16,102.52 93.19,102.5 R5728.2 93.72,102.54 95.43,104.24 95.43,112.75 v1(95.74,113.06)
  IN1 w0.06: 229.81,123.46 230.43,123.46 230.64,123.25 v1(230.81,123.25)
  IN1 w0.089: 229.81,123.46 228.87,123.46 228.61,123.73 226.92,123.73 226.84,123.81 226.39,123.81 226.08,124.11 225.46,124.11 v3(225.18,123.83) ; v5(221.18,138.95) 221.01,139.12 216.06,139.12 215.97,139.03 215.28,139.03 214.75,139.56 214.12,139.56 213.73,139.17 210.47,139.17 209.85,138.55 208.67,138.55 208.5,138.39 207.71,138.39 204.75,135.42 204.75,135.25 203.03,133.53 196.4,133.53 195.95,133.07 195.45,133.07 194.95,132.57 193.2,132.57 192.87,132.24 192.03,132.24 189.44,129.65 188.22,129.65 186.37,127.8 186.37,126.16 185.13,124.92 179.78,124.92 179.27,125.43 179.27,127.88 177.94,129.21 176.33,129.21 175.83,128.71 173.82,128.71 173.29,129.24 172.64,129.24 170.77,131.11 167.75,131.11 167.1,130.46 165.72,130.46 165.21,130.97 163.42,130.97 162.76,131.63 v5(162.76,131.64) ; v1(95.74,113.06) 95.74,122.74 96.88,123.88 96.88,124.9 99.89,127.92 101.42,127.92 101.82,128.32 101.82,129.01 102.25,129.45 102.25,129.83 102.78,130.36 104.23,130.36 104.53,130.65 106.65,130.65 107.26,131.27 108.29,131.27 v3(109.61,129.95)
  GND1 w0.119: v5(162.76,131.64) 162.7,131.7 v4(162.19,131.7) ; v4(221.6,138.4) 221.6,138.53 v5(221.18,138.95)
  IN2 w0.084: v4(225.84,123.6) 225.61,123.83 v3(225.18,123.83) ; v4(110.59,132.77) 110.83,132.53 110.83,130.49 110.45,130.11 110.1,130.11 109.94,129.95 v3(109.61,129.95)
  GND3 w0.119: v4(162.19,131.7) 161.83,131.35 161.23,131.35 159.29,129.41 154.48,129.41 152.86,131.02 151.47,131.02 151.14,131.36 150.28,131.36 149.38,130.46 149.38,129.97 145.79,126.38 142.7,126.38 142.12,125.8 141.21,125.8 140.56,126.46 138.97,126.46 138.18,127.25 134.64,127.25 133.92,126.52 128.12,126.52 123.37,131.27 120.71,131.27 120,131.97 117.65,131.97 117.13,132.49 115.87,132.49 115.59,132.77 v4(110.59,132.77)
  IN3 w0.084: v4(225.84,123.6) 226.96,124.73 226.96,126.85 227.69,127.58 227.69,128.26 228.26,128.83 228.26,130.43 227.65,131.04 227.65,131.61 228.04,132.01 228.04,134.41 225.42,137.03 222.98,137.03 221.6,138.41 v4(221.6,138.4)
KEYSSA_LDBE_CTRL: length 131
  TOP w0.119: v1(230,115.99) 229.87,116.12 R5702.1 ; v1(134.07,82.62) 135.58,82.62 136.67,83.71 142.46,83.71 145.13,86.38 145.13,87.76 145.86,88.49 148.41,88.49 148.71,88.19 153.64,88.19 154.45,89 162.53,89 v1(163.07,89.54) ; QT21.2 127.64,83.6 v1(127.48,83.43)
  IN1 w0.089: v1(163.07,89.54) 163.64,89.54 163.85,89.34 164.28,89.34 165.12,88.49 165.12,88.22 165.49,87.85 171.86,87.85 172.01,88 188.1,88 189.38,89.27 195.32,89.27 195.56,89.51 199.59,89.51 199.98,89.9 199.98,102.56 199.57,102.96 199.57,104.52 199.98,104.92 199.98,104.91 202.57,107.5 206,107.5 212.17,113.67 212.17,114.01 213.53,115.36 215.57,115.36 216.27,116.06 217.24,116.06 217.9,116.73 221.07,116.73 221.45,116.35 221.68,116.35 222.27,115.76 225.43,115.76 225.66,115.99 v1(230,115.99) ; v1(134.07,82.62) 133.81,82.35 128.26,82.35 127.48,83.13 v1(127.48,83.43)
KEYSSA_LDBE_CTRL_R: length 8.6
  TOP w0.119: v1(228.2,117.6) 228.2,116.43 R5702.2
  IN1 w0.089: v1(231.31,121.75) 231.54,121.51 231.54,120.94 231.46,120.86 231.22,120.86 230.82,120.47 230.82,119.58 230.61,119.37 230.61,118.88 230.84,118.65 230.84,118.39 230.5,118.06 229.4,118.06 228.94,117.6 v1(228.2,117.6)
KEYSSA_LDBE_EN: length 1.7
  TOP w0.119: QT21.3 127.03,83.83 R5704.2 126.38,83.64 R143.2
KEYSSA_STABLE: length 149.1
  TOP w0.119: R1041.2 229.25,130.37 v7(230.1,131.22) ; QT20.3 128.79,80.42 129.11,80.1 133.43,80.1 136.82,83.48 142.55,83.48 145.35,86.28 145.35,87.67 145.95,88.27 148.32,88.27 148.62,87.97 153.73,87.97 154.54,88.78 162.79,88.78 v1(163.1,89.09)
  IN1 w0.089: v1(163.1,89.09) 163.1,88.91 164.35,87.66 172.02,87.66 v5(172.09,87.59)
  GND1 w0.119: v4(172.5,87.66) 172.42,87.59 v5(172.09,87.59)
  IN2 w0.084: v7(230.1,131.22) 230.12,131.21 231.3,131.21 232.36,130.15 232.36,128.92 233.35,127.93 233.35,125.76 233.47,125.64 233.47,125.13 232.78,124.44 232.78,123.76 232.62,123.59 232.62,122.56 v2(232.31,122.25) ; v4(198.96,116.14) 202.72,116.14 204.25,117.67 206.18,117.67 207.38,116.47 210.07,116.47 210.34,116.73 211.17,116.73 212.62,118.18 213.62,118.18 214.1,118.66 215.25,118.66 215.46,118.45 216.36,118.45 217.67,119.76 v4(222.89,119.76)
  IN3 w0.084: v7(230.1,131.22) 229.73,130.85 229.73,128.49 230.33,127.9 230.33,127.03 227.68,124.38 227.68,121.65 226.29,120.26 223.4,120.26 v4(222.89,119.76)
  GND4 w0.119: v4(198.96,116.14) 198.48,116.14 v9(198.15,116.47) ; v4(172.5,87.66) v6(172.98,87.66)
  BOTTOM w0.119: v6(172.98,87.66) 175.11,87.66 180.77,93.32 183.13,93.32 186.71,96.89 186.71,100.52 190.85,104.66 190.85,108.35 197.49,114.99 197.49,115.81 v9(198.15,116.47)
KEYSSA_USB_PWR_EN: length 179.6
  TOP w0.119: v7(97.99,85.53) 97.92,85.6 97.92,90.36 98.25,90.68 100.84,90.68 101.07,90.45 101.07,89.11 101.27,88.91 R389.2 101.43,88.5 101.19,88.27 U33.3
  IN1 w0.089: v7(215.02,118.13) 214.53,117.65 212.82,117.65 209.93,114.77 209.83,114.77 208.79,113.72 208.57,113.72 208.24,113.4 208.24,113.19 203.99,108.94 202.11,108.94 198.23,105.06 197.96,105.06 196.91,104.01 196.91,103.26 196.37,102.72 196.37,101.92 197.29,101 197.29,98.92 196.53,98.16 194.29,98.16 193.08,96.95 191.12,96.95 187.16,92.98 183.92,92.98 183.5,93.4 180.26,93.4 178.13,91.27 v3(174.05,91.27) ; v1(230.31,124.75) 230.23,124.82 229.33,124.82 229.08,125.07 227.33,125.07 224.93,127.47 217.84,127.47 217.66,127.65 215.67,127.65 v7(214.74,128.58)
  IN2 w0.084: v4(173.64,91.27) v3(174.05,91.27)
  IN3 w0.076: v7(215.02,118.13) 215.02,119.31 215.36,119.65 215.36,121.12 215.3,121.18 215.3,124.25 214.61,124.94 214.61,125.6 214.02,126.2 214.02,127.4 214.74,128.13 v7(214.74,128.58)
  IN3 w0.084: v7(97.99,85.53) 98.35,85.89 98.88,85.89 100.03,84.74 102.72,84.74 103.86,83.61 107.18,83.61 110.52,80.26 134.1,80.26 137.01,83.18 140.31,83.18 141.51,84.38 142.7,84.38 143.13,84.82 148.89,84.82 150.56,86.48 153.59,86.48 154.53,87.42 163.68,87.42 164.57,88.31 169.49,88.31 172.45,91.27 v4(173.64,91.27)
LAN_WAKE#: length 138.6
  IN1 w0.089: v3(230.17,136.51) 229.42,136.51 229.08,136.85 228.77,136.85 228.32,137.3 223.04,137.3 222.69,137.66 221.99,137.66 221.66,137.33 213.01,137.33 212.54,137.81 211.68,137.81 211.35,137.48 211.35,137.25 211.07,136.97 211.07,136.05 210.67,135.65 210.67,135.43 209.07,133.83 206.43,131.18 205.86,131.18 204.12,129.44 203.09,129.44 202.96,129.31 200.65,129.31 200.47,129.5 199.09,129.5 198.4,128.81 194.42,128.81 194.19,128.57 194.19,128.22 194.02,128.06 193.52,128.06 193.05,128.53 192.63,128.53 189,124.9 188.41,124.9 186.3,122.78 186.3,121.11 184.68,119.5 183.91,119.5 183.73,119.32 177.95,119.32 176.17,117.53 176.17,113.09 176.8,112.46 176.8,110.7 175.76,109.65 174.57,109.65 173.57,110.65 172.76,110.65 172.25,111.16 172.12,111.16 171.76,111.51 171.76,112.22 171.37,112.61 170.99,112.61 170.61,112.99 169.18,112.99 168.22,113.95 168.22,114.3 167.74,114.78 167.03,114.78 166.25,115.56 166.25,116.21 166.38,116.35 166.38,116.68 166.22,116.85 166.22,117.63 166.06,117.79 166.06,118.23 166.26,118.43 166.26,118.75 165.81,119.2 165.81,119.47 164.41,120.86 164.2,120.86 163.5,121.56 163.17,121.56 162.71,122.02 162.33,122.02 162.03,122.32 160.56,122.32 160.06,121.83 159.86,121.83 158.31,120.28 151.24,120.28 149.47,122.04 148.94,122.04 v3(148.62,122.36)
  IN2 w0.084: v3(148.62,122.36) 148.11,122.87 146.37,122.87 145.35,121.84 143.3,121.84 v2(142.63,122.51) ; v3(230.17,136.51) 230.17,133.03 230.54,132.66 231.7,132.66 233.27,131.09 233.27,129.12 234.17,128.22 234.52,128.22 235.62,127.11 235.62,125.13 235.27,124.78 235.27,124.43 234.51,123.67 233.7,123.67 233.55,123.52 233.55,123.19 234.1,122.65 234.22,122.65 234.79,122.08 234.79,121.27 v2(234.81,121.25)
LCD_VDD_AND_TST_EN: length 117.9
  TOP w0.119: R162.2 236.56,120.09 v2(236.12,120.53) ; v7(178.82,106.26) 178.82,106.01 178.27,105.46 177.82,105.46 177.32,104.96 175.93,104.96 175.6,104.63 175.6,102.74 D1.3 ; JLVDS1.29 v1(178.65,94.24)
  IN1 w0.089: v1(178.65,94.24) 178.76,94.24 178.95,94.43 179.69,94.43 179.87,94.61 183.42,94.61 184.28,93.75 186.84,93.75 190.8,97.71 192.37,97.71 193.4,98.73 196.29,98.73 196.72,99.16 196.72,100.76 195.75,101.73 195.75,102.91 196.34,103.5 196.34,104.25 199.64,107.56 199.64,108.02 200.19,108.57 200.93,108.57 201.92,109.56 203.09,109.56 v7(205.26,111.73) ; v1(235.31,121.25) 236.03,120.53 v2(236.12,120.53)
  IN2 w0.084: v4(228.26,118.7) 228.35,118.61 229.79,118.61 229.88,118.52 233.89,118.52 235.89,120.53 v2(236.12,120.53)
  IN3 w0.084: v4(228.26,118.7) 228.1,118.87 221.44,118.87 219.54,116.97 217.98,116.97 217.13,116.13 216.9,116.13 214.82,114.05 214.13,114.05 212.1,112.02 205.55,112.02 v7(205.26,111.73) 205.17,111.64 198.7,111.64 198.32,111.26 195.73,111.26 191.89,107.42 191.89,105.47 189.45,103.03 187.76,103.03 185.92,104.88 185.92,107.07 185.43,107.56 180.1,107.56 178.82,106.28 v7(178.82,106.26)
LDO2-CAP: length 5.8
  TOP w0.203: 24.93,18.39 25.17,18.63 UA1.22
  TOP w0.254: v2(22.97,17.37) 23.45,17.85 CA28.1 24.1,17.85 24.34,18.09 24.63,18.09 24.93,18.39
  IN2 w0.254: v2(21.85,15.55) 22.6,16.3 22.6,17 v2(22.97,17.37)
LG4: length 5.7
  TOP w0.254: PU500.L1 165.14,122.4 164.8,122.06
  TOP w0.508: PR502.2 161.02,120.18 161.63,120.79 163.34,120.79 164.61,122.06 164.8,122.06
LG4-1: length 1.4
  TOP w0.508: PQ500.8 160.89,118.91 PR502.1
LG5: length 23.3
  TOP w0.254: PU500.A6 167.59,126.85 167.22,127.22 v7(167.22,127.31)
  TOP w0.508: PR512.2 184.64,134.73 v10(184.36,135.01)
  GND1 w0.508: v4(183.9,135.39) 184.13,135.39 184.36,135.16 v10(184.36,135.01)
  IN3 w0.508: v4(183.9,135.39) 180.85,135.39 178.6,133.14 177.16,133.14 176.43,132.41 171.7,132.41 167.22,127.93 v7(167.22,127.31)
LG5-1: length 1.2
  TOP w0.508: PQ501.8 185.35,133.76 PR512.1
LG6: length 10.1
  TOP w0.254: PU500.L14 171,122.4 171.44,121.96 172.27,121.96 172.52,122.22 v1(172.66,122.22)
  TOP w0.457: v1(177.22,119.69) 177.37,119.54 178.25,119.54 PR517.2
  IN1 w0.508: v1(177.22,119.69) 176.61,119.08 176.23,119.08 175.81,119.5 174.64,119.5 172.97,121.17 172.97,121.39 172.66,121.7 v1(172.66,122.22)
LG6-1: length 1.7
  TOP w0.432: PR517.1 178.23,118.17 178.23,117.62 177.78,117.18 PQ502.8
LG10: length 8.6
  TOP w0.254: PU500.H1 165.59,123.58 163.96,123.58 v7(163.71,123.83)
  TOP w0.508: v7(158.07,123.15) 158.02,123.2 PR606.2
  BOTTOM w0.508: v7(163.71,123.83) 163.3,123.42 158.34,123.42 v7(158.07,123.15)
LG10-1: length 5
  GND1 w0.508: v4(157.69,124.54) 157.94,124.54 v10(158.15,124.75) ; v10(154.16,125.9) 155.22,125.9 v4(155.53,125.59)
  IN3 w0.508: v4(155.53,125.59) 155.68,125.74 156.95,125.74 157.38,125.31 157.38,124.89 157.69,124.58 v4(157.69,124.54)
LG11: length 18
  TOP w0.254: v7(166.96,120.15) 166.97,120.16 166.97,120.77 167.19,120.99 PU500.P5
  IN3 w0.762: v6(168.33,113.08) 168.21,112.95 168.21,110.29 168.92,109.58 168.92,108.54 167.14,106.76 166.02,106.76 165.08,105.82 v7(165.08,105.47)
  BOTTOM w0.762: 168.81,114.22 168.34,114.69 168.34,118.77 v7(166.96,120.15)
LG11-1: length 1.5
  TOP w0.508: PQ601.8 163.03,105.57 PR610.1
LID_CL_SIO#: length 188.8
  TOP w0.119: U24.6 81.54,133.9 v1(81.53,133.89) 80.79,133.89 R130.2 ; U27.J1 231.81,126.83 230.89,127.75 230.89,129.52 v7(230.31,130.11)
  IN1 w0.089: v3(83.37,133.38) 82.94,133.38 82.73,133.59 82.01,133.59 81.71,133.89 v1(81.53,133.89) ; v5(147.09,116.72) 147.48,116.72 147.8,116.41 149.97,116.41 150.3,116.74 150.79,116.74 151.3,116.23 151.3,115.77 153.78,113.29 163.25,113.29 163.33,113.22 164.26,113.22 168.1,109.38 168.62,109.38 170.8,107.2 172.83,107.2 173.19,106.83 175.1,106.83 175.37,106.57 178.04,106.57 178.5,107.03 179.07,107.03 179.72,107.68 185.59,107.68 188.18,110.27 188.18,114.61 191.58,118 191.58,118.55 193.54,120.51 193.54,120.88 193.86,121.2 193.86,122.13 195.94,124.21 197.72,124.21 198.79,125.28 202.72,125.28 203.03,125.59 203.47,125.59 204.47,126.59 204.96,126.59 210.6,132.23 210.92,132.23 213.7,135.01 228.02,135.01 229.61,133.41 229.61,130.8 v7(230.31,130.11)
  GND1 w0.119: v4(146.67,116.64) 146.74,116.72 v5(147.09,116.72)
  IN2 w0.084: v4(83.5,132.37) 83.5,133.25 v3(83.37,133.38)
  GND3 w0.119: v4(146.67,116.64) 145.24,115.22 142.98,115.22 142.47,114.71 141.55,114.71 141.01,115.24 139.06,115.24 138.7,114.89 138.26,114.89 137.91,115.24 137.25,115.24 136.74,115.75 134.85,115.75 134.13,115.02 122.18,115.02 117.56,119.64 114.79,119.64 113.71,120.72 112.91,120.72 111.77,121.86 105.44,121.86 104.8,122.5 101.97,122.5 96.51,127.96 95.25,127.96 94.45,128.76 88.46,128.76 86.27,130.95 84.9,130.95 83.5,132.35 v4(83.5,132.37)
LINE1_L: length 1.3
  TOP w0.254: CA51.1 30.36,11.87 RA61.2
LINE1_L_C: length 1
  TOP w0.254: RA31.1 CA50.2
LINE1_R: length 3.9
  GND1 w0.254: v10(28.56,12.58) 29.14,12.58 v4(29.34,12.38) ; v10(30.08,10.32) v4(30.54,10.32)
  IN3 w0.254: v4(29.34,12.38) 30.54,11.18 v4(30.54,10.32)
LINE1_R_C: length 1
  TOP w0.254: RA30.1 CA51.2
LINE1_VREFO: length 9
  TOP w0.203: v2(31.58,14.51) 31.31,14.78 UA1.40
  TOP w0.254: D8.1 v2(36.65,11.46)
  IN2 w0.254: v2(36.65,11.46) 33.31,14.8 31.86,14.8 v2(31.58,14.51)
LINE_L: length 2.7
  TOP w0.203: RA61.1 29.24,12.94 29.24,14.49 29.26,14.49 29.31,14.54 UA1.35
LINE_R: length 1.9
  TOP w0.203: RA63.1 28.91,13.85 UA1.34
LPC_AD0: length 140.5
  IN1 w0.06: v1(132.87,111.64) 132.87,111.85 133.1,112.08 133.1,112.09 133.3,112.3 133.3,112.59 134.17,113.46 136.65,113.46 137.95,114.76 138.77,114.76 139.53,115.53 139.81,115.53
  IN1 w0.089: v1(211.76,111.33) 211.76,111.5 213.14,112.88 213.14,113.6 v3(213.87,114.33) ; 139.81,115.53 v3(141.66,115.53)
  IN2 w0.084: v4(213.2,115.15) 213.2,115.01 v3(213.87,114.33) ; v3(141.66,115.53) 141.89,115.76 143.22,115.76 144,116.55 144,117.21 145.4,118.6 149.16,118.6 151.34,116.43 151.34,116.43 154.79,112.97 165.72,112.97 166.33,112.37 171.12,112.37 173.23,114.48 174.62,114.48 176.26,116.11 176.26,116.27 179.36,119.38 184.55,119.38 184.89,119.03 187.31,119.03 187.79,118.55 189.9,118.55 190.73,119.39 190.73,119.99 193.86,123.11 195.71,123.11 200.16,127.56 200.63,127.56 201.23,128.16 202.93,128.16 203.18,127.91 206.18,127.91 208.2,129.93 209.46,129.93 v4(210.81,131.28) 211.16,130.92 214.86,130.92 216.7,129.08 216.7,128.13 216.86,127.97 226.73,127.97 227.14,127.56 228.2,127.56 228.66,127.1 228.66,126.12 229.95,124.82 230.79,124.82 231.31,124.31 v2(231.31,124.25)
  IN3 w0.084: v4(213.2,115.15) 213.2,116.64 212.5,117.34 212.5,119.23 212.17,119.56 212.17,121.34 210.78,122.74 210.78,123.7 210.12,124.36 210.12,130.58 v4(210.81,131.28)
LPC_AD1: length 134.3
  IN1 w0.06: 139.81,114.03 139.66,114.03 139.41,113.78 138.89,113.78 137.83,112.72 136.32,112.72 136.19,112.85 134.99,112.85 134.58,112.44 134.06,112.44 133.92,112.3 133.92,112.06 133.78,111.92 133.78,111.44 v1(133.7,111.37)
  IN1 w0.089: v3(143.57,115.4) 143.41,115.25 142.61,115.25 142.02,114.66 140.93,114.66 140.72,114.45 140.6,114.45 140.18,114.03 139.81,114.03 ; v1(212.26,111.33) 212.26,111.44 213.37,112.54 213.37,113.43 v3(214.24,114.31)
  IN2 w0.084: v3(143.57,115.4) 143.57,115.5 144.64,116.57 144.64,117.22 145.36,117.94 147.76,117.94 148.04,117.66 149.51,117.66 154.62,112.55 165.55,112.55 166.15,111.94 171.3,111.94 173.41,114.05 174.89,114.05 176.84,116.01 176.84,116.26 179.54,118.96 183.24,118.96 184.23,117.97 189.95,117.97 191.34,119.36 191.34,120 194.03,122.69 195.89,122.69 200.34,127.14 200.8,127.14 201.35,127.68 202.81,127.68 203.07,127.41 207.27,127.41 207.71,127.86 209.34,127.86 210.09,128.61 211.22,128.61 v4(211.31,128.7) 211.42,128.58 212.43,128.58 213.11,129.27 214.99,129.27 215.43,128.82 215.43,128.31 216.21,127.54 218.06,127.54 218.13,127.47 219.02,127.47 219.63,126.85 223.5,126.85 223.64,126.99 226.19,126.99 227.51,125.67 228.5,125.67 229.68,124.49 230.38,124.49 230.63,124.25 v2(230.81,124.25) ; v4(213.59,115.49) 213.59,115.03 214.24,114.38 v3(214.24,114.31)
  IN3 w0.084: v4(211.31,128.7) 210.99,128.37 210.99,122.83 212.38,121.43 212.38,119.64 212.71,119.32 212.71,117.43 213.59,116.55 v4(213.59,115.49)
LPC_AD2: length 137.5
  IN1 w0.06: 139.81,113.59 139.73,113.59 139.67,113.53 139.13,113.53 138.08,112.48 135.99,112.48 135.82,112.31 135.28,112.31 135.15,112.44 134.92,112.44 134.79,112.31 134.79,112.12 134.68,112.01 134.04,112.01 133.9,111.87 133.9,111.59 133.94,111.55 133.94,111.28 133.82,111.16 133.51,111.16 133.35,111 v1(133.28,111)
  IN1 w0.089: 139.81,113.59 140.35,113.59 140.78,114.02 141.34,114.02 141.46,113.9 141.89,113.9 142.34,114.35 143.57,114.35 143.99,114.77 v3(144.3,114.77) ; v3(214.6,114.31) 214.6,114.17 213.94,113.51 213.94,112.81 212.76,111.63 v1(212.76,111.33)
  IN2 w0.084: v3(144.3,114.77) 144.3,115.28 144.85,115.83 144.85,117.13 145.43,117.71 147.69,117.71 147.95,117.45 148.44,117.45 149.14,116.76 149.31,116.76 153.76,112.3 163.54,112.3 164.11,111.73 166.74,111.73 168.78,109.69 171.88,109.69 172.03,109.84 186.18,109.84 187.3,110.96 187.46,111.12 187.46,114.55 193,120.09 193,120.63 194.85,122.48 195.97,122.48 199.66,126.16 200.53,126.16 201.09,126.72 201.09,127.12 201.43,127.47 202.72,127.47 202.99,127.2 207.36,127.2 207.8,127.64 209.43,127.64 210.1,128.32 211.68,128.32 v4(211.79,128.2) 212.63,128.2 213.47,129.04 214.92,129.04 215.22,128.74 215.22,128.23 216.12,127.33 217.97,127.33 218.05,127.26 218.93,127.26 219.55,126.64 223.63,126.64 223.77,126.78 226.09,126.78 228,124.87 229,124.87 229.63,124.25 v2(230.31,124.25) ; v3(214.6,114.31) 214.6,114.37 213.99,114.98 v4(213.99,115.16)
  IN3 w0.084: v4(213.99,115.16) 213.99,116.45 212.92,117.52 212.92,119.41 212.59,119.73 212.59,121.52 211.2,122.92 211.2,127.61 v4(211.79,128.2)
LPC_AD3: length 133.9
  TOP w0.076: v2(137.29,113.09) 137.26,113.06 134.92,113.06 UC1.BP5
  IN1 w0.089: v3(214.95,114.32) 214.95,114.1 214.23,113.38 214.23,112.73 213.26,111.76 v1(213.26,111.33)
  IN2 w0.084: v3(214.95,114.32) 214.95,114.38 214.36,114.98 v4(214.36,115.54) ; v2(231.31,123.75) 231.31,123.88 231.04,124.14 231.04,124.34 230.74,124.65 229.83,124.65 228.58,125.89 227.59,125.89 226.09,127.39 223.81,127.39 223.52,127.68 218.22,127.68 218.15,127.75 216.29,127.75 215.64,128.4 215.64,128.91 215.07,129.48 212.31,129.48 v4(211.77,128.94) 211.09,129.61 208.18,129.61 206.24,127.67 203.12,127.67 202.84,127.95 201.31,127.95 200.72,127.35 200.25,127.35 195.8,122.9 193.94,122.9 191.09,120.05 191.09,119.44 189.85,118.19 184.3,118.19 183.33,119.17 179.45,119.17 176.51,116.23 176.51,116.04 174.74,114.26 173.32,114.26 171.21,112.16 166.24,112.16 165.63,112.76 154.71,112.76 149.59,117.87 148.12,117.87 147.83,118.17 145.29,118.17 144.42,117.31 144.42,116.65 143.32,115.55 142.06,115.55 141.51,114.99 140.36,114.99 139.1,113.73 139.1,113.48 138.59,112.96 137.41,112.96 v2(137.29,113.09)
  IN3 w0.084: v4(211.77,128.94) 212.15,128.56 212.15,125.29 212.5,124.94 212.5,123.28 212.81,122.97 212.81,119.82 213.13,119.49 213.13,117.61 214.36,116.38 v4(214.36,115.54)
LPC_FRAME#: length 136.7
  TOP w0.076: UC1.BP7 134.05,112.73 134.52,113.2 137.08,113.2 137.21,113.33 137.63,113.33 v2(137.72,113.24)
  IN1 w0.089: v3(215.31,114.31) 215.31,114 214.88,113.57 214.88,113.05 213.76,111.93 v1(213.76,111.33)
  IN2 w0.084: v2(231.31,124.75) 231.1,124.75 230.84,125 230.07,125 228.87,126.2 228.87,127.19 228.29,127.77 227.23,127.77 223.57,131.43 v4(212.5,131.43) 212.23,131.7 210.52,131.7 209.4,130.59 208.56,130.59 207,129.02 202.47,129.02 202.28,128.83 200.95,128.83 200.35,128.24 199.49,128.24 194.58,123.32 193.64,123.32 190.27,119.95 190.07,119.95 189.37,119.24 184.98,119.24 184.63,119.59 179.28,119.59 174.37,114.69 173.14,114.69 171.03,112.58 166.42,112.58 165.82,113.18 154.88,113.18 151.43,116.64 149.23,118.83 145.19,118.83 143.79,117.43 143.79,116.63 143.13,115.97 141.7,115.97 141,115.27 139.68,115.27 137.72,113.32 v2(137.72,113.24) ; v3(215.31,114.31) 215.31,114.61 v4(214.74,115.18)
  IN3 w0.084: v4(212.5,131.43) 212.5,128.61 212.38,128.48 212.38,125.36 212.71,125.03 212.71,123.37 213.02,123.06 213.02,119.91 213.34,119.58 213.34,117.69 214.74,116.3 v4(214.74,115.18)
M_A_CA_0_0: length 23
  IN2 w0.06: v2(118.05,108.98) 117.83,108.75 116.64,108.75 116.09,109.3
  IN2 w0.076: v2(110.64,118.45) 110.99,118.45 111.25,118.2 111.75,118.2 111.83,118.12 111.83,117.97 111.75,117.89 111.22,117.89 111.14,117.82 111.14,117.39 110.8,117.05 108.99,117.05 108.49,116.55 108.47,116.55 108.46,116.54 108.07,116.54 107.62,116.09 107.62,115.88 107.05,115.31 107.05,113.77 107.42,113.4 107.42,113.39 107.44,113.37 107.44,113.18 107.45,113.17 107.45,113.16 110.81,109.8 114.15,109.8 114.21,109.85 114.21,109.86 114.34,109.99 114.34,109.99 114.52,109.99 114.53,109.99 114.66,109.86 114.67,109.84 114.67,109.39 114.76,109.3 116.09,109.3
M_A_CA_0_1: length 24.4
  IN2 w0.06: 116.03,108.65 116.47,108.21 118.65,108.21 119.06,108.62 119.06,108.96 v2(119.04,108.98)
  IN2 w0.076: 116.03,108.65 114.54,108.65 109.97,108.83 108.02,110.38 107.86,110.53 107.86,110.85 105.99,112.73 105.99,112.74 105.98,112.75 105.98,117.11 106.59,117.77 107.61,118.03 v2(110.14,118.45)
M_A_CA_0_2: length 24.4
  IN1 w0.061: v18(110.08,114.5) 110.07,114.5 110.14,114.57 110.14,114.64 110.36,114.86 110.36,116 111.49,117.12 111.49,117.32 111.12,117.69 110,117.69 109.88,117.81 109.88,118.04 109.64,118.29 v1(109.64,118.45)
  IN2 w0.06: 115.84,111.37 116.62,110.59 UC1.BF62 v2(117.31,110.59)
  IN2 w0.076: v18(110.08,114.5) 110.08,113.62 110.45,113.26 110.45,112.28 110.62,112.11 110.81,112.11 110.91,112.21 111.01,112.21 111.06,112.16 111.06,111.66 111.18,111.55 111.29,111.55 111.34,111.6 111.34,112.18 111.42,112.26 111.57,112.26 111.64,112.18 111.64,111.65 111.72,111.58 111.83,111.58 111.9,111.65 111.9,112.18 112,112.29 112.13,112.29 112.21,112.21 112.21,111.63 112.28,111.55 112.43,111.55 112.64,111.75 112.82,111.75 112.89,111.83 112.89,111.93 112.82,112.01 112.54,112.01 112.47,112.08 112.47,112.19 112.82,112.54 113.02,112.54 113.07,112.49 113.07,111.98 113.25,111.8 113.36,111.8 113.44,111.73 113.44,111.63 113.52,111.55 113.67,111.55 113.75,111.63 113.75,111.73 113.82,111.8 113.97,111.8 114.05,111.73 114.05,111.63 114.13,111.55 114.28,111.55 114.43,111.71 114.59,111.71 114.66,111.63 114.66,111.63 114.74,111.55 114.89,111.55 114.96,111.63 114.96,111.73 115.04,111.8 115.15,111.8 115.41,111.55 115.51,111.55 115.58,111.63 115.58,111.78 115.41,111.96 115.41,112.46 115.53,112.59 115.71,112.59 115.9,112.4 115.9,112.3 115.82,112.22 115.69,112.22 115.62,112.14 115.62,112.04 115.76,111.89 115.86,111.89 115.94,111.81 115.94,111.68 115.84,111.58 115.84,111.37
M_A_CA_0_3: length 23.7
  IN2 w0.06: v2(118.79,108.65) 118.47,108.33 117.05,108.33 117.03,108.35 116.57,108.35 116.1,108.81 116.07,108.81
  IN2 w0.076: v2(110.64,117.95) 110.26,118.18 110.18,118.19 107.69,117.87 106.72,117.65 106.16,117.09 106.16,112.77 108.02,110.92 108.02,110.64 108.21,110.45 110.03,109.03 114.67,108.81 116.07,108.81
M_A_CA_0_4: length 23.6
  IN2 w0.06: 116.07,109.09 116.63,108.53 117.95,108.53 118.03,108.45 118.39,108.45 118.55,108.61 v2(118.55,108.98)
  IN2 w0.076: v2(110.14,117.95) 110.27,117.95 110.33,117.9 110.33,117.75 110.26,117.68 109.71,117.68 109.57,117.82 109.42,117.82 109.32,117.72 107.76,117.72 107.53,117.49 106.82,117.49 106.31,116.99 106.31,112.87 108.19,110.99 108.19,110.69 108.36,110.52 110.1,109.2 114.12,109.2 114.33,108.99 114.7,108.99 114.8,109.09 116.07,109.09
M_A_CA_0_5: length 21
  IN2 w0.06: v2(118.3,108.65) UC1.AV58 118.3,109.04 118.16,109.18 118.16,109.18 118.15,109.18 118.15,109.18 117.95,109.18 117.95,109.18 117.82,109.18 117.54,108.9 116.71,108.9 116.13,109.48
  IN2 w0.076: v2(110.14,116.45) 110.29,116.6 110.66,116.6 110.75,116.7 110.75,116.8 110.68,116.87 109.05,116.87 108.57,116.39 108.14,116.39 107.8,116.06 107.8,115.84 107.2,115.23 107.2,113.83 107.58,113.46 107.58,113.45 107.6,113.43 107.6,113.24 110.86,109.98 113.78,109.98 114.26,110.46 114.48,110.46 114.82,110.11 114.82,109.72 115.06,109.48 116.13,109.48
M_A_CA_0_6: length 21.7
  IN2 w0.06: v2(118.79,109.3) 118.8,109.31 118.8,109.66 118.76,109.7 118.76,109.71 118.69,109.79 118.52,109.96 118.52,110.03 118.39,110.16 118.31,110.16 118.18,110.29 118.18,110.44 117.82,110.8 117.82,110.95 117.65,111.12 117.01,111.12 116.58,111.55 116.58,112.78 116.26,113.09 116.26,113.09 116.02,113.33 115.76,113.33
  IN2 w0.076: v2(109.64,116.45) 109.64,116.28 109.88,116.04 109.88,115.88 110.07,115.69 110.3,115.69 110.61,115.99 110.91,115.99 110.97,116.06 111.08,116.06 111.2,115.94 111.31,115.94 111.42,116.04 111.52,116.04 111.95,115.62 112.06,115.62 112.77,116.33 112.87,116.33 112.97,116.23 113.08,116.23 113.18,116.34 113.18,116.45 112.77,116.87 112.77,117.16 112.69,117.24 112.31,117.24 112.23,117.32 112.23,117.47 112.31,117.54 112.69,117.54 112.77,117.62 112.77,117.72 112.87,117.83 113.09,117.83 113.23,117.69 113.23,117.58 112.98,117.33 112.98,117.22 113.09,117.12 113.2,117.12 113.45,117.36 113.55,117.36 113.66,117.26 113.66,117.15 113.24,116.74 113.24,116.63 113.35,116.53 113.46,116.53 113.87,116.94 113.98,116.94 114.29,116.63 114.29,116.5 114.21,116.43 114.14,116.43 114.06,116.35 114.06,116.2 114.14,116.12 114.21,116.12 114.29,116.04 114.29,115.72 114.06,115.49 114.06,115.03 115.76,113.33
M_A_CA_0_7: length 23.3
  IN1 w0.061: v18(110.35,114.25) 110.35,114.3 110.39,114.33 110.39,114.52 110.59,114.73 110.73,114.73 110.89,114.88 110.89,115.06 111.05,115.22 111.09,115.22 111.16,115.29 111.16,115.61 111.37,115.82 111.37,116.04 111.22,116.2 110.88,116.2 v1(110.64,115.95)
  IN2 w0.06: 116.09,112.56 116.09,111.37 116.67,110.79 117.39,110.79 117.54,110.65 117.69,110.65 117.97,110.36 v2(117.97,110.35)
  IN2 w0.076: 116.09,112.56 115.94,112.72 115.8,112.72 115.72,112.79 115.3,112.79 115.22,112.72 115.22,112.12 115.12,112.01 115.07,112.01 114.99,112.09 114.99,112.24 114.99,112.24 114.99,112.64 114.84,112.79 114.68,112.79 114.55,112.66 114.55,112.54 114.44,112.44 114.36,112.44 114.28,112.52 114.28,112.77 113.98,113.07 113.63,113.07 113.55,113 113.55,112.11 113.47,112.03 113.32,112.03 113.24,112.11 113.24,113 113.17,113.07 113.1,113.07 112.49,112.47 111,112.47 111,112.46 110.81,112.46 110.81,112.47 110.78,112.47 110.61,112.64 110.61,112.79 110.61,113.07 110.71,113.18 110.94,113.18 111.27,112.85 111.54,112.85 111.62,112.92 111.92,112.92 112,112.85 112.24,112.85 112.4,113 112.4,113.21 112.24,113.37 112.03,113.37 111.75,113.1 111.29,113.1 111.12,113.27 111.12,113.38 111.49,113.74 111.49,113.82 111.4,113.91 111.29,113.91 111.16,113.77 111.05,113.77 110.94,113.88 110.94,113.99 111.07,114.11 111.07,114.21 111.01,114.27 110.37,114.27 v18(110.35,114.25)
M_A_CA_0_8: length 23
  IN2 w0.06: 115.43,111.25 115.44,111.24 ; 115.96,110.71 116.41,110.26 UC1.BD61 v2(117.56,110.26)
  IN2 w0.076: 115.44,111.24 115.96,110.71 ; v2(110.14,115.95) 110.31,115.95 110.53,116.17 110.83,116.17 111.29,116.63 111.77,116.63 111.85,116.71 111.85,116.81 111.77,116.88 111.22,116.88 110.76,116.43 110.48,116.43 110.26,116.21 110.06,116.21 109.89,116.38 109.89,116.62 109.8,116.7 109.13,116.7 108.64,116.22 108.19,116.22 107.96,115.99 107.96,115.72 108.09,115.59 108.42,115.59 108.52,115.49 108.62,115.49 108.73,115.39 109.01,115.39 109.08,115.31 109.08,115.21 109.01,115.14 108.47,115.14 108.37,115.23 108.02,115.23 107.84,115.06 107.84,114.88 108.03,114.69 109.55,114.69 109.7,114.53 109.7,113.55 110.12,113.13 110.12,112.12 110.99,111.25 115.43,111.25
M_A_CA_0_9: length 23.5
  IN2 w0.06: 115.66,113.18 115.97,113.18 115.97,113.17 116.26,112.88 116.26,111.46 116.77,110.95 117.52,110.95 v2(117.56,110.91)
  IN2 w0.076: 115.66,113.18 115.58,113.25 115.48,113.25 115.33,113.11 115.22,113.11 115.11,113.21 115.11,113.32 115.26,113.47 115.26,113.58 115.16,113.67 115.06,113.67 114.52,113.13 114.41,113.13 114.3,113.24 114.3,113.35 114.84,113.89 114.84,114 114.76,114.07 114.65,114.07 114.14,113.56 114.03,113.56 113.92,113.67 113.92,113.77 114.44,114.29 114.44,114.4 114.36,114.47 114.26,114.47 113.68,113.89 113.57,113.89 112.46,115 112.46,115.11 112.55,115.19 112.65,115.19 113.52,114.32 113.68,114.32 114.04,114.69 114.04,114.8 113.88,114.95 113.88,115.74 113.76,115.87 113.64,115.87 113.57,115.79 113.57,114.97 113.73,114.8 113.73,114.7 113.65,114.62 113.54,114.62 113.26,114.9 113.26,115.18 113.18,115.26 112.89,115.26 112.82,115.34 112.82,115.49 112.89,115.57 113.24,115.57 113.31,115.64 113.31,115.79 113.24,115.87 112.89,115.87 112.25,115.23 111.39,115.23 111.23,115.39 111.03,115.39 110.88,115.23 110.54,115.23 110.53,115.24 110.5,115.24 110.2,115.53 110.01,115.53 109.64,115.9 v2(109.64,115.95)
M_A_CA_1_0: length 18.3
  IN1 w0.06: v1(118,111.57) 116.83,111.57 116.75,111.49 116.75,111.4 116.68,111.32 116.52,111.32
  IN1 w0.061: 116.52,111.32 115.4,111.32 115.24,111.47 113.65,111.47 113.25,111.88 112.84,111.88 112.64,112.08 112.49,112.08 112.33,112.24 112.33,112.64 112.03,112.95 112.03,113.66 112.23,113.86 113.02,113.86 113.1,113.94 113.1,114.17 112.99,114.27 111.88,114.27 111.75,114.14 111.75,113.61 111.68,113.54 111.68,113.43 111.87,113.25 111.87,113.14 111.76,113.03 111.65,113.03 111.47,113.22 111.36,113.22 111.19,113.05 111.19,112.81 111.31,112.69 111.92,112.69 112,112.62 112,112.46 111.92,112.39 111.19,112.39 111.08,112.27 109.45,112.27 109.34,112.39 109.34,112.78 109.36,112.81 109.36,113.63 109.14,113.86 v1(109.14,113.95)
M_A_CA_1_1: length 17.3
  IN1 w0.061: v1(109.14,114.45) 109.54,114.05 109.54,113.43 109.92,113.05 110.18,113.05 110.25,112.97 110.25,112.77 110.33,112.69 110.48,112.69 110.56,112.77 110.56,112.97 110.64,113.05 110.91,113.05 111.57,113.71 111.57,114.24 111.77,114.45 113.12,114.45 113.3,114.27 113.3,113.84 113.16,113.7 112.32,113.7 112.21,113.58 112.21,113.07 112.46,112.82 112.78,112.82 112.85,112.74 112.85,112.66 112.78,112.58 112.59,112.58 112.51,112.51 112.51,112.36 112.59,112.28 112.78,112.28 112.85,112.2 112.85,112.18 112.93,112.11 113.04,112.11 113.11,112.18 113.11,112.7 113.23,112.82 113.32,112.82 113.5,112.64 113.5,112.46 113.6,112.36 113.62,112.36 113.69,112.29 113.69,112.08 113.77,112.01 113.92,112.01 114.04,112.12 114.04,112.69 114.17,112.82 114.39,112.82 115.49,111.72 116.07,111.72 116.14,111.79 v1(117.23,111.79)
M_A_CA_1_2: length 17.9
  IN1 w0.06: 116.52,111.16 117.3,111.16 117.31,111.16 117.51,111.36 v1(117.66,111.36)
  IN1 w0.061: 116.52,111.16 113.25,111.16 113.17,111.23 113.17,111.58 113.1,111.65 112.94,111.65 112.87,111.58 112.87,111.23 112.79,111.16 112.64,111.16 112.56,111.23 112.56,111.58 112.49,111.65 112.34,111.65 112.26,111.58 112.26,111.23 112.18,111.16 112.03,111.16 111.95,111.23 111.95,111.88 111.88,111.96 111.73,111.96 111.65,111.88 111.65,111.23 111.57,111.16 111.42,111.16 111.34,111.23 111.34,111.88 111.27,111.96 111.12,111.96 111.04,111.88 111.04,111.23 110.96,111.16 110.81,111.16 110.73,111.23 110.73,111.88 110.66,111.96 110.51,111.96 110.43,111.88 110.43,111.23 110.35,111.16 110.19,111.16 109.6,111.74 108.85,112.49 108.85,113.58 108.91,113.64 108.91,114.58 109.14,114.81 v1(109.14,114.95)
M_A_CA_1_3: length 15.2
  IN1 w0.06: v1(117.81,108.65) 118.02,108.65 118.25,108.89 118.25,108.97 118.5,109.22 118.5,109.38 118.5,109.39 118.5,109.4 118.47,109.42 118.41,109.47 118.35,109.54 118.35,109.7 118.5,109.86 118.5,109.86 118.5,110.25 118.58,110.33 118.58,110.49 118.46,110.61 118.46,110.61 118.38,110.69 118.31,110.69 118.18,110.82 118.18,110.84 118.07,110.95 118.03,110.95 118.03,110.95 117.86,110.95 117.86,110.95 117.8,110.95 117.64,111.11 117.48,111.11 117.36,110.99 117.36,110.92 117.07,110.62 116.73,110.62 116.52,110.83
  IN1 w0.061: 116.52,110.83 115.83,110.83 115.68,110.99 110.02,110.99 108.64,112.38 v1(108.64,113.95)
M_A_CA_1_4: length 18.9
  IN1 w0.061: v18(109.58,112.5) 110.72,112.5 v18(110.91,112.69) ; v1(117.23,112.22) 115.52,112.22 114.52,113.23 112.65,113.23 v18(112.63,113.25)
  IN2 w0.076: v18(109.58,112.5) 109.58,112.25 109.69,112.13 109.84,112.13 109.95,112.24 109.95,112.59 109.79,112.74 109.46,112.74 109.34,112.62 109.23,112.62 109.11,112.74 109.11,112.85 109.26,113 109.72,113 109.77,113.05 109.77,113.23 109.55,113.45 109.55,114.33 109.43,114.45 109.22,114.45 109.11,114.35 109.11,114.24 109.18,114.17 109.26,114.17 109.34,114.1 109.34,113.94 109.26,113.87 109.13,113.87 109.06,113.79 109.06,113.64 109.13,113.56 109.26,113.56 109.34,113.49 109.34,113.33 109.25,113.25 108.84,113.25 108.78,113.31 108.78,114.31 v2(108.64,114.45) ; v18(110.91,112.69) 112.48,112.69 113.07,113.28 113.07,113.54 112.68,113.94 112.46,113.94 112.31,113.79 112.31,113.57 v18(112.63,113.25)
M_A_CA_1_5: length 17
  IN1 w0.061: v1(117.56,109.62) 117.18,109.62 116.94,109.86 115.91,109.86 115.84,109.94 115.84,110.15 115.76,110.23 115.61,110.23 115.53,110.15 115.53,109.94 115.46,109.86 115.31,109.86 115.23,109.94 115.23,110.4 115.16,110.48 114.7,110.48 114.62,110.4 114.62,110.3 114.7,110.22 114.85,110.22 114.93,110.14 114.93,109.94 114.85,109.86 114.78,109.86 114.65,110 114.02,110 113.69,110.32 113.69,110.33 113.56,110.46 113.55,110.46 113.53,110.48 112.52,110.48 112.44,110.41 112.44,110.15 112.36,110.08 112.21,110.08 112.13,110.15 112.13,110.41 112.06,110.48 110.86,110.48 110.78,110.41 110.78,110.15 110.71,110.08 110.56,110.08 110.48,110.15 110.48,110.41 110.4,110.48 109.15,110.48 108.74,110.89 108.74,110.89 108.58,111.05 107.76,111.86 107.76,111.87 107.74,111.89 107.74,113.01 107.4,113.35 107.4,113.64 107.18,113.86 107.18,114.41 v1(107.14,114.45)
M_A_CA_1_6: length 20
  IN1 w0.061: v1(117.66,111.79) 117.52,111.79 117.32,112 115.49,112 115.43,112.06 114.46,113.03 112.72,113.03 112.72,113.03 112.53,113.03 112.4,113.16 112.4,113.16 112.38,113.18 112.38,113.43 112.46,113.51 113.35,113.51 113.5,113.66 113.5,114.29 113.15,114.65 111.67,114.65 111.37,114.34 111.37,113.81 110.78,113.23 110,113.23 109.7,113.52 109.7,114.17 109.61,114.26 109.61,114.58 109.39,114.8 109.39,115.07 109.28,115.18 108.99,115.18 108.88,115.08 108.88,114.82 108.77,114.71 108.52,114.71 108.38,114.85 108.38,115.1 108.91,115.64 108.91,116.03 108.76,116.18 108.57,116.18 108.44,116.06 108.44,115.69 108.31,115.56 108.06,115.56 107.45,114.95 v1(107.14,114.95)
M_A_CA_1_7: length 19.4
  IN1 w0.06: v1(118.01,112.03) 118.01,112.19 117.78,112.42 117.69,112.42 117.39,112.72 116.95,112.72
  IN1 w0.061: v18(106.9,116.6) 106.36,116.06 106.36,115.31 106.19,115.14 106.19,114.39 v1(106.64,113.95) ; 116.95,112.72 115.8,112.72 115.79,112.73 115.78,112.73 115.18,113.33 115.18,113.86 113.53,115.5 113.53,115.75 111.78,117.5 111.78,117.78 110.82,118.75 110.15,118.75 109.86,119.04 109.86,119.04 109.73,119.18 109.52,119.18 109.36,119.02 109.36,118.85 109.23,118.71 108.38,118.71 v18(106.9,117.23)
  IN2 w0.076: v18(106.9,116.6) v18(106.9,117.23)
M_A_CA_1_8: length 18.8
  IN1 w0.061: v1(106.64,114.45) 106.55,114.45 106.37,114.63 106.37,115.04 106.52,115.19 106.7,115.19 106.87,115.36 106.87,115.59 106.77,115.69 106.69,115.69 106.59,115.79 106.59,116.02 106.78,116.21 107.14,116.21 107.22,116.29 107.22,116.53 107.3,116.6 107.69,116.6 107.74,116.55 107.74,116.41 107.43,116.1 107.43,115.92 107.51,115.84 107.51,115.74 107.55,115.7 107.8,115.7 107.96,115.85 107.96,116.29 108.12,116.46 108.32,116.46 108.37,116.4 108.37,116.25 108.2,116.08 v18(108.2,115.84) ; v1(118.33,112.29) 117.92,112.7 117.61,112.7 117.36,112.95 v18(115.89,112.95)
  IN2 w0.076: v18(108.2,115.84) 108.42,115.84 108.46,115.8 108.59,115.67 108.67,115.67 108.8,115.54 109.29,115.54 109.59,115.23 109.67,115.23 109.67,115.23 109.86,115.23 109.86,115.23 110.23,115.23 110.38,115.08 110.48,115.08 110.48,115.08 110.94,115.08 110.94,115.08 111.91,115.08 112.16,114.82 112.27,114.82 112.28,114.82 112.39,114.82 112.49,114.72 112.49,114.61 112.49,114.6 112.49,114.49 112.6,114.39 112.7,114.39 112.71,114.39 112.82,114.39 112.93,114.29 112.93,114.18 112.92,114.17 112.92,114.06 113.5,113.48 113.5,113.43 113.7,113.23 114.09,113.23 114.37,112.95 v18(115.89,112.95)
M_A_CA_1_9: length 15
  IN1 w0.06: v1(117.31,108.65) 117.31,109.01 117.15,109.18 117.15,109.18 116.98,109.18 116.89,109.08 116.62,109.08 116.57,109.14 116.3,109.14
  IN1 w0.061: 116.3,109.14 116.24,109.2 114.87,109.2 114.7,109.03 114.53,109.03 114.34,109.03 114.34,109.03 114.28,109.03 114.11,109.21 114.11,109.47 113.68,109.9 110.33,109.9 108.33,110.55 108.2,110.68 107.62,111.71 106.9,114.17 106.9,114.58 106.64,114.84 v1(106.64,114.95)
M_A_CK_DDR0_DN: length 13.8
  IN2 w0.06: v2(117.31,109.94) UC1.BC62 117.31,109.94 117.24,109.86 117.19,109.86 117.01,110.05 116.35,110.05 116.24,110.16 116.02,110.16 115.83,109.97 115.75,109.97 115.74,109.99 115.73,109.99
  IN2 w0.091: 115.73,109.99 115.5,109.99 115.49,110 115.45,110.04 115.45,110.04 115.43,110.06 115.43,110.16 115.68,110.42 115.68,110.74 115.5,110.92 115.23,110.92 115.07,110.76 114.89,110.76 114.64,111.01 110.55,111.01 110.33,111.24 110.33,111.35 110.37,111.39 110.37,111.63 110.16,111.84 109.92,111.84 109.88,111.8 109.77,111.8 108.59,112.97 108.59,113.6 108.44,113.76 108.44,113.85 108.56,113.97 108.56,114.08 108.45,114.19 108.34,114.19 108.23,114.07 108.12,114.07 108.03,114.16 107.96,114.23 107.85,114.23 107.64,114.45 v2(107.64,114.45)
M_A_CK_DDR0_DP: length 13.9
  IN2 w0.06: 115.73,109.84 115.74,109.85 115.88,109.85 116.07,110.04 116.19,110.04 116.3,109.93 116.96,109.93 117.14,109.74 117.21,109.74 117.23,109.73 117.4,109.73 117.62,109.94 UC1.BC60 v2(117.81,109.94)
  IN2 w0.091: v2(107.64,113.95) 107.76,114.08 107.9,114.08 108.05,113.92 108.06,113.92 108.07,113.91 108.29,113.7 108.34,113.64 108.41,113.58 108.44,113.54 108.44,112.91 109.71,111.64 109.94,111.64 109.98,111.69 110.1,111.69 110.22,111.57 110.22,111.46 110.17,111.42 110.17,111.18 110.49,110.86 114.58,110.86 114.83,110.61 115.13,110.61 115.3,110.77 115.43,110.77 115.53,110.67 115.53,110.48 115.28,110.23 115.28,110 115.38,109.89 115.39,109.89 115.44,109.84 115.73,109.84
M_A_CK_DDR1_DN: length 20.9
  IN1 w0.06: 115.96,109.68 116.92,109.68 117.1,109.5 117.4,109.5 117.6,109.3 v1(117.81,109.3)
  IN1 w0.069: v1(110.64,116.95) 110.46,116.95 110.21,116.7 108.87,116.7 108.48,117.09 v18(108.24,117.09)
  IN1 w0.076: 115.96,109.68 115.63,109.68 115.54,109.59 114.61,109.59 v18(114.43,109.76)
  IN2 w0.091: v18(114.43,109.76) 114.42,109.76 114.24,109.58 110.15,109.58 107.11,112.62 107.11,113.23 106.64,113.7 106.64,115.8 107.4,116.55 107.4,116.68 108.06,117.34 108.2,117.34 108.26,117.29 108.26,117.12 v18(108.24,117.09)
M_A_CK_DDR1_DP: length 20.9
  IN1 w0.06: 115.96,109.51 115.97,109.53 116.88,109.53 117.04,109.36 117.25,109.36 v1(117.31,109.3)
  IN1 w0.069: v1(110.14,116.95) 110.01,116.83 109.84,116.83 109.78,116.89 109.78,117.14 109.7,117.21 109.55,117.21 109.47,117.14 109.47,116.92 109.38,116.83 108.93,116.83 108.6,117.16 v18(108.6,117.46)
  IN1 w0.076: v18(114.43,109.25) 114.6,109.42 115.61,109.42 115.7,109.51 115.96,109.51
  IN2 w0.091: v18(114.43,109.25) 114.26,109.42 110.09,109.42 106.95,112.56 106.95,113.17 106.49,113.63 106.49,115.86 107.25,116.62 107.25,116.74 108,117.49 108.29,117.49 108.32,117.46 v18(108.6,117.46)
M_A_CKE0: length 23.4
  IN2 w0.06: 116.72,109.61 116.78,109.61 116.9,109.61 116.96,109.55 116.96,109.46 116.9,109.4 116.79,109.4 116.73,109.34 116.73,109.22 116.79,109.16 116.9,109.16 116.96,109.1 116.96,109.1 117.02,109.04 117.14,109.04 117.2,109.1 117.2,109.55 117.26,109.61 117.38,109.61 117.44,109.55 117.44,109.27 117.5,109.21 117.62,109.21 117.68,109.27 117.68,109.55 117.74,109.61 117.85,109.61 117.91,109.55 117.91,109.37 117.97,109.31 118.09,109.31 118.15,109.37 118.15,109.55 118.22,109.62 UC1.BB57 v2(118.55,109.62)
  IN2 w0.076: v2(108.14,114.45) 107.96,114.45 107.73,114.67 107.73,114.68 107.63,114.68 107.55,114.76 107.55,114.98 107.98,115.4 107.98,115.47 107.91,115.54 107.74,115.54 107.35,115.16 107.35,113.91 107.81,113.46 107.92,113.46 108.04,113.58 108.15,113.58 108.26,113.47 108.26,113.36 108.17,113.28 108.08,113.28 108,113.2 108,113.1 110.44,110.66 110.62,110.66 110.7,110.59 110.7,110.51 110.77,110.43 110.93,110.43 111,110.51 111,110.59 111.08,110.66 111.31,110.66 111.39,110.59 111.39,110.28 111.46,110.2 111.62,110.2 111.69,110.28 111.69,110.59 111.77,110.66 111.92,110.66 112,110.59 112,110.28 112.07,110.2 112.23,110.2 112.3,110.28 112.3,110.59 112.38,110.66 112.47,110.66 112.54,110.59 112.54,110.53 112.62,110.46 112.77,110.46 112.85,110.53 112.85,110.59 112.92,110.66 113.02,110.66 113.09,110.59 113.09,110.23 113.17,110.15 113.28,110.15 113.35,110.23 113.35,110.59 113.43,110.66 113.54,110.66 113.61,110.59 113.61,110.41 113.69,110.33 113.84,110.33 113.92,110.41 113.92,110.53 113.99,110.61 114.54,110.61 115,110.16 115,109.78 115.09,109.68 115.94,109.68 116.03,109.77 116.03,109.78 116.1,109.85 116.16,109.85 116.31,109.7 116.62,109.7 116.72,109.61
