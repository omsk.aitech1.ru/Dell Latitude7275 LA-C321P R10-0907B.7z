# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_ON: length 104.4
  TOP w0.119: U33.5 100.39,88.65 100.59,88.84 R134.2 99.63,89.05 v10(99.63,89.06) ; U41.3 140.93,127.66 141,127.73 141,128.15 140.86,128.29 140.53,128.29 140.27,128.03 v2(140.27,127.95) 140.13,127.81 U41.5
  IN1 w0.089: v5(107.91,131) 107.91,130.64 107.23,129.97 103.18,129.97 103.02,129.8 103.02,128.71 101.66,127.35 100.35,127.35 98.96,125.96 98.96,121.69 97.05,119.77 97.05,112.11 96.56,111.62 96.56,106.19 95.79,105.41 95.79,101.83 93.26,99.3 93.26,98.18 92.2,97.12 92.2,93.77 v5(91.14,92.72)
  GND1 w0.119: v5(91.14,92.72) 91.14,91.35 v4(91.07,91.27) ; v10(99.63,89.06) v4(99.63,88.43) ; v5(107.91,131) 107.91,131.31 108.12,131.53 v4(108.12,131.9)
  IN2 w0.084: v4(139.1,125.21) 140.27,126.38 v2(140.27,127.95)
  GND3 w0.119: v4(139.1,125.21) 138.74,125.58 137.26,125.58 136.59,124.9 127.37,124.9 121.88,130.38 120.34,130.38 119.68,131.04 116.69,131.04 116.53,131.2 116.31,131.2 115.79,131.72 108.3,131.72 v4(108.12,131.9)
  IN3 w0.084: v6(96.37,91.16) 96.3,91.16 95.84,91.62 91.41,91.62 v4(91.07,91.27)
  GND4 w0.119: v4(99.63,88.43) v9(99.17,88.43)
  BOTTOM w0.119: v6(96.37,91.16) 96.81,90.72 96.81,89.9 98.38,88.32 99.01,88.32 99.11,88.43 v9(99.17,88.43)
PWR_SW_IN#: length 367.9
  TOP w0.119: R175.2 236.67,131.55 v2(236.67,130.84) 236.09,130.26 C190.1 ; PR307.1 v2(170.02,109.09)
  IN1 w0.089: v3(115.58,132.98) 115.58,133.02 113.2,135.4 110.95,135.4 110.56,135.78 109.76,135.78 109.41,135.43 108.07,135.43 107.46,136.04 105.66,136.04 105.21,135.59 102.28,135.59 101.83,136.04 100.64,136.04 100.05,136.62 93.22,136.62 89.1,132.5 85.98,132.5 85.03,131.56 83.75,131.56 83.29,131.1 80.29,131.1 79.43,130.24 79.43,129.7 79.16,129.43 78.67,129.43 77.65,128.41 75.45,126.21 72.5,126.21 71.56,125.28 70.56,125.28 70.21,124.93 69.44,124.93 69.27,124.76 68.62,124.76 66.6,122.74 66.6,121.99 66.29,121.68 65.77,121.68 64.32,120.23 64.32,120.12 61.42,117.23 61.42,112.65 59.4,110.63 59.4,103.21 58.46,102.26 49.79,102.26 47.57,100.04 45.25,100.04 44.28,99.06 41.4,99.06 39.57,97.23 34.21,97.23 33.88,96.9 32.98,96.9 32.82,97.05 32.25,97.05 31.11,95.91 29.57,95.91 29.26,95.61 28.5,95.61 27.24,94.34 27.24,92.89 25.49,91.14 23.58,91.14 23.38,90.95 14.33,90.95 11.18,87.8 11.18,78 4.26,71.08 4.26,61.69 5.16,60.79 9.95,60.79 10.24,60.5 10.24,59.75 9.19,58.69 9.19,58.07 9,57.88 9,57.62 8.83,57.45 v1(8.83,56.99) ; v3(148.44,126.75) 148.44,129.07 149.93,130.55 159.35,130.55 159.59,130.79 161.53,130.79 v3(161.78,130.54) 162.61,129.71 166.69,129.71 166.86,129.89 167.37,129.89 167.6,130.12 171.22,130.12 172.49,128.85 173.14,128.85 173.69,128.31 175.98,128.31 176.08,128.41 177.04,128.41 177.27,128.18 177.27,127.76 178.82,126.22 178.82,122.45 178.92,122.35 182.43,122.35 183.04,122.97 183.04,123.62 183.51,124.08 184.83,124.08 186.75,126.01 186.75,127.62 188.39,129.26 189.59,129.26 192.16,131.82 193.49,131.82 193.86,132.19 195.87,132.19 196.05,132.37 202.4,132.37 204.18,134.15 205.91,134.15 206.71,134.95 206.71,135.04 207.35,135.68 207.35,137.45 207.71,137.82 208.74,137.82 208.91,137.98 209.82,137.98 210.63,138.79 213.84,138.79 214.3,138.33 215.81,138.33 216.21,138.74 220.61,138.74 220.87,138.48 222.99,138.48 223.23,138.25 229.43,138.25 229.84,137.84 230.07,137.84 231.39,136.52 232.25,136.52 232.93,135.85 233.73,135.85 234.02,135.56 234.02,133.31 v3(234.49,132.84) ; v1(234.81,126.25) 234.81,127.47 236.38,129.04 236.38,130.55 v2(236.67,130.84)
  IN2 w0.084: v4(116.87,131.9) 116.28,132.49 115.88,132.49 115.58,132.8 v3(115.58,132.98) ; v4(161.03,130.34) 161.16,130.34 161.36,130.54 v3(161.78,130.54) ; v2(170.02,109.09) 169.08,109.09 168.11,110.07 165.11,110.07 164.81,109.76 164.11,109.76 164.09,109.78 163.41,109.78 162.14,111.04 160.91,111.04 v4(160.66,111.29) ; v4(148.57,126.37) 148.57,126.63 v3(148.44,126.75) ; v3(234.49,132.84) 235.11,132.22 235.79,132.22 236.16,131.85 236.16,131.44 236.67,130.92 v2(236.67,130.84)
  GND3 w0.119: v4(148.57,126.37) 148.39,126.2 148.39,125.03 148.01,124.65 147.55,124.65 147.26,124.94 145.97,124.94 145.62,124.59 145.01,124.59 144.43,124 142.28,124 142.08,123.8 141.68,123.8 139.46,126.02 137.08,126.02 136.44,125.38 127.53,125.38 122.09,130.82 120.52,130.82 119.82,131.53 117.24,131.53 116.87,131.89 v4(116.87,131.9)
  IN3 w0.084: v4(161.03,130.34) 160.85,130.34 159.94,129.42 159.6,129.42 158.91,128.73 158.91,126.71 159.62,126 159.62,119.74 160.1,119.25 160.1,113.58 160.26,113.42 160.26,111.69 v4(160.66,111.29)
PWR_TB_DOCK#: length 0.8
  TOP w0.119: R177.1 9.42,56.38 R1440.2
PWRBTN#: length 104.7
  TOP w0.119: R175.1 236.16,132.56 v7(235.72,133) ; SW1.3 SW1.1 203.54,107.9 204.58,108.94 D23.1 204.58,110.1 v1(203.77,110.92)
  IN1 w0.089: v3(227.36,144.2) 226.89,144.67 226.53,144.67 225.7,145.51 217.05,145.51 215.04,143.49 v5(213.44,143.49) ; v1(203.77,110.92) 203.77,111.36 204.75,112.35 206.32,112.35 207.46,113.49 207.46,113.7 208.25,114.49 208.48,114.49 209.68,115.69 209.68,116.43 210.17,116.92 211.2,116.92 213.61,119.33 214.5,119.33 215.42,120.25 216.78,120.25 v7(218.04,121.51)
  GND1 w0.119: v4(213.44,142.98) v5(213.44,143.49)
  IN2 w0.084: v3(227.36,144.2) 228.82,144.2 230.77,142.25 233.14,142.25 233.46,141.92 v4(233.78,141.92) 234.09,142.24 249.52,142.24 250.7,141.06 v2(250.7,138.85)
  IN3 w0.076: v7(235.72,133) 235.92,133.2 235.92,138.81 233.9,140.83 233.9,141.79 v4(233.78,141.92)
  IN3 w0.084: v4(213.44,142.98) 213.86,142.57 213.86,138.74 215.74,136.86 215.74,131.93 216.81,130.86 216.81,126.36 218.22,124.95 218.22,121.69 v7(218.04,121.51)
PWRBTN#_HW: length 83.1
  TOP w0.119: v1(243.52,132.33) 242.53,132.33 242.3,132.1 240.77,132.1 240.45,131.78 U715.4
  IN1 w0.089: v5(213.95,142.54) 215.41,142.54 216.91,144.04 219.02,144.04 219.46,144.48 225.4,144.48 226.15,143.73 226.96,143.73 228.34,142.36 229.76,142.36 231.22,140.89 233.22,140.89 234.02,140.1 236.33,140.1 236.49,139.94 236.49,139.25 238.64,137.1 239.3,137.1 243.52,132.89 v1(243.52,132.33) ; v1(204.58,111.62) 204.58,111.8 204.93,112.16 206.4,112.16 207.65,113.41 207.65,113.62 208.33,114.3 208.55,114.3 209.87,115.61 209.87,116.36 210.25,116.73 211.28,116.73 212.98,118.43 213.83,118.43 214.02,118.63 214.1,118.63 215.54,120.06 217.81,120.06 218.73,120.98 v7(218.73,121.51)
  GND1 w0.119: v5(213.95,142.54) v4(213.95,143)
  IN3 w0.084: v7(218.73,121.51) 218.73,122.21 218.41,122.53 218.41,125.03 217,126.44 217,130.94 215.93,132.01 215.93,136.94 214.05,138.82 214.05,142.9 v4(213.95,143)
PWRGD_XDP: length 6.1
  TOP w0.119: RC29.2 122.84,92.41 122.36,91.93 118.27,91.93 v10(118.19,92.01)
  GND1 w0.119: v4(117.91,91.64) 117.91,91.73 v10(118.19,92.01)
  GND4 w0.119: v4(117.91,91.64) 117.71,91.64 v9(117.55,91.8)
PWRPATH _DD: length 90.1
  TOP w0.119: PQ212.3 175.47,107.92 PR250.2 173.55,109.84 v1(173.49,109.84) ; U27.N2 227.76,128.29 v10(227.7,128.29)
  IN1 w0.089: v5(222.59,137.37) 221.97,137.37 221.74,137.14 212.85,137.14 212.37,137.62 211.76,137.62 211.54,137.4 211.54,137.17 211.26,136.89 211.26,135.97 210.86,135.57 210.86,135.35 208.02,132.51 206.5,130.99 205.94,130.99 204.2,129.25 203.17,129.25 202.29,128.37 201.22,128.37 201.09,128.23 198.06,128.23 197.2,127.38 194.98,127.38 193.71,126.11 191.84,126.11 190.06,124.33 188.65,124.33 186.87,122.54 186.87,120.88 184.93,118.94 184.93,118.46 184.72,118.24 184.21,118.24 183.71,118.75 178.19,118.75 176.76,117.32 176.76,113.35 178.3,111.82 178.3,110.42 177.14,109.26 176.31,109.26 176.12,109.07 174.26,109.07 v1(173.49,109.84)
  GND1 w0.119: v5(222.59,137.37) 223.17,137.37 v4(223.23,137.43) ; v4(228.07,128.13) 227.91,128.29 v10(227.7,128.29)
  IN3 w0.084: v4(223.23,137.43) 225.28,137.43 228.23,134.48 228.23,131.88 228.45,131.66 228.45,128.5 v4(228.07,128.13)
PWRPATH_S1#: length 252.4
  TOP w0.119: PR247.2 61.77,142.69 61.31,142.22 61.31,141.68 61.94,141.05 v1(62.03,141.05) 62.17,140.91 62.17,140.17 62.44,139.9 PU201.1 ; PR248.2 73.56,120.99 73.08,121.47 v1(73.08,121.75)
  IN1 w0.089: v7(238.4,129.83) 238.12,129.55 238.12,128.76 236.57,127.21 236.57,125.84 236.73,125.67 236.73,125.29 236.43,124.99 235.54,124.99 235.04,124.49 234.55,124.49 v1(234.31,124.25) ; v1(62.03,141.05) 62.29,141.31 65.36,141.31 65.84,141.79 65.84,141.92 66.5,142.58 66.83,142.58 67.8,143.55 v5(67.91,143.55) ; v1(73.08,121.75) 73.16,121.75 74.71,123.31 76.1,123.31 76.43,123.64 77.31,123.64 81.04,127.37 85.47,127.37 v8(85.99,127.88) ; v3(146.87,114.97) 146.96,114.88 147.27,114.88 149.57,112.58 151.16,112.58 153.26,110.48 162.3,110.48 162.97,109.81 162.97,107.75 163.36,107.36 166.03,107.36 167.06,106.34 168.35,106.34 168.74,105.95 168.74,105.23 169.56,104.4 178.81,104.4 179.01,104.6 186.42,104.6 187.92,106.1 188.38,106.1 189.46,107.17 189.46,108.6 190.37,109.51 190.37,110.91 195.89,116.43 195.89,119.43 197.87,121.41 200.34,121.41 200.67,121.74 201.96,121.74 202.71,122.49 203.35,122.49 203.66,122.8 203.66,123.27 203.89,123.5 204.35,123.5 205.08,124.23 206.4,124.23 207.08,124.91 208.37,124.91 215.52,132.05 223.24,132.05 225.11,133.93 v5(225.53,133.93)
  GND1 w0.119: v5(67.91,143.55) v4(68.34,143.55) ; v8(85.99,127.88) 85.99,128.26 85.98,128.26 v4(86.2,128.49) ; v5(225.53,133.93) 226.23,133.93 v4(226.31,133.85)
  IN2 w0.084: v3(146.87,114.97) 146.87,114.78 v4(146.66,114.56)
  GND3 w0.119: v4(146.66,114.56) 145.35,113.25 141.28,113.25 140.96,113.58 139.46,113.58 138.99,113.1 138.26,113.1 137.36,114 135.23,114 134.92,113.69 121.63,113.69 117.01,118.31 113.83,118.31 112.93,119.21 112.3,119.21 111.16,120.35 101.68,120.35 98.71,123.33 97.11,123.33 95.08,125.36 90.24,125.36 87.73,127.87 86.82,127.87 v4(86.2,128.49)
  GND4 w0.119: v9(226.63,134.22) 226.63,134.17 v4(226.31,133.85) ; v4(86.2,128.49) 86.08,128.49 v9(85.83,128.74) ; v4(68.34,143.55) v9(68.86,143.55)
  BOTTOM w0.119: v7(238.4,129.83) 238.78,130.21 238.78,133.33 238.19,133.92 235.53,133.92 234.82,134.63 232.83,134.63 231.92,135.53 230.97,135.53 230.2,134.76 227.16,134.76 v9(226.63,134.22) ; v9(85.83,128.74) 83.06,128.74 80.03,131.77 80.03,132.01 79.66,132.38 79.66,134.13 76.26,137.54 76.26,141.57 74.26,143.57 68.88,143.57 v9(68.86,143.55)
PWRPATH_S3#: length 224.4
  TOP w0.119: PU203.2 59.85,145.96 PR237.2 60.65,146.24 v7(60.71,146.17)
  IN1 w0.06: 234.68,125.98 234.55,125.85 234.55,125.8 234.05,125.3 234.05,125 v1(234.31,124.75)
  IN1 w0.089: 234.68,125.98 234.92,125.98 235.03,126.09 235.03,127.4 236.75,129.12 v5(236.81,129.12) ; v3(232.97,141.21) 231.17,141.21 229.67,142.71 229.37,142.71 228.86,143.22 228.13,143.22 227.73,143.62 227.73,144.27 227.11,144.89 227.11,145.65 226.14,146.62 225.26,146.62 224.73,146.1 215.81,146.1 213.94,144.23 212.33,144.23 212.13,144.03 207.82,144.03 205.89,145.96 203.23,145.96 202.53,146.66 196.87,146.66 196.59,146.95 188.42,146.95 188.12,146.64 188.12,141.96 188.8,141.27 188.8,138.32 188.39,137.91 173.81,137.91 173.64,138.08 162.08,138.08 161.98,137.98 159.43,137.98 159.33,138.09 154.57,138.09 153.07,136.58 v5(152.18,136.58)
  GND1 w0.119: v4(236.81,129.5) v5(236.81,129.12) ; v4(151.85,136.84) 151.92,136.84 v5(152.18,136.58)
  IN2 w0.084: v3(232.97,141.21) 233.48,140.7 v4(233.48,140.44)
  IN3 w0.084: v4(236.81,129.5) 236.18,129.5 235.85,129.83 235.85,130.23 234.97,131.11 234.97,138.67 234.61,139.03 234.61,139.32 v4(233.48,140.44) ; v4(151.85,136.84) 151.51,136.5 148.23,136.5 148.02,136.3 144.65,136.3 142.8,134.46 142.33,133.99 142.25,133.99 141.81,133.56 141.81,132.79 139.91,130.89 137.65,130.89 136.8,130.04 129.47,130.04 128.58,130.93 128.58,131.74 129.56,132.72 129.56,133.23 129.39,133.4 126.65,133.4 125.1,134.95 123.58,134.95 122.36,136.17 115.99,136.17 115.84,136.03 115.5,136.03 114.16,137.36 103.06,137.36 102.26,136.55 97.56,136.55 97.47,136.46 v6(97.47,136.47) ; v7(60.71,146.17) 61.37,146.17 64.22,143.33 64.22,142.04 69.33,136.92 79.26,136.92 79.65,136.53 v6(80.19,136.53)
  BOTTOM w0.119: v6(80.19,136.53) 80.65,136.99 92.19,136.99 92.79,136.38 97.38,136.38 v6(97.47,136.47)
PWRPATH_S6: length 230.2
  TOP w0.119: v2(60.85,140.55) 60.46,140.55 60.28,140.37 PQ205.2 ; v7(61.98,134.86) 61.98,134.59 PR246.1 61.39,134.48 61.39,134.97 62.19,135.77 62.19,136.61 62.39,136.81 PU205.2
  IN1 w0.089: v3(227.18,119.21) 227.32,119.07 227.32,118.89 227.97,118.25 228.81,118.25 229.17,118.61 229.41,118.61 230.17,119.37 230.17,119.84 230.31,119.98 230.53,119.98 230.63,120.09 230.63,120.65 231.04,121.06 231.04,121.85 231.07,121.88 231.07,122.36 231.31,122.6 v1(231.31,122.75)
  IN2 w0.084: v4(99.01,134.88) 99.01,135.41 98.41,136.01 92.64,136.01 92.46,136.18 91.08,136.18 90.75,136.52 89.4,136.52 88.55,135.67 85.33,135.67 84.91,136.09 v4(84.07,136.09) ; v4(220.73,140.13) 220.55,140.13 220.35,139.93 216.67,139.93 216.49,140.11 214.24,140.11 213.24,139.11 207.23,139.11 206.66,139.67 205.22,139.67 201.39,135.84 197.57,135.84 196.34,134.61 196.34,133.11 195.56,132.32 194.87,132.32 193.96,131.41 193,131.41 191.34,129.76 191.34,126.41 189.03,124.1 185.68,124.1 185.04,123.45 183.17,123.45 182.22,122.51 179.06,122.51 178.97,122.59 178.97,123.07 178.65,123.39 178.65,124.7 177.62,125.73 177.62,126.74 177.22,127.14 176.91,127.14 176.44,127.61 172.27,127.61 171.24,128.64 167.4,128.64 167.29,128.53 162.14,128.53 161.99,128.38 161.31,128.38 160.66,127.74 159.85,127.74 159.06,126.95 153.95,126.95 152.97,127.93 150.25,127.93 150.07,127.74 147.56,127.74 147.05,127.24 147.05,126.86 145.44,125.25 139.63,125.25 139.25,124.87 138.47,124.87 v4(138.05,124.45) ; v4(226.36,121.09) 227.18,120.26 v3(227.18,119.21) ; v7(61.98,134.86) 61.98,135.24 62.24,135.49 62.24,138.31 61.25,139.3 61.25,140.15 v2(60.85,140.55)
  GND3 w0.119: v4(99.01,134.88) 99.34,134.88 100.49,133.73 101.07,133.73 101.63,133.17 105.99,133.17 107.75,131.4 111.01,131.4 111.12,131.3 115.04,131.3 115.6,130.74 116.31,130.74 116.46,130.6 119.5,130.6 120.88,129.22 122.41,129.22 127.18,124.44 136.76,124.44 137.08,124.77 137.73,124.77 v4(138.05,124.45)
  IN3 w0.084: v4(84.07,136.09) 82.91,136.09 82.7,135.89 79.5,135.89 78.87,136.52 63.65,136.52 v7(61.98,134.86) ; v4(226.36,121.09) 226.75,121.48 226.75,123.4 227.31,123.96 227.31,126.2 228.82,127.71 228.82,131.85 228.68,131.99 228.68,134.56 225.35,137.88 224.96,137.88 224.23,138.62 222.92,138.62 222.23,139.3 221.56,139.3 v4(220.73,140.13)
REG5: length 33.4
  TOP w0.254: v10(171.86,125.08) 171.86,125.59 172.12,125.84 PC607.1 172.12,126.11 v1(171.67,126.55) ; v1(163.28,124.04) 163.23,123.99 163.23,122.72 162.85,122.33 PC634.1 PC617.1 PC500.1 ; v1(172.09,127.52) 172.24,127.67 173.53,127.67 PC708.1 175.49,128.43 175.74,128.67 PC505.1
  IN1 w0.06: v1(167.59,121.6) 167.59,121.34 v5(167.52,121.27) ; v1(168.39,122) 168.39,121.46 v5(168.46,121.39) ; 169.65,127.8 169.65,127.26 168.94,126.55 168.94,126.25 168.99,126.2 168.99,125.8 v1(168.79,125.6) ; 171.81,125.03 171.63,124.85 171.2,124.85 170.95,124.6 170.57,124.6 170.39,124.42 v1(170.39,124.4)
  IN1 w0.089: v1(169.65,127.85) 169.65,127.8 ; 171.81,125.03 v10(171.86,125.08)
  IN1 w0.203: v10(165.99,122.4) 165.31,122.4 ; v1(169.99,125.6) 170.09,125.7 170.22,125.7 ; v1(165.99,124) 165.35,124
  IN1 w0.254: 165.31,122.4 164.95,122.04 163.36,122.04 v1(162.94,122.45) ; 165.35,124 164.75,124 164.45,124.3 163.43,124.3 163.28,124.15 v1(163.28,124.04) ; 170.22,125.7 170.54,125.7 171.39,126.55 v1(171.67,126.55) 171.67,127.13 172.06,127.52 v1(172.09,127.52) 171.3,128.3 170.11,128.3 v1(169.65,127.85)
  GND1 w0.119: v4(166.36,122.51) 166.25,122.4 v10(165.99,122.4) ; v5(168.46,121.39) 168.26,121.39 v4(167.87,121.01) 167.62,121.27 v5(167.52,121.27)
  GND1 w0.254: v4(171.43,124.62) 171.86,125.05 v10(171.86,125.08)
  IN3 w0.254: v4(167.87,121.01) 166.71,122.18 166.68,122.18 166.35,122.51 v4(166.36,122.51)
  GND4 w0.119: v4(167.87,121.01) v9(167.39,121.01)
  GND4 w0.254: v9(171.08,124.21) 171.43,124.57 v4(171.43,124.62)
REG33: length 54.6
  TOP w0.127: v1(169.99,123.2) PU500.K11
  TOP w0.152: PU500.K11 v1(169.59,122.4)
  TOP w0.254: v1(175.79,121.18) 175.79,121.1 PC711.1 ; PR735.1 174.02,110.26 v7(174.02,111.01) 174,111.03 173.42,111.03 PR734.1 ; PC710.1 172.55,123.13 172.55,123.43 172.24,123.73 172.02,123.73 171.75,124 v1(170.79,124) ; PC706.1 171.94,120.23 171.46,120.71 v10(171.46,121.29) ; PC704.1 PC707.1 v2(163.3,127.47) ; PU500.C3 v2(166.39,125.2) ; v10(164.85,120.81) 164.83,120.79 164.14,120.79 163.28,119.92 PC702.1
  IN1 w0.06: v10(164.85,120.81) 165.44,121.4 166.12,121.4 166.38,121.66 166.38,121.99 v10(166.39,122) ; v10(171.46,121.29) 170.95,121.8 170.19,121.8 v1(169.99,122) 169.99,122.12 169.71,122.4 v1(169.59,122.4) ; v1(169.99,123.2) 170.19,123.4 170.19,123.76 170.26,123.83 170.62,123.83 v1(170.79,124)
  IN1 w0.254: v1(175.79,121.18) 175.27,121.7 v1(175.27,122.41)
  GND1 w0.254: v4(171.82,121.45) 171.81,121.43 171.8,121.45 171.61,121.45 v10(171.46,121.29) ; v4(165.23,120.73) 164.93,120.73 v10(164.85,120.81)
  IN2 w0.254: v2(166.39,125.2) 166.23,125.2 164.83,126.6 164.17,126.6 ; 164.17,126.6 163.96,126.6 163.66,126.3 163.66,125.95 v4(163.7,125.91) ; 164.17,126.6 v2(163.3,127.47)
  IN3 w0.254: v4(163.7,125.91) 164.15,125.46 164.7,125.46 165.25,124.91 v6(165.25,123.21) 165.25,121.89 165.56,121.57 165.56,121.06 v4(165.23,120.73)
  GND4 w0.254: v4(171.82,121.45) 171.81,121.43 171.81,121.14 v9(171.56,120.89)
  BOTTOM w0.254: v7(174.02,111.01) 174.24,111.22 174.24,112.54 171.56,115.22 v9(171.56,120.89) 171.91,121.24 171.91,124.02 171.15,124.79 166.82,124.79 v6(165.25,123.21)
REM_DIODE1_N: length 190.5
  TOP w0.119: v2(111.87,126.5) 111.87,126.25 112.55,125.56 C204.2 113.64,125.56 Q27.3 ; U27.E13 233.75,120.69 233.75,120.36 v2(233.85,120.26) 233.78,120.19 233.78,119.14 234.07,118.85 C191.2 234.07,117.64 234.21,117.5 234.21,115.39 233.51,114.69 224.09,114.69 223.58,115.2 223.58,116.3 C209.1 223.64,117.07 Q30.2 224.29,118.59 Q30.1
  IN1 w0.089: v3(164.71,111.36) 164.8,111.26 165.02,111.26 166.57,109.71 166.57,109.21 167.85,107.93 168.77,107.93 170.4,106.29 172.5,106.29 172.81,105.98 173.93,105.98 174.27,105.64 178.31,105.64 178.5,105.83 185.79,105.83 187.35,107.39 187.35,108.23 189.1,109.98 189.1,111.38 194.44,116.73 194.44,120.58 195.17,121.3 195.17,121.42 195.91,122.16 196.89,122.16 197.4,122.68 199.12,122.68 199.27,122.82 199.88,122.82 201.04,123.99 202.03,123.99 202.36,124.32 202.97,124.32 203.38,124.73 203.82,124.73 204.55,125.47 205.89,125.47 207.21,126.78 208.06,126.78 v3(208.36,126.47) ; v3(148.53,116.84) 148.53,116.98 148.13,117.38 146.84,117.38 146.39,117.83 144.43,117.83 143.9,117.3 143.21,117.3 142.82,117.69 142.82,118.2 143.07,118.45 143.07,119.53 143.48,119.95 143.48,120.71 145,122.22 145,123.07 144.75,123.31 v3(144.72,123.31)
  IN2 w0.084: v3(148.53,116.84) 148.53,116.5 149.82,115.21 150.2,115.21 153.57,111.84 163.19,111.84 163.76,111.27 164.62,111.27 v3(164.71,111.36) ; v4(139.36,122.74) 141.27,122.74 141.52,122.98 143.62,122.98 143.95,123.31 v3(144.72,123.31) ; v4(118.8,128.74) 118.34,128.74 116.34,126.75 112.11,126.75 v2(111.87,126.5) ; v3(208.36,126.47) 208.93,127.04 211.33,127.04 211.47,126.9 212.9,126.9 214.67,125.13 216.81,125.13 217.24,125.57 219.96,125.57 220.44,125.09 222.42,125.09 222.98,124.53 224.04,124.53 224.66,125.14 226.24,125.14 228.54,122.84 229.01,122.84 229.39,122.46 229.39,121.81 229.71,121.5 232.28,121.5 233.25,120.53 233.59,120.53 v2(233.85,120.26)
  IN3 w0.084: v4(118.8,128.74) 118.96,128.58 121.58,128.58 125.17,125 125.17,120.43 126.06,119.53 133.19,119.53 135.74,116.98 136.47,116.98 136.8,117.32 136.8,120.57 138.97,122.74 v4(139.36,122.74)
REM_DIODE1_P: length 187.5
  TOP w0.119: Q27.1 114.36,126.14 Q27.2 113.39,126.47 v2(112.6,126.47) ; U27.F13 233.31,120.73 233.47,120.57 v2(233.47,120.24) 233.55,120.16 233.55,119.2 233.15,118.8 C191.1 233.19,118.78 233.84,118.13 233.84,117.55 233.99,117.4 233.99,115.48 233.42,114.91 224.18,114.91 223.8,115.29 223.8,116.32 C209.2 224.94,117.46 Q30.3
  IN1 w0.089: v3(144.72,122.96) 144.73,122.95 144.73,122.22 143.29,120.79 143.29,120.03 142.88,119.61 142.88,118.53 142.62,118.28 142.62,117.61 143.13,117.11 143.98,117.11 144.51,117.64 146.31,117.64 146.76,117.19 147.99,117.19 148.18,117 v3(148.18,116.81) ; v3(164.71,111) 164.78,111.07 164.94,111.07 166.38,109.63 166.38,109.13 167.77,107.74 168.69,107.74 170.32,106.1 172.42,106.1 172.73,105.79 173.85,105.79 174.2,105.44 178.38,105.44 178.58,105.64 185.88,105.64 187.55,107.32 187.55,108.17 189.3,109.91 189.3,111.31 194.67,116.69 194.67,120.54 195.36,121.22 195.36,121.34 195.99,121.97 196.96,121.97 197.48,122.49 199.2,122.49 199.35,122.63 199.95,122.63 201.1,123.78 202.09,123.78 202.44,124.13 203.05,124.13 203.46,124.54 203.9,124.54 204.63,125.27 205.97,125.27 207.29,126.59 207.84,126.59 v3(207.96,126.47)
  IN2 w0.084: v3(207.96,126.47) 207.98,126.47 208.27,126.18 208.45,126.18 209.13,126.86 211.25,126.86 211.4,126.71 212.83,126.71 214.6,124.94 216.88,124.94 217.32,125.38 219.88,125.38 220.36,124.9 222.34,124.9 222.9,124.34 224.12,124.34 224.73,124.96 226.16,124.96 228.46,122.66 228.94,122.66 229.21,122.38 229.21,121.74 229.63,121.31 232.2,121.31 233.17,120.34 233.37,120.34 v2(233.47,120.24) ; v4(139.15,122.28) 139.39,122.28 139.67,122.56 141.35,122.56 141.59,122.8 143.74,122.8 143.9,122.96 v3(144.72,122.96) ; v2(112.6,126.47) 116.33,126.47 117.97,128.11 118.19,128.33 v4(118.42,128.33) ; v3(148.18,116.81) 148.18,116.59 149.75,115.02 150.12,115.02 153.49,111.65 163.11,111.65 163.68,111.08 164.63,111.08 v3(164.71,111)
  IN3 w0.084: v4(118.42,128.33) 118.48,128.39 121.51,128.39 124.98,124.92 124.98,120.35 125.98,119.35 133.12,119.35 135.67,116.8 136.55,116.8 136.99,117.24 136.99,120.5 138.77,122.28 v4(139.15,122.28)
REM_DIODE2_N: length 11
  TOP w0.119: U27.D13 234.5,120.55 234.5,120.14 235.29,119.35 235.29,119.21 C192.2 235.05,118.91 235.94,118.01 235.94,115.81 236.71,115.04 240.41,115.04 R5761.2
REM_DIODE2_N_R: length 415.7
  TOP w0.119: v2(19.11,19.85) 18.79,19.53 Q28.2 18.79,17.79 Q28.1 ; R5761.1 241.86,115.08 242.33,115.08 v1(242.46,114.94)
  IN1 w0.089: v3(122.7,136.99) 122.78,136.91 122.78,135.59 125.11,133.26 126.78,133.26 127.45,132.59 129.32,132.59 129.5,132.77 130.01,132.77 131.66,131.12 132.61,131.12 133.41,130.32 134.57,130.32 136.55,128.34 137.79,128.34 139.22,129.77 139.44,129.77 139.45,129.78 139.72,129.78 v3(139.94,129.99) ; v3(227.16,141.23) 227.32,141.07 227.32,140.97 227.78,140.51 229.86,140.51 230.74,139.63 232.72,139.63 234.03,138.32 234.2,138.32 235.07,137.46 236.14,137.46 237.74,135.86 237.74,135.05 239.13,133.65 239.13,132.73 243.11,128.75 243.85,128.75 246.79,125.8 246.79,116.18 246.15,115.53 242.9,115.53 242.6,115.23 242.6,115.08 v1(242.46,114.94)
  IN2 w0.084: v2(19.11,19.85) 18.79,19.53 18.09,19.53 17.74,19.88 17.74,21.04 15.18,23.59 15.18,25.65 11.86,28.98 11.86,30.6 11.33,31.13 11.33,35.73 10.44,36.62 10.44,41.44 4.78,47.1 4.78,58.61 3.99,59.39 3.99,71.23 9.21,76.45 9.21,79.82 10.17,80.77 10.17,87.36 v4(9.91,87.61) ; v3(227.16,141.23) 226.99,141.4 218.95,141.4 218.95,141.4 218.79,141.4 217.98,142.22 212.5,142.22 211.75,142.96 204.24,142.96 204.02,143.19 201.28,143.19 200.91,142.81 197.78,142.81 196.48,141.51 196.48,140.53 194.86,138.91 194.14,138.91 188.53,133.31 185.03,133.31 184.17,132.45 178.51,132.45 178.39,132.33 163.65,132.33 163.41,132.09 160.9,132.09 158.3,129.49 154.83,129.49 154.1,130.21 151.09,130.21 150.59,130.72 148.14,130.72 146.5,129.07 144.48,129.07 143.95,129.6 141.72,129.6 141.23,130.09 140.03,130.09 v3(139.94,129.99) ; v4(51.81,148.36) 52.22,147.94 57.33,147.94 58.26,148.88 71.53,148.88 76.77,143.64 76.77,140.94 80.02,137.69 102.96,137.69 103.86,136.79 108.9,136.79 110.08,137.97 122.18,137.97 122.76,137.38 122.76,137.05 v3(122.7,136.99)
  IN3 w0.084: v4(9.91,87.61) 9.63,87.61 8.19,89.06 8.19,91.08 9.21,92.1 9.21,97.38 15.69,103.86 31.49,103.86 32.33,103.03 34.91,103.03 36,104.12 36,104.42 37.07,105.48 37.07,108.72 38.44,110.09 39.12,110.09 40.1,111.07 40.1,111.74 40.63,112.26 40.63,126.42 41.09,126.88 41.09,127.37 40.78,127.69 40.78,139.25 46.16,144.63 48.86,144.63 51.98,147.75 51.98,148.19 v4(51.81,148.36)
REM_DIODE2_P: length 10.4
  TOP w0.119: R5762.2 240.25,115.26 236.81,115.26 236.16,115.9 236.16,118.17 235.9,118.43 C192.1 235.51,119.29 235.51,119.44 234.72,120.23 234.72,120.66 U27.C13
REM_DIODE2_P_R: length 413.3
  TOP w0.119: v2(18.19,19.85) 17.49,19.14 Q28.3 ; R5762.1 241.94,115.3 242.51,115.3 v1(242.89,114.92)
  IN1 w0.089: v1(242.89,114.92) 242.79,115.02 242.79,115.15 242.98,115.34 246.22,115.34 246.98,116.1 246.98,125.88 243.93,128.94 243.19,128.94 239.33,132.81 239.33,133.73 237.93,135.13 237.93,135.94 236.22,137.65 235.15,137.65 234.28,138.51 234.11,138.51 232.8,139.82 230.82,139.82 229.94,140.7 227.86,140.7 227.51,141.05 227.51,141.35 v3(227.5,141.36) ; v3(123.08,137) 122.97,136.89 122.97,135.66 125.19,133.45 126.86,133.45 127.53,132.78 129.24,132.78 129.42,132.97 130.09,132.97 131.74,131.31 132.69,131.31 133.49,130.51 134.65,130.51 136.63,128.53 137.71,128.53 139.14,129.96 139.36,129.96 139.46,130.06 v3(139.57,130.06)
  IN2 w0.084: v2(18.19,19.85) 17.92,20.12 17.92,21.12 15.37,23.67 15.37,25.73 12.04,29.06 12.04,30.68 11.51,31.21 11.51,35.81 10.63,36.69 10.63,41.51 4.96,47.18 4.96,58.68 4.18,59.47 4.18,71.15 9.4,76.37 9.4,79.74 10.35,80.7 10.35,87.72 v4(10.45,87.82) ; v4(52.32,148.38) 52.57,148.13 57.25,148.13 58.18,149.06 71.61,149.06 76.96,143.71 76.96,141.01 80.1,137.87 103.04,137.87 103.94,136.97 108.82,136.97 110,138.15 122.26,138.15 122.95,137.46 122.95,137.14 v3(123.08,137) ; v3(139.57,130.06) 139.78,130.27 141.31,130.27 141.8,129.78 144.03,129.78 144.56,129.26 146.42,129.26 148.06,130.9 150.67,130.9 151.17,130.4 154.18,130.4 154.9,129.68 158.23,129.68 160.83,132.27 163.34,132.27 163.58,132.51 178.31,132.51 178.43,132.63 184.09,132.63 184.95,133.5 188.46,133.5 194.06,139.1 194.78,139.1 196.29,140.61 196.29,141.58 197.71,143 200.84,143 201.21,143.37 204.1,143.37 204.32,143.15 211.83,143.15 212.57,142.4 218.05,142.4 218.87,141.58 218.88,141.59 227.27,141.59 v3(227.5,141.36)
  IN3 w0.084: v4(52.32,148.38) 52.17,148.23 52.17,147.67 48.94,144.45 46.23,144.45 40.96,139.17 40.96,127.77 41.28,127.45 41.28,126.81 40.81,126.34 40.81,112.19 40.29,111.66 40.29,110.99 39.2,109.91 38.53,109.91 37.25,108.63 37.25,105.4 36.19,104.34 36.19,104.04 34.99,102.85 32.25,102.85 31.42,103.68 15.77,103.68 9.39,97.3 9.39,92.02 8.37,91 8.37,89.14 9.55,87.96 10.3,87.96 v4(10.45,87.82)
REM_DIODE3_N: length 307.5
  TOP w0.119: Q29.3 92.78,125.54 93.79,125.54 C208.2 95.06,124.86 v1(95.38,125.18) ; Q31.2 36.76,109.59 37.34,109 38.06,109 Q31.1 38.6,108.45 v2(38.6,107.29) ; v1(242.92,116.42) 242.84,116.33 242.53,116.33 242.3,116.56 240.38,116.56 239.83,116.01 237.16,116.01 236.94,116.23 236.94,118.17 C193.2 237.63,118.91 237.17,119.36 236.7,119.36 236.36,119.7 236.36,119.7 235.98,120.08 235.72,120.34 235.72,120.66 U27.A13
  IN1 w0.089: v1(95.38,125.18) 95.38,125.31 v3(98.74,128.67) ; v1(242.92,116.42) 243,116.34 245.19,116.34 245.9,117.05 245.9,124.88 243.69,127.1 242.99,127.1 238.47,131.61 238.47,133.36 236.49,135.34 236.49,136.14 235.89,136.74 234.09,136.74 231.88,138.95 230.49,138.95 229.59,139.85 223.31,139.85 221.88,141.28 220.98,141.28 220.46,140.76 216.27,140.76 216.06,140.98 212.68,140.98 212.6,141.05 212.36,141.05 211.97,141.45 208.19,141.45 206.09,139.35 205.9,139.35 205.26,138.72 204.91,138.72 201.97,135.78 195.15,135.78 194.67,136.25 193.61,136.25 193.49,136.14 191.63,136.14 190.29,134.81 188.78,134.81 188.7,134.73 188.7,134.6 v3(188.87,134.44)
  IN2 w0.084: v2(38.6,107.29) 38.32,107.29 38.24,107.2 38.24,107 38.45,106.79 39.58,106.79 40.42,107.63 40.42,108.2 41.14,108.92 46.77,108.92 47.91,107.78 47.91,106.92 48.11,106.71 48.43,106.71 v4(48.61,106.89) ; v4(138.26,129.59) 138.44,129.76 138.44,130.28 139.11,130.95 141.55,130.95 142.07,130.43 146.23,130.43 147.38,131.58 150.91,131.58 151.44,131.05 154.45,131.05 155.16,130.34 157.96,130.34 160.54,132.92 162.46,132.92 162.7,133.16 175.83,133.16 175.95,133.28 183.79,133.28 184.66,134.15 187.3,134.15 187.83,134.68 188.62,134.68 v3(188.87,134.44) ; v3(98.74,128.67) 98.38,129.03 98.38,131.26 94.56,135.08 93.4,135.08 92.83,134.51 92.32,134.51 v4(92.16,134.67) 91.99,134.5 91.66,134.5 91.28,134.88 90.12,134.88 89.49,134.24 87.65,134.24 87.26,134.64 84.48,134.64 84.36,134.76 v7(84.36,135.01)
  IN3 w0.084: v7(84.36,135.01) 84.15,135.21 84.15,135.39 83.97,135.57 83.36,135.57 83.12,135.33 79.41,135.33 78.68,136.06 64.2,136.06 61.37,133.23 58.25,133.23 56.72,131.7 52.72,131.7 50.19,129.17 50.19,123.42 47.7,120.93 47.7,113.88 48.79,112.8 48.79,107.07 v4(48.61,106.89) ; v4(138.26,129.59) 138.44,129.41 138.44,129.16 137.98,128.71 133.41,128.71 132.91,128.2 125.01,128.2 122.07,131.14 121.35,131.14 120.37,132.12 117.94,132.12 117.56,132.5 115.69,132.5 114.57,133.62 112.62,133.62 111.23,135.01 107.63,135.01 106.78,135.86 104.65,135.86 103.5,134.7 101.31,134.7 100.84,134.23 100.54,134.23 99.49,133.18 99.22,133.18 99.09,133.06 97,133.06 95.55,134.51 94.97,134.51 94.71,134.76 93.64,134.76 93.39,134.51 92.31,134.51 v4(92.16,134.67)
REM_DIODE3_P: length 307.6
  TOP w0.119: v2(37.69,107.29) 36.69,108.29 Q31.3 ; v1(242.91,116.04) 242.83,116.11 242.44,116.11 242.21,116.34 240.47,116.34 239.92,115.79 237.06,115.79 236.72,116.13 236.72,118.27 236.76,118.3 C193.1 236.76,118.98 235.82,119.92 235.49,120.25 235.49,120.56 U27.B13 ; Q29.1 92.81,124.26 Q29.2 94.42,123.94 C208.1 94.66,123.94 95.83,125.12 v1(95.83,125.18)
  IN1 w0.089: v1(95.83,125.18) 95.83,125.47 98.75,128.39 98.97,128.39 v3(98.99,128.41) ; v3(188.39,134.41) 188.51,134.54 188.51,134.81 188.7,135 190.21,135 191.55,136.33 193.41,136.33 193.53,136.44 194.75,136.44 195.23,135.97 201.85,135.97 204.79,138.91 205.18,138.91 205.86,139.58 206.05,139.58 208.11,141.64 212.05,141.64 212.44,141.24 212.68,141.24 212.76,141.17 216.14,141.17 216.35,140.95 220.38,140.95 220.9,141.47 221.96,141.47 223.39,140.04 229.67,140.04 230.57,139.14 231.96,139.14 234.17,136.93 235.97,136.93 236.68,136.22 236.68,135.42 238.66,133.44 238.66,131.69 243.07,127.29 243.77,127.29 246.11,124.95 246.11,116.99 245.27,116.15 243.06,116.15 242.94,116.04 v1(242.91,116.04)
  IN2 w0.084: v3(98.99,128.41) 98.98,128.4 98.63,128.4 98.19,128.83 98.19,131.13 94.43,134.89 93.48,134.89 92.91,134.32 92.32,134.32 v4(92.16,134.16) 92,134.32 91.58,134.32 91.21,134.69 90.2,134.69 89.57,134.06 87.57,134.06 87.18,134.45 84.3,134.45 v7(83.78,134.97) ; v4(138.77,129.59) 138.62,129.74 138.62,130.2 139.18,130.77 141.47,130.77 141.99,130.25 146.31,130.25 147.46,131.39 150.83,131.39 151.36,130.86 154.37,130.86 155.09,130.15 158.03,130.15 160.62,132.74 162.54,132.74 162.78,132.98 175.91,132.98 176.03,133.1 183.87,133.1 184.73,133.96 187.38,133.96 187.91,134.5 188.3,134.5 v3(188.39,134.41) ; v4(48.63,106.31) 48.41,106.53 48.04,106.53 47.73,106.84 47.73,107.7 46.69,108.74 41.22,108.74 40.61,108.12 40.61,107.55 39.66,106.6 38.37,106.6 38.05,106.92 38.05,107.2 37.97,107.29 v2(37.69,107.29)
  IN3 w0.084: v4(48.63,106.31) 48.97,106.64 48.97,112.87 47.89,113.96 47.89,120.86 50.38,123.34 50.38,129.09 52.8,131.51 56.8,131.51 58.33,133.04 61.45,133.04 64.28,135.87 78.6,135.87 79.33,135.14 83.2,135.14 83.44,135.38 83.9,135.38 83.97,135.31 83.97,135.15 v7(83.78,134.97) ; v4(92.16,134.16) 92.33,134.33 93.47,134.33 93.72,134.58 94.63,134.58 94.89,134.32 95.47,134.32 96.92,132.87 99.17,132.87 99.3,133 99.58,133 100.63,134.04 100.92,134.04 101.38,134.5 103.58,134.5 104.74,135.67 106.7,135.67 107.55,134.82 111.15,134.82 112.54,133.43 114.5,133.43 115.61,132.32 117.48,132.32 117.86,131.93 120.3,131.93 121.27,130.96 121.99,130.96 124.93,128.02 132.98,128.02 133.49,128.52 138.06,128.52 138.62,129.09 138.62,129.44 v4(138.77,129.59)
RESET_OUT#: length 47
  TOP w0.06: v2(138.68,115.71) 138.93,115.96 138.94,115.96
  TOP w0.076: UC1.BP14 132.23,112.82 132.58,113.17 133.04,113.17 133.79,113.93 136.64,113.93 137.25,114.54 138.45,114.54 RH44.2
  TOP w0.119: 138.94,115.96 T29.1 139.05,115.93 139.05,115.43 138.88,115.26 RH44.2
  IN1 w0.06: v1(166.79,122.4) 166.79,122.39 166.6,122.2 166.3,122.2 166.19,122.09 166.19,121.88 166.11,121.8 166.05,121.8 165.43,121.8 164.75,121.12 164.52,121.12
  IN1 w0.089: v3(149,122.39) 149.16,122.23 149.55,122.23 151.3,120.48 158.25,120.48 159.65,121.88 159.65,122.31 159.85,122.51 162.11,122.51 162.41,122.21 162.79,122.21 163.25,121.75 163.58,121.75 164.22,121.12 164.52,121.12
  IN2 w0.084: v3(149,122.39) 149,122.23 148.85,122.08 148.37,122.08 147.81,122.64 146.47,122.64 145.03,121.19 142.34,121.19 142.01,121.53 139.96,121.53 139.24,120.81 139.24,119.13 138.92,118.81 138.92,118.39 139.24,118.07 139.24,116.27 v2(138.68,115.71)
REXT: length 1.9
  TOP w0.119: R1101.1 50.63,95.49 U23.20
RING2: length 2.5
  TOP w0.381: 19.4,9.94 18.65,9.94 18.22,9.51 17.76,9.51 17.63,9.63 Q68.1
  vias: v7(19.01,9.3) v7(19.59,9.28) v7(20.99,6.64) v7(21.55,6.61)
RREF: length 3.3
  TOP w0.203: 29.64,81.68 29.58,81.62 UR1.9
  TOP w0.305: 29.64,81.68 30.22,81.68 30.7,82.16 RR6.2
RTC_RST#: length 137.6
  TOP w0.076: UC1.BN12 132.55,112.78 132.81,113.04 133.13,113.04 133.86,113.77 136.81,113.77 137.43,114.4 138.71,114.4 138.83,114.52
  TOP w0.14: v2(232.99,138.98) 232.23,138.98 231.46,138.21 R5669.1 ; JAPS2.9 220.77,144.79 220.86,144.88 v1(220.86,144.97) ; CLRP3.2 160.36,131.46 v1(160.23,131.34) ; 138.83,114.52 139.67,114.52 139.86,114.71 T33.1 140.06,115.22 140.41,115.57 140.88,115.57 RH42.2 140.61,115.91 CH5.2 140.39,116.39 140.39,116.92 v1(140.47,117)
  IN1 w0.084: v3(226.68,144.2) 226.34,144.2 225.59,144.95 220.87,144.95 v1(220.86,144.97) 217.18,144.97 215.23,143.02 212.92,143.02 212.78,143.16 207.22,143.16 205.52,141.46 205.28,141.46 204.06,140.24 202.57,140.24 v3(202.46,140.36) ; v1(140.47,117) 140.67,117.2 141.69,117.2 141.94,117.46 141.94,119.72 142.77,120.55 142.77,121.28 144.18,122.69 144.18,124.19 144.24,124.25 144.24,129.6 145.67,131.03 147.5,131.03 147.63,130.89 148.01,130.89 148.14,131.02 159.37,131.02 159.68,131.34 v1(160.23,131.34) 160.85,131.34 160.93,131.26 161.73,131.26 162.08,130.91 162.49,130.91 163.09,130.31 164.75,130.31 v3(164.94,130.12)
  IN2 w0.079: v3(202.46,140.36) 202.46,138.96 201.82,138.33 197.61,138.33 197.18,137.9 196.12,137.9 194.96,136.74 194.22,136.74 191.41,133.93 191.41,132.39 189.87,130.85 179.17,130.85 177.84,129.52 176.41,129.52 175.93,129.04 172.54,129.04 171.74,129.84 165.76,129.84 165.49,130.12 v3(164.94,130.12) ; v3(226.68,144.2) 227.42,143.46 228.64,143.46 230.5,141.6 231.86,141.6 232.99,140.47 v2(232.99,138.98)
RTCRST_ON: length 14.3
  TOP w0.119: v2(228.93,135.85) 226.91,135.85 R5719.1
  IN2 w0.084: v2(233.81,126.25) 233.81,128 232.9,128.9 232.9,130.13 231.37,131.66 231.37,132.05 231.13,132.29 230.32,132.29 229.68,132.93 229.68,135.1 v2(228.93,135.85)
RTD3_CIO_PWR_EN: length 4
  TOP w0.119: RT10.1 21.77,27.28 21.41,27.64 21.41,28.38 21.55,28.52 R1411.1 21.77,29.13 22.49,29.85 UT1.F1
RTD3_USB_PWR_EN: length 3.5
  GND1 w0.119: v10(21.35,31.44) 21.33,31.44 21.1,31.21 v4(21,31.21)
  GND4 w0.119: v9(21.53,31.76) 21.53,31.64 21.14,31.25 21.04,31.25 v4(21,31.21)
  BOTTOM w0.119: R1412.1 22.76,32.71 RT6.1 22.08,31.76 v9(21.53,31.76)
RUN_ON: length 258.1
  TOP w0.102: 181.34,98.97 181.03,98.97 180.69,99.31 v1(179.75,99.31)
  TOP w0.119: 181.34,98.97 188.89,98.97 189.01,98.84 192.24,98.84 192.89,99.5 R135.1 ; v2(98.95,85.94) 98.94,85.94 98.14,86.73 98.14,88.7 98.51,89.06 R133.1 98.71,89.78 R217.2 ; v1(235.31,133.73) 234.32,132.74 234.32,131 234.64,130.68 R1064.2 235.2,130.28 235.2,129.7 235.23,129.67 235.23,127.9 234.56,127.22 234.56,127 U27.D1
  IN1 w0.089: v1(235.31,133.73) 235.31,134.8 233.89,136.23 233.09,136.23 232.4,136.91 231.54,136.91 230.21,138.24 229.98,138.24 229.59,138.63 224.34,138.63 223.84,139.12 222.22,139.12 221.84,139.5 216.16,139.5 215.53,140.13 212.32,140.13 212.27,140.18 209.82,140.18 209.54,139.9 209.54,139.33 209.4,139.18 207.48,139.18 203.97,135.67 203.17,135.67 202.43,134.93 192.25,134.93 191.13,133.8 191.13,133.04 189.13,131.05 187.33,131.05 185.6,129.32 185.6,125.94 184.97,125.31 180.01,125.31 179.76,125.55 179.76,127.92 178.09,129.59 176.13,129.59 175.64,129.1 173.97,129.1 173.45,129.62 172.8,129.62 170.93,131.49 165.19,131.49 165.05,131.35 163.58,131.35 163.28,131.65 163.28,131.83 162.54,132.57 160.19,132.57 159.76,132.15 159.6,132.15 159.2,131.74 156.43,131.74 v5(155.73,132.44) ; v1(179.75,99.31) 179.33,99.31 179.22,99.42 176.61,99.42 176.39,99.64 173.42,99.64 172.86,99.08 168.46,99.08 168.38,99 164.05,99 163.48,98.43 156.89,98.43 156.28,99.04 153.39,99.04 152.64,99.79 152.64,99.97 v8(152.58,100.03)
  GND1 w0.119: v4(152.2,99.7) 152.53,100.03 v8(152.58,100.03) ; v5(155.73,132.44) v4(155.73,131.63)
  IN2 w0.084: v4(98.66,85.53) 98.65,85.54 98.65,85.63 v2(98.95,85.94)
  IN3 w0.084: v6(127.77,82.15) 127.06,81.44 v6(125.03,81.44) ; v6(150.83,102.8) 150.83,103.77 151.49,104.43 151.49,106.33 153.42,108.26 153.42,115.01 151.62,116.81 151.62,118.02 151.27,118.36 151.27,121.64 150.77,122.15 150.77,124.46 152.08,125.77 152.08,128.23 155.48,131.63 v4(155.73,131.63) ; v4(98.66,85.53) 98.98,85.53 100.09,84.41 101.32,84.41 103.83,81.91 103.83,81.77 v6(103.98,81.62)
  GND4 w0.119: v9(151.8,99.7) v4(152.2,99.7)
  BOTTOM w0.119: v6(127.77,82.15) 128.35,82.74 129.51,82.74 130.31,83.53 134.16,83.53 136.41,85.78 138.24,85.78 139.25,86.8 143.46,86.8 148.36,91.7 148.36,91.92 151.14,94.7 v14(151.14,97.04) 151.14,97.62 152,98.48 152,99.3 151.8,99.5 v9(151.8,99.7) 151.9,99.7 152.1,99.91 152.1,101.46 151.85,101.71 151.85,102.45 151.49,102.8 v6(150.83,102.8) ; v6(125.03,81.44) 124.67,81.08 118.98,81.08 118.68,80.78 109.7,80.78 109.35,81.13 104.47,81.13 v6(103.98,81.62)
RUNPWROK: length 4.1
  TOP w0.119: R176.2 233.06,130.04 233.06,126.99 U27.F1
S2_GATE-1: length 3
  TOP w0.119: PU205.4 64.7,136 63.86,135.16 63.86,134.53 63.61,134.27 PU204.2
S_VSYNC: length 131.2
  TOP w0.102: JCAM2.8 96.54,133.54 96.44,133.64
  TOP w0.119: v1(156.32,135.26) 156.32,136.36 156.66,136.7 157.36,136.7 157.6,136.94 C1429.1 R80.2 ; 96.44,133.64 95.84,134.23 v2(95.84,134.64)
  IN1 w0.089: v3(108.27,135.9) 109.61,135.9 109.68,135.97 110.64,135.97 111.03,135.59 113.27,135.59 115.61,133.25 120.19,133.25 v3(120.64,132.8) ; v1(197.95,141.31) 197.95,140.78 197.09,139.92 192.8,139.92 191.31,138.42 190.31,138.42 188.81,136.91 181.79,136.91 179.3,134.42 174.13,134.42 173.28,135.27 172.77,135.27 171.91,136.13 169.03,136.13 168.65,136.51 163.51,136.51 162.15,135.15 159.76,135.15 159.42,135.49 156.55,135.49 v1(156.32,135.26) 154.85,135.26 153.86,134.27 149.48,134.27 148.23,133.02 145,133.02 144.21,132.23 142.06,132.23 140.77,130.95 140.77,130.16 139.92,129.31 139.64,129.31 139.32,128.98 139.1,128.77 139.1,128.46 138.94,128.3 138.41,128.3 137.98,127.87 136.36,127.87 134.49,129.73 133.18,129.73 132.66,130.26 131.51,130.26 130.95,130.81 130.95,131.12 130.37,131.7 130.19,131.7 v3(130.01,131.88)
  IN2 w0.084: v3(108.27,135.9) 105.49,135.9 101.62,132.03 101.62,130.83 102.24,130.21 102.24,129.85 v2(101.95,129.56) 101.71,129.8 101.71,130.03 100.91,130.83 100.91,132.81 101.14,133.04 101.14,133.46 100.26,134.34 98.59,134.34 97.5,135.43 96.63,135.43 v2(95.84,134.64) ; v3(130.01,131.88) 129.95,131.82 129,131.82 128.73,132.09 128.73,132.22 128.33,132.62 127.14,132.62 126.81,132.29 125.05,132.29 124.41,132.93 121.6,132.93 121.55,132.88 v4(121.39,132.88) 121.32,132.8 v3(120.64,132.8)
  GND4 w0.119: v4(121.39,132.88) 121.39,132.98 120.94,133.43 v15(120.94,133.98)
S_VSYNC_J1: length 15.3
  TOP w0.119: JP1.15 145.51,137.27 v2(145.5,137.28)
  IN1 w0.089: v5(158.3,137.19) 158.43,137.07 v1(159.23,137.07)
  GND1 w0.119: v5(158.3,137.19) v12(158.3,137.78)
  IN2 w0.084: v12(158.3,137.78) 157.89,137.78 157.74,137.93 146.14,137.93 v2(145.5,137.28)
S_VSYNC_R: length 4.8
  TOP w0.119: v1(197.71,143.9) 197.71,142.51 R79.2
  IN1 w0.089: v1(197.71,143.9) 197.38,143.57 196.89,143.57 196.77,143.44 196.77,142.87 196,142.1 v1(195.77,142.1)
SABTS: length 10.9
  TOP w0.508: PR1000.1 78.28,104.59 v7(78.14,104.73)
  GND1 w0.119: v10(71.22,108.75) v4(71.75,108.75)
  IN3 w0.508: v4(71.75,108.75) 72.38,109.38 74.78,109.38 78.14,106.03 v7(78.14,104.73)
SAHGS: length 12.8
  TOP w0.254: PU800.G10 71.61,108.74 71.61,108.36 71.32,108.07 v7(71.32,107.89)
  TOP w0.508: PQ1000.1 v7(77.41,101.02)
  IN2 w0.508: v7(72.62,103.44) 73.36,102.7 74,102.7 74.62,102.08 76.36,102.08 v7(77.41,101.02)
  BOTTOM w0.508: v7(72.62,103.44) 72.61,103.45 72.61,107.21 71.93,107.89 v7(71.32,107.89)
SALGS: length 17.2
  TOP w0.254: PU800.D10 72.82,108.55 73.41,107.96 v2(73.46,107.96)
  TOP w0.508: v7(76.69,95.79) 76.89,95.59 PR1004.1
  IN2 w0.254: v4(73.87,107.96) v2(73.46,107.96)
  IN3 w0.508: v7(76.69,95.79) 77.5,96.6 77.5,98.28 76.51,99.27 76.51,101.3 77.16,101.95 77.16,103.45 76.51,104.1 76.51,105.7 74.25,107.96 v4(73.87,107.96)
SALGS_1: length 1.2
  TOP w0.508: PQ1000.8 77.58,97.42 PR1004.2
SAR_DPR: length 277.1
  TOP w0.119: v7(28.66,100.59) 27.3,100.59 26.8,101.09 JNGFF1.17 ; v7(29.83,98.66) 30.58,98.66 31.35,97.89 Q43.1 31.35,95.16 32.07,94.43 v2(32.07,90.58)
  IN1 w0.06: v3(233.06,124.23) 233.05,124.24 231.64,124.24 231.41,124.01 230.23,124.01 230.08,124.16 229.72,124.16 229.65,124.09
  IN1 w0.089: v5(94.16,122.94) 94.61,122.94 95.15,122.4 95.15,106.67 94.43,105.95 94.43,103.26 92.74,101.57 91.32,101.57 90.89,101.14 90.89,99.72 88.75,97.59 88.75,95.3 86.83,93.38 80.33,93.38 79.95,93 77.14,93 76.02,94.12 64.79,94.12 62.71,96.2 53.79,96.2 52.03,94.45 50.26,94.45 49.73,94.98 47.96,94.98 v3(47.17,94.19) ; 229.65,124.09 229.4,123.84 229.06,123.84 228.79,124.11 227.08,124.11 227,124.19 226.63,124.19 224.73,126.09 223.71,126.09 223.53,126.27 218.62,126.27 218.47,126.42 217.54,126.42 217.31,126.65 216.07,126.65 215.83,126.42 215.09,126.42 214.74,126.07 214.19,126.07 213.84,126.43 211.24,126.43 210.28,125.47 210.28,124.57 209.44,123.73 208.76,123.73 208.44,123.41 207.48,123.41 206.6,122.53 205.97,122.53 205.7,122.26 205.7,121.81 205.36,121.47 204.9,121.47 204.68,121.26 204.68,120.77 204.38,120.47 203.89,120.47 203.66,120.24 203.66,119.82 203.3,119.46 198.83,119.46 197.2,117.83 197.2,116.11 191.51,110.42 191.51,109.03 191.17,108.7 191.17,107.77 190.61,107.21 190.61,106.71 188.86,104.95 188.39,104.95 186.89,103.46 182.97,103.46 182.62,103.1 179.83,103.1 179.58,102.85 172.39,102.85 171.98,103.26 167.6,103.26 167.47,103.39 165.39,103.39 165.29,103.28 157.85,103.28 156.48,104.66 153.98,104.66 152.81,105.82 152.81,108.57 151.92,109.46 v5(151.92,109.62)
  GND1 w0.119: v4(94.65,122.94) v5(94.16,122.94) ; v5(151.92,109.62) 151.97,109.67 v4(151.97,110.07)
  IN2 w0.084: v3(47.17,94.19) 45.05,94.19 44.74,93.89 43.6,93.89 43.03,94.45 42.12,94.45 41.36,93.7 40.22,93.7 40.14,93.62 37.07,93.62 35.13,91.69 33.18,91.69 v2(32.07,90.58) ; v2(234.81,124.75) 234.75,124.69 233.52,124.69 v3(233.06,124.23)
  GND3 w0.119: v4(151.97,110.07) 151.97,110.35 151.67,110.65 141.75,110.65 141.2,111.2 137.15,111.2 136.74,110.8 132.44,110.8 131.55,111.69 116.98,111.69 111.76,116.91 101.11,116.91 98.84,119.18 98.84,120.02 95.92,122.94 v4(94.65,122.94)
  IN3 w0.084: v7(28.66,100.59) 28.66,99.83 v7(29.83,98.66)
SAR_DPR_R: length 1.5
  TOP w0.119: Q43.3 30.7,98.07 30.61,98.15 29.97,98.15 R47.2
SASWS: length 19
  TOP w0.254: PL1001.1 81.83,98.46 82.09,98.2 82.09,96.54 81.21,95.66 PR1002.1 ; v10(72.02,108.31) 72.02,108.31 72.02,108.75 PU800.F10
  GND1 w0.119: v4(72.04,107.91) 71.96,107.91 72.02,107.96
  GND1 w0.254: 72.02,107.96 v10(72.02,108.31)
  IN3 w0.508: v7(79.69,101.91) 79.69,103.18 79.23,103.64 77.83,103.64 77.22,104.25 77.22,105.85 74.45,108.62 72.75,108.62 v4(72.04,107.91)
SC_ALERT#: length 140.2
  TOP w0.119: v1(142.06,87.33) MD6.9 MD6.1 ; Q347.6 222.11,118.48 222.42,118.79 R5750.2 222.76,118.54 222.76,116.42 222.38,116.04 v1(221.44,116.04) ; JPOGO.70 121.3,81.8 121.77,81.33 126.14,81.33 v2(126.19,81.28)
  IN1 w0.089: v7(200.98,105.29) 202.96,107.27 206.05,107.27 212.37,113.59 212.37,113.93 213.61,115.17 215.65,115.17 216.34,115.87 217.31,115.87 217.98,116.54 220.94,116.54 v1(221.44,116.04) ; v7(188.94,87.43) 188.28,86.77 185.44,86.77 183.15,84.49 171.44,84.49 169.7,86.23 168.42,86.23 167.44,85.24 163.88,85.24 160.42,88.7 153.35,88.7 152.89,88.25 143.75,88.25 143.11,87.61 142.34,87.61 v1(142.06,87.33) 141.18,86.44 141.18,86.41 v3(140.37,85.6)
  IN2 w0.084: v2(126.19,81.28) 126.47,81.28 126.87,81.67 129.93,81.67 133.48,85.22 139.99,85.22 v3(140.37,85.6)
  BOTTOM w0.119: v7(200.98,105.29) 200.29,105.29 197.92,107.67 196.65,107.67 195.77,108.54 193.76,108.54 192.76,107.55 192.76,103.09 191.55,101.88 191.55,101.14 189.43,99.02 189.43,95.56 188.42,94.55 188.42,87.95 v7(188.94,87.43)
SC_SMBCLK: length 149.3
  TOP w0.119: MD6.2 MD6.8 v1(142.05,87.83) ; JPOGO.18 110.9,82.52 110.75,82.37 v1(110.75,82.25) ; v1(216.3,115.43) 215.48,116.25 215.48,118.37 215.18,118.67 215.18,119.22 215.36,119.4 218.14,119.4 218.54,119.01 R5751.2 218.54,118.23 218.78,117.99 Q348.3
  IN1 w0.089: v1(110.75,82.25) 110.75,82.22 110.95,82.01 110.95,81.85 111.65,81.15 118.75,81.15 119.36,80.53 131.35,80.53 131.56,80.75 134.25,80.75 134.3,80.8 134.93,80.8 140.61,86.48 140.7,86.48 v1(142.05,87.83) 142.66,88.44 152.81,88.44 153.27,88.9 160.5,88.9 163.33,86.06 166.5,86.06 166.9,85.67 167.59,85.67 168.34,86.42 169.78,86.42 171.52,84.68 183.08,84.68 185.36,86.97 187.87,86.97 v7(188.34,87.43) ; v1(216.3,115.43) 215.86,114.98 213.69,114.98 212.56,113.85 212.56,113.51 206.11,107.07 203.41,107.07 v7(201.62,105.28)
  BOTTOM w0.119: v7(201.62,105.28) 201.62,105.44 201.26,105.8 200.1,105.8 198.01,107.89 196.74,107.89 195.86,108.77 193.67,108.77 192.54,107.64 192.54,103.18 191.33,101.97 191.33,101.23 189.21,99.11 189.21,95.66 188.2,94.64 188.2,87.57 v7(188.34,87.43)
SC_SMBDAT: length 146.3
  TOP w0.119: JPOGO.16 110.5,82.51 110.43,82.44 110.43,82.13 110.66,81.9 v1(110.67,81.9) ; MD6.7 MD6.4 144.28,88.83 144.45,88.66 144.45,86.85 v2(143.71,86.12) ; v7(216.57,117.83) 216.58,117.81 216.58,116.67 217.47,115.78 R5752.2 217.87,116.52 217.7,116.69 Q348.6
  IN1 w0.089: v1(110.67,81.9) 110.67,81.86 111.58,80.96 118.67,80.96 119.28,80.34 131.85,80.34 131.97,80.46 134.47,80.46 134.62,80.61 135.01,80.61 138.6,84.19 v3(138.97,84.19)
  IN2 w0.084: v4(207.52,108.42) 207.32,108.42 206.47,107.56 203,107.56 202.31,106.87 200.35,106.87 198.45,104.98 198.45,102.92 199.29,102.08 199.29,97.91 199.7,97.5 199.7,89.74 198.11,88.16 192.03,88.16 190.46,86.58 183.68,86.58 183.41,86.31 168.65,86.31 167.93,87.03 161.3,87.03 160.55,87.78 150.45,87.78 148.83,86.16 143.76,86.16 v2(143.71,86.12) 143.26,85.67 142.02,85.67 140.54,84.19 v3(138.97,84.19)
  GND4 w0.119: v9(207.44,109.71) 207.44,108.5 v4(207.52,108.42)
  BOTTOM w0.119: v7(216.57,117.83) 216.39,117.65 216,117.65 213.02,114.67 213.02,112.45 212.13,111.56 209.05,111.56 207.44,109.95 v9(207.44,109.71)
SCLK: length 2.8
  TOP w0.119: PR835.2 69.63,112.96 69.63,112.02 70.1,111.55 PU800.K3
SD_CD#: length 24
  TOP w0.152: v19(28.38,76.4) 28.38,76.4 UR1.30 ; JCR1.9 16.8,91.12 16.31,90.64 v1(16.31,88.7)
  IN1 w0.089: v1(16.31,88.7) 16.31,87.99 16.87,87.43 16.87,84.23 18.8,82.31 18.8,81.55 22.78,77.57 27.21,77.57 v19(28.38,76.4)
SD_CLK: length 10
  TOP w0.152: v7(18.54,86.82) 18.53,86.82 JCR1.5 ; v1(23.72,82.04) 23.43,81.75 RR12.2
  IN1 w0.089: v7(18.54,86.82) 19.46,85.89 19.46,85 20.54,83.93 21.83,83.93 v1(23.72,82.04)
SD_CLK_L: length 1.9
  TOP w0.152: RR12.1 24.06,81.28 24.97,81.28 25.28,80.97 UR1.17
SD_CMD: length 10.2
  TOP w0.152: v1(18.4,84.54) 17.91,85.02 JCR1.3 ; RR13.2 CR21.1 v7(22.88,79.37)
  IN1 w0.089: v1(18.4,84.54) 18.52,84.41 18.52,84.14 19.28,83.39 19.28,81.93 21.34,79.87 22.39,79.87 v7(22.88,79.37)
SD_CMD_L: length 1.8
  TOP w0.152: UR1.19 24.23,80.17 RR13.1
SD_D2: length 10.2
  TOP w0.152: RR15.2 CR19.1 23.4,76.76 v7(22.85,76.76) ; v1(18.17,82.53) 17.48,83.22 JCR1.1
  IN1 w0.089: v7(22.85,76.76) 22.68,76.93 22.68,77.31 18.58,81.41 18.58,82.12 v1(18.17,82.53)
SD_D2_L: length 3.1
  TOP w0.152: RR15.1 24.48,77.89 24.48,78.81 25.04,79.37 UR1.21
SD_D3: length 9.8
  TOP w0.152: RR14.2 CR20.1 v7(22.88,78.05) ; JCR1.2 v1(17.37,84.12)
  IN1 w0.089: v1(17.37,84.12) 19.03,82.46 19.03,81.88 22.85,78.05 v7(22.88,78.05)
SD_D3_L: length 2.2
  TOP w0.152: RR14.1 24.01,78.74 25.05,79.77 UR1.20
SD_LN0_M: length 29.7
  TOP w0.119: v7(25.31,76.35) 25.6,76.35 26.38,77.13 UR1.25 ; JCR1.17 v7(4.59,87.4)
  IN3 w0.084: v7(25.31,76.35) 25.12,76.16 19.27,76.16 14.25,81.18 8.02,81.18 5.11,84.09 5.11,86.88 v7(4.59,87.4)
SD_LN0_P: length 29.8
  TOP w0.119: JCR1.16 v7(4.62,86.49) ; v7(26.66,76.68) 26.61,76.72 26.61,76.98 26.78,77.15 UR1.26
  IN3 w0.084: v7(26.66,76.68) 26.11,76.14 25.63,76.14 25.48,75.98 19.19,75.98 14.17,81 7.87,81 4.91,83.96 4.91,86.21 v7(4.62,86.49)
SD_LN1_M: length 29.6
  TOP w0.119: v7(24.9,78.08) 25.4,78.57 UR1.23 ; JCR1.19 v7(4.55,89.22)
  IN3 w0.084: v7(4.55,89.22) 5.16,89.22 5.66,88.71 5.66,83.81 8.06,81.41 14.45,81.41 17.12,78.74 23.36,78.74 23.87,78.23 24.75,78.23 v7(24.9,78.08)
SD_LN1_P: length 29.9
  TOP w0.119: v7(24.9,78.63) 25.24,78.97 UR1.22 ; JCR1.20 v7(4.52,90.13)
  IN3 w0.084: v7(4.52,90.13) 5.87,88.78 5.87,83.86 8.12,81.61 15,81.61 v7(15.69,80.92) 17.68,78.93 23.43,78.93 23.95,78.41 24.68,78.41 v7(24.9,78.63)
SD_PWR_EN: length 182.6
  TOP w0.119: v1(39.12,95.54) 38.86,95.54 R5754.2 38.37,95.83 37.4,96.81 35.76,96.81 34.84,95.89 34.33,95.89 R225.2 34.67,95.18 U32.3
  IN1 w0.06: 139.81,112.14 139.67,112.14 139.44,111.9 138.88,111.9 138.82,111.83 138.56,111.83 138.3,111.57 137.9,111.57 137.5,111.98 136.91,111.98 136.73,111.8 136.73,111.62 136.59,111.47 136.19,111.47 135.67,112 134.83,112 134.63,111.79 v1(134.56,111.79)
  IN1 w0.089: 139.81,112.14 140.55,112.14 140.92,112.51 143.2,112.51 143.8,111.9 143.83,111.9 144.34,111.39 144.78,111.39 145.18,110.98 146.44,110.98 147.76,109.66 v8(147.76,109.56) ; v1(39.12,95.54) 39.13,95.53 40.24,95.53 41.89,97.18 45.88,97.18 47.04,98.34 48.02,98.34 49.79,100.11 59.39,100.11 61.68,102.4 61.68,110.91 62.84,112.07 62.84,115.79 65.27,118.22 65.5,118.22 70.26,122.97 71.8,122.97 72.1,123.27 72.5,123.27 74.02,124.79 75.53,124.79 76.07,125.34 76.59,125.34 79.27,128.02 79.74,128.02 80.47,128.74 81.06,128.74 81.48,129.16 82.8,129.16 84.17,130.53 86,130.53 86.93,131.46 89.65,131.46 93.79,135.6 99.58,135.6 100.17,135.01 101.4,135.01 101.85,134.56 104.09,134.56 104.63,134.02 105.31,134.02 105.5,134.2 108.07,134.2 108.68,133.59 109.89,133.59 110.67,134.37 112.7,134.37 113.75,133.32 113.75,132.6 v3(114.15,132.19)
  GND1 w0.119: v4(148.29,109.61) 148.24,109.56 v8(147.76,109.56)
  IN2 w0.084: v4(113.54,129.09) 113.95,129.5 114.31,129.5 114.56,129.75 114.56,129.83 114.65,129.92 114.65,131.21 114.15,131.71 v3(114.15,132.19)
  GND3 w0.119: v4(113.54,129.09) 113.54,129.01 114.18,128.38 114.26,128.38 114.5,128.14 114.5,127.92 115.46,126.96 121.45,126.96 126.63,121.78 139.18,121.78 140.24,122.85 143.9,122.85 145.14,124.09 145.76,124.09 146.14,124.47 146.92,124.47 v4(147.3,124.09)
  IN3 w0.084: v4(148.29,109.61) 147.4,110.5 147.4,112.2 147.87,112.66 147.87,117.96 147.92,118.01 147.92,118.8 147.42,119.3 147.42,121.49 147.33,121.59 147.33,124.06 v4(147.3,124.09)
