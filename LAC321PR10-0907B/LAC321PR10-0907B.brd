# Allegro board LAC321PR10-0907B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCPRIM_1P0 on IN3: 129.27,108.49 130.16,108.49 130.41,108.24 130.41,106.33 130.09,106.02 130.09,104.49 130.28,104.3 130.92,104.3 131.3,104.68 133.33,104.68 134.22,103.79 134.22,103.28 134.6,102.9 135.11,102.9 136.09,103.88 136.68,103.88 137.01,103.55 137.01,101.63 136.63,101.25 134.22,101.25 131.81,103.67 129.9,103.67 129.39,104.17 129.39,105.19 129.01,105.57 129.01,108.24
+VCCPRIM_1P0 on VCC: 149,102.27 148.82,102.45 148.82,103.72 145.58,106.97 134.04,106.97 132.39,105.32 130.64,105.32 130.64,108.24 131.83,109.43 150.88,109.43 150.98,109.33 150.98,102.27
+VCCPRIM_3P3 on TOP: 135.24,104.3 135.57,104.3 135.67,104.2 136.79,104.2 137.34,104.75 137.34,104.87 137.41,104.94 138.55,104.94 138.65,104.83 138.65,104.19 138.79,104.05 139.43,104.05 139.55,103.92 139.55,103.16 139.43,103.03 138.79,103.03 137.85,103.97 137.14,103.97 136.96,103.79 135.36,103.79 135.24,103.67 135.11,103.67 134.98,103.79 134.98,104.05
+VCCPRIM_3P3 on BOTTOM: 130.41,107.22 130.66,107.22 130.74,107.15 130.74,105.39 130.52,105.17 130.3,105.17 130.22,105.24 130.22,105.47 130.26,105.5 130.26,107.07
+VCCPRIM_CORE on IN3: 130.44,104.41 130.78,104.41 131.54,105.17 132.57,105.17 133.09,105.7 133.09,107.7 132.43,108.36 131.79,108.36 131.6,108.55 131.28,108.55 131.16,108.43 131.16,107.73 130.71,107.28 130.71,106.33 130.27,105.89 130.27,104.58
+VCCPRIM_CORE on VCC: 142.65,99.6 138.34,103.92 132.52,103.92 132.39,104.05 130.59,104.05 130.33,104.3 130.33,104.81 130.59,105.06 132.49,105.06 134.15,106.71 145.47,106.71 148.57,103.61 148.57,102.34 148.9,102.01 150.98,102.01 150.98,99.71 150.88,99.6
AGND on TOP: 37.95,19.59 38.46,19.59 38.72,19.34 38.72,13.24 38.59,13.11 36.94,13.11 36.68,13.37 36.68,17.94 36.94,18.19 37.57,18.19 37.83,18.45 37.83,19.46
AGND on BOTTOM: 18.4,0.25 18.4,4.99 18.78,5.37 20.94,5.37 21.06,5.24 24.11,5.24 24.49,5.62 24.49,10.19 25.25,10.96 25.25,11.46 24.36,12.35 22.08,12.35 20.05,10.32 16.74,10.32 16.74,11.97 20.17,15.4 20.81,15.4 21.95,16.54 21.95,18.96 22.46,19.46 26.27,19.46 26.4,19.34 26.4,16.29 26.78,15.91 32.11,15.91 33.13,16.92 35.03,16.92 35.67,17.56 35.67,19.34 35.79,19.46 41,19.46 41,10.06 40.37,9.43 35.03,9.43 31.6,6 31.6,0.41 31.44,0.25
AGND on IN1: 30.95,0.25 30.95,0.29 16.74,0.29 16.74,14.89 17.25,15.4 20.6,15.4 22.08,16.88 22.08,19.08 22.33,19.34 26.27,19.34 26.4,19.21 26.4,16.29 26.78,15.91 32.11,15.91 32.49,16.29 32.49,16.8 32.62,16.92 35.03,16.92 35.67,17.56 35.67,19.34 35.79,19.46 40.99,19.46 40.99,9.69 41,9.69 41,0.5 40.92,0.33 40.75,0.25 ; 1 cut-out
AGND on GND1: 37.7,0.26 16.74,0.26 16.74,15.4 20.79,15.4 21.95,16.57 21.95,18.98 22.37,19.4 26.36,19.4 26.4,19.36 26.4,16.31 26.8,15.91 32.03,15.91 32.43,16.31 32.43,16.95 32.47,16.99 35.01,16.99 35.6,17.58 35.6,19.36 35.71,19.46 41,19.46 41,3.55 ; 1 cut-out
AGND on IN2: 16.74,0.26 16.74,4.73 17.51,5.49 25.38,5.49 25.89,6 25.89,7.65 24.11,9.43 24.11,10.19 24.36,10.45 27.16,10.45 29.83,13.11 31.1,13.11 31.73,13.75 31.73,15.02 33.64,16.92 35.03,16.92 35.67,17.56 35.67,19.34 35.79,19.46 40.99,19.46 40.99,7.4 40.49,6.89 36.05,6.89 34.14,4.99 34.14,1.14 33.25,0.26
AGND on GND2: 37.98,0.26 16.74,0.26 16.74,15.4 20.79,15.4 21.95,16.57 21.95,18.98 22.37,19.4 26.36,19.4 26.4,19.36 26.4,16.31 26.8,15.91 32.03,15.91 32.43,16.31 32.43,16.95 32.47,16.99 35.01,16.99 35.6,17.58 35.6,19.36 35.71,19.46 41,19.46 41,3.27
AGND on GND3: 16.74,0.26 16.74,15.4 20.79,15.4 21.95,16.57 21.95,18.98 22.37,19.4 26.36,19.4 26.4,19.36 26.4,16.31 26.8,15.91 32.03,15.91 32.43,16.31 32.43,16.95 32.47,16.99 35.01,16.99 35.6,17.58 35.6,19.36 35.71,19.46 41,19.46 41,4.4 36.85,0.26
AGND on IN3: 26,5.98 25.71,5.98 25.64,6.03 25.66,6.11 25.44,6.69 25.22,6.11 25.24,6.03 25.17,5.98 23.83,5.98 23.76,6.01 23.76,6.08 23.64,6.46 23.25,6.41 23.19,6.39 23.13,6.42 22.73,6.49 22.62,6.09 22.62,6.01 22.55,5.98 22.26,5.98 22.19,6.03 22.21,6.11 22.28,6.22 22.31,6.34 22.31,6.36 24.11,8.16 24.11,11.97 27.29,15.15 29.7,15.15 29.95,14.89 29.95,13.75 30.21,13.5 31.48,13.5 31.73,13.75 31.73,15.53 33.13,16.92 35.03,16.92 35.67,17.56 35.67,19.34 35.79,19.46 40.99,19.46 40.99,7.4 40.49,6.89 36.05,6.89 34.14,4.99 34.14,1.14 33.25,0.26 16.74,0.26 16.74,4.73 17.25,5.24 21.19,5.24 21.21,5.27 26.29,5.27 27.11,6.08 27.11,6.58 26.6,6.58 ; 1 cut-out
AGND on GND4: 16.74,0.26 16.74,15.4 20.79,15.4 21.95,16.57 21.95,18.98 22.37,19.4 26.36,19.4 26.4,19.36 26.4,16.31 26.8,15.91 32.03,15.91 32.43,16.31 32.43,16.95 32.47,16.99 35.01,16.99 35.6,17.58 35.6,19.36 35.71,19.46 41,19.46 41,4.1 37.15,0.26 ; 1 cut-out
AGND on VCC: 16.74,0.26 16.74,15.4 20.79,15.4 21.95,16.57 21.95,18.98 22.37,19.4 26.36,19.4 26.4,19.36 26.4,16.31 26.8,15.91 32.03,15.91 32.43,16.31 32.43,16.95 32.47,16.99 35.01,16.99 35.6,17.58 35.6,19.36 35.71,19.46 41,19.46 41,3.71 37.54,0.26
DV12S on TOP: 30.32,83.94 30.32,82.42 30.07,82.16 29.05,82.16 28.9,82.01 28.9,81.25 28.82,81.17 28.72,81.17 28.67,81.22 28.67,82.55 28.92,82.8 29.05,82.8 29.56,83.31 29.56,83.94 29.69,84.07 30.19,84.07
GND on TOP (solid shape): 180.23,138.1 161.78,138.1 161.78,138.9 180.23,138.9
GND on TOP (solid shape): 240.91,113 200.54,113 200.54,113.8 240.91,113.8
GND on TOP (solid shape): 39.86,59.6 5.05,59.6 5.05,46.7 4.25,46.7 4.25,60.4 39.86,60.4
GND on TOP (solid shape): 66.85,130.3 64.35,130.3 64.35,127.57 63.55,127.57 63.55,131.1 66.85,131.1
GND on TOP (solid shape): 148.1,127.38 147.3,127.38 147.3,130.65 144.28,130.65 144.28,131.45 148.1,131.45
GND on TOP (solid shape): 34.46,59.14 34.46,58.13 34.33,58 28.55,58 28.53,58.02 28.53,59.24 28.61,59.32 34.28,59.32
GND on TOP (solid shape): 40.75,8.1 11.75,8.1 11.75,9.38 12.55,9.38 12.55,8.9 39.95,8.9 39.95,57.64 40.75,57.64
GND on TOP (solid shape): 48.38,149.45 48.85,149.45 48.85,141.6 42.09,141.6 42.09,142.4 48.05,142.4 48.05,150.4 48.38,150.4
GND on TOP (solid shape): 57.51,127.36 57.51,126.27 57.26,126.02 56.62,126.02 56.5,126.14 56.5,127.31 56.67,127.49 57.38,127.49
GND on TOP (solid shape): 77.49,103.96 77.49,102.47 77.43,102.41 74.34,102.41 74.29,102.46 74.29,103.96 74.34,104.01 77.44,104.01
GND on TOP (solid shape): 91.78,97.11 91.78,95.96 91.65,95.82 90.65,95.82 90.33,96.14 90.33,97.09 90.43,97.19 91.7,97.19
GND on TOP (solid shape): 100.63,108.21 100.63,106.4 100.45,106.22 99.49,106.22 99.23,106.47 99.23,108.21 99.49,108.47 100.37,108.47
GND on TOP (solid shape): 159.2,138.1 155.89,138.1 155.89,131.15 153.78,131.15 153.78,131.95 155.09,131.95 155.09,138.9 159.2,138.9
GND on TOP (solid shape): 197.89,109.27 197.89,104.35 197.09,104.35 197.09,109.12 185.92,138.1 182.78,138.1 182.78,138.9 186.47,138.9
GND on TOP (solid shape): 244.67,113 243.87,113 243.87,140.21 243.14,140.21 243.14,141.01 244.67,141.01
GND on TOP (solid shape): 46.36,106.6 46.36,102.08 46.23,101.95 44.02,101.95 43.9,102.07 43.9,106.66 43.95,106.71 46.25,106.71
GND on TOP (solid shape): 61.65,131.26 61.65,130.46 61.53,130.34 60.5,130.34 60.37,130.46 60.37,131.29 60.43,131.35 61.56,131.35
GND on TOP (solid shape): 61.77,127.39 61.77,126.61 61.63,126.47 60.48,126.47 60.37,126.59 60.37,127.48 60.43,127.54 61.61,127.54
GND on TOP (solid shape): 63.05,83.33 58.12,83.33 58.12,84.13 62.25,84.13 62.25,99.1 20.85,99.1 20.85,63.97 20.05,63.97 20.05,99.9 63.05,99.9
GND on TOP (solid shape): 82.19,106.75 82.19,105.82 81.48,105.11 77.45,105.11 77.2,105.37 77.2,107.02 77.31,107.13 81.81,107.13
GND on TOP (solid shape): 97.6,83.33 63.55,83.33 63.55,125.02 64.35,125.02 64.35,84.13 96.8,84.13 96.8,130.3 94.13,130.3 94.13,131.1 97.6,131.1
GND on TOP (solid shape): 101.73,130.65 98.9,130.65 98.9,91.75 147.3,91.75 147.3,124.84 148.1,124.84 148.1,90.95 98.1,90.95 98.1,131.45 101.73,131.45
GND on TOP (solid shape): 151.22,131.15 149.4,131.15 149.4,98.6 197.09,98.6 197.09,101.8 197.89,101.8 197.89,97.8 148.6,97.8 148.6,131.95 151.22,131.95
GND on TOP (solid shape): 179.42,111.32 179.42,107.59 179.18,107.35 178.16,107.35 178.03,107.48 178.03,111.29 178.16,111.41 179.33,111.41
GND on TOP (solid shape): 185.87,122.65 185.87,121.8 185.75,121.68 185.01,121.68 184.77,121.92 184.77,122.65 184.85,122.73 185.79,122.73
GND on TOP (solid shape): 87.54,93.65 87.54,92.38 87.39,92.24 80.88,92.24 80.63,92.49 80.63,93 81.01,93.38 81.39,93.38 81.9,93.89 87.3,93.89
GND on TOP (solid shape): 188.83,129.13 189.85,126.4 189.85,125.89 189.66,125.7 188.64,125.7 188.45,125.89 188.45,126.65 187.94,127.16 187.94,129.19 188,129.26 188.7,129.26
GND on TOP (solid shape): 205.22,141.01 240.57,141.01 240.57,140.21 204.42,140.21 204.42,149.6 187.42,149.6 187.42,140.11 197.54,113.8 197.9,113.8 197.9,113 196.97,113 186.62,139.9 186.62,150.4 205.22,150.4
GND on TOP (solid shape): 17.81,54.45 17.81,53.78 17.76,53.73 17.46,53.73 17.27,53.54 17.27,52.04 17.25,52.03 16.64,52.03 16.59,52.08 16.59,53.55 16.35,53.79 15.74,53.79 15.65,53.89 15.65,54.45 15.69,54.5 17.76,54.5
GND on TOP (solid shape): 76.99,97.71 76.99,96.73 74.78,94.52 66.91,94.52 66.51,94.92 66.51,96.37 66.66,96.52 74.49,96.52 74.91,96.93 74.91,97.57 75.19,97.85 76.85,97.85
GND on TOP (solid shape): 95.21,106.17 95.21,104.33 93.91,103.03 89.39,103.03 89.13,103.28 89.13,104.17 89.39,104.43 94,104.43 94.36,104.79 94.36,106.17 94.47,106.28 95.1,106.28
GND on TOP (solid shape): 64.05,143.6 78.05,143.6 78.05,131.59 63.05,131.59 63.05,100.4 39.55,100.4 39.55,141.55 40.35,141.55 40.35,101.2 62.25,101.2 62.25,132.39 77.25,132.39 77.25,142.8 63.25,142.8 63.25,149.6 50.91,149.6 50.91,150.4 64.05,150.4
GND on TOP (solid shape): 184.55,123.93 184.55,120.63 184.42,120.51 183.85,120.51 183.79,120.57 183.79,121.88 183.86,122.08 183.79,122.29 183.79,123.93 183.85,124 184.49,124
GND on TOP (solid shape): 48.38,149.45 48.58,149.45 48.58,142.24 48.03,141.69 42.09,141.69 42.09,142.62 39.3,142.62 39.3,150.4 39.38,150.57 39.55,150.65 48.38,150.65
GND on TOP (solid shape): 180.19,138.21 180.57,137.83 182.61,137.83 182.99,137.45 182.99,136.56 182.61,136.18 179.05,136.18 179.05,136.18 178.92,136.18 178.9,136.2 178.9,136.79 179.43,137.32 179.43,137.7 179.05,138.08 178.03,138.08 177.91,138.21 177.91,138.72 178.03,138.84 180.19,138.84
GND on TOP (solid shape): 61.7,121.83 61.7,114.33 61.17,113.8 59.12,113.8 58.65,114.27 58.65,116.49 58.78,116.62 60.43,116.62 60.56,116.75 60.56,117.38 60.31,117.64 58.53,117.64 58.27,117.89 58.27,121.95 58.4,122.08 61.45,122.08
GND on TOP (solid shape): 40.07,112.4 39.62,111.33 38.55,110.88 35.21,110.88 35.21,110.67 34.45,110.67 34.45,111.4 34.52,111.57 34.7,111.65 38.55,111.65 39.08,111.87 39.3,112.4 39.3,141.55 40.07,141.55
GND on TOP (solid shape): 5.48,45.2 12.25,45.2 12.55,45.2 12.55,44.9 12.55,44.9 12.55,38.27 12.55,11.97 11.75,11.97 11.75,37.93 9.87,37.93 9.35,38.46 8.41,38.46 8.37,38.47 8.35,38.48 8.34,38.5 8.34,38.53 8.34,38.55 8.41,38.64 8.5,38.74 8.58,38.85 8.66,38.97 8.74,39.09 8.8,39.21 8.86,39.34 8.91,39.47 8.95,39.61 8.99,39.74 9.02,39.88 9.04,40.02 9.05,40.16 9.05,40.3 9.05,40.44 9.04,40.58 9.02,40.72 8.99,40.85 8.96,40.99 8.91,41.12 8.86,41.25 8.8,41.38 8.74,41.51 8.67,41.63 8.59,41.74 8.5,41.85 8.41,41.96 8.31,42.06 8.21,42.15 8.2,42.16 11.2,42.16 11.2,43.87 9.47,43.87 9.47,42.16 8.2,42.16 8.1,42.24 7.99,42.33 7.87,42.4 7.75,42.47 7.62,42.53 7.49,42.59 7.36,42.63 7.22,42.67 7.09,42.71 6.95,42.73 6.81,42.75 6.67,42.75 6.6,42.75 4.25,42.75 4.23,42.75 4.19,42.76 4.15,42.78 4.11,42.8 4.08,42.83 4.05,42.86 4.03,42.9 4.01,42.94 4,42.98 4,43 4,44.12 5.3,44.12 5.3,45.2
GND on TOP (solid shape): 80.12,150.65 80.29,150.57 80.37,150.4 80.37,139.9 80.59,139.37 81.12,139.15 131.84,139.15 132.01,139.07 132.09,138.9 132.09,134.15 132.31,133.62 132.84,133.4 139,133.4 139.53,133.62 139.75,134.15 139.75,138.9 139.83,139.07 140,139.15 142.37,139.15 142.37,138.38 140.52,138.38 140.52,134.15 140.07,133.08 139,132.63 132.84,132.63 131.77,133.08 131.32,134.15 131.32,138.38 81.12,138.38 80.05,138.83 79.6,139.9 79.6,149.88 50.91,149.88 50.91,150.65
GND on TOP (solid shape): outline of 250 points within 23.65,50.24 26.46,54.15
GND on TOP (solid shape): outline of 86 points within 14.31,100.48 19.16,104.24
GND on TOP (solid shape): outline of 3685 points within 1.55,57.58 91.45,132.26
GND on BOTTOM (solid shape): 11.7,62.99 3.7,62.99 3.7,70.99 11.7,70.99
GND on BOTTOM (solid shape): 115.15,111.9 100.15,111.9 100.15,121.9 115.15,121.9
GND on BOTTOM (solid shape): 124.52,99.65 124.52,98.89 124.82,98.59 125.33,98.59 125.46,98.71 126.47,98.71 126.73,98.46 126.73,95.28 127.49,94.52 127.49,94.27 127.36,94.14 125.84,94.14 123.17,96.81 121.77,96.81 121.65,96.93 121.65,97.57 121.42,97.79 120.21,97.79 119.87,98.14 119.87,99.6 119.95,99.68 124.49,99.68
GND on BOTTOM (solid shape): 146.95,135.11 146.97,135.06 146.94,135 145.23,133.29 142.89,133.29 142.47,133.72 142.43,133.75 142.15,134.04 142.15,135.44 142.27,135.57 144.04,135.57 144.23,135.75 144.23,135.76 144.47,136 146.06,136
GND on IN1 (solid shape): 124.23,104.78 123.89,104.78 123.85,104.82 123.85,107.8 123.89,107.84 124.23,107.84
GND on IN1 (solid shape): 126.18,107.8 126.18,104.82 126.14,104.78 125.8,104.78 125.8,107.84 126.14,107.84
GND on IN1 (solid shape): 126.18,103.89 126.18,100.91 126.14,100.87 125.8,100.87 125.8,103.93 126.14,103.93
GND on IN1 (solid shape): 124.23,103.77 124.24,103.77 124.24,100.87 123.89,100.87 123.85,100.91 123.85,103.89 123.89,103.93 124.23,103.93
GND on IN1 (solid shape): 128.22,103.05 128.25,103.02 128.22,102.98 128.22,101.94 128.25,101.9 128.19,101.83 128.13,101.89 127.84,101.89 127.83,101.88 127.78,101.9 127.78,104.09 128.22,104.09
GND on IN1 (solid shape): 190.39,120.22 190.46,120.17 190.44,120.09 189.86,119.51 189.86,118.48 188.98,117.6 188.9,117.58 188.85,117.65 188.85,119.21 189.86,120.22
GND on IN1 (solid shape): 60.96,110.89 61.04,110.91 61.09,110.84 61.09,102.66 59.2,100.78 49.93,100.78 49.86,100.82 49.88,100.91 49.93,100.95 58.63,100.95 60.31,102.64 60.31,110.25
GND on IN1 (solid shape): 202.76,133.38 202.83,133.34 202.81,133.25 202.26,132.7 195.91,132.7 195.73,132.53 195.29,132.53 195.22,132.57 195.24,132.66 195.51,132.93 196.01,132.93 196.46,133.38
GND on IN1 (solid shape): 127.93,108.43 128.07,108.43 128.17,108.33 128.17,108.31 128.16,108.3 128.16,105.32 128.15,105.29 127.78,105.29 127.78,108.01 127.64,108.15 127.66,108.18 127.68,108.26 127.66,108.35 127.67,108.43 127.73,108.46 127.9,108.46
GND on IN1 (solid shape): 197.93,94.8 198.01,94.82 198.06,94.75 198.06,93.29 195.56,90.79 191.2,90.79 190.85,90.44 189.33,90.44 189.29,90.46 189.3,90.5 189.43,90.63 190.36,90.63 192.21,92.48 192.21,93.82 196.94,93.82
GND on IN1 (solid shape): 91.97,91.01 92.03,91.03 92.09,91 92.15,90.94 92.24,90.9 92.29,90.85 92.27,90.78 91.72,90.22 76.83,90.22 76.76,90.27 76.77,90.35 77.14,90.72 91.68,90.72
GND on IN1 (solid shape): 168.15,120.26 168.2,120.33 168.28,120.32 168.33,120.27 168.33,119.99 168.32,119.95 168.31,119.92 168.31,119.58 168.54,119.35 168.54,114.9 168.49,114.83 168.41,114.84 168.14,115.11 167.84,115.11 167.84,116.04 167.85,116.07 167.87,116.08 168.01,116.1 168.13,116.18 168.41,116.46 168.41,119.12 168.35,119.32 168.18,119.45 168.15,119.46
GND on IN1 (solid shape): 104.39,84.58 104.45,84.54 104.44,84.46 104.39,84.33 104.44,84.19 104.45,84.18 104.45,84.15 104.42,84.12 101.61,84.12 101.33,84.4 97.12,84.4 96.32,83.6 81.38,83.6 80.91,84.07 74.84,84.07 74.54,84.37 71.07,84.37 70.76,84.05 60.39,84.05 60.33,84.11 60.32,84.15 60.36,84.18 70.31,84.18 70.59,84.46 74.89,84.46 75.17,84.18 75.93,84.18 76.39,84.18 76.39,84.17 80.18,84.17 80.18,84.18 81.47,84.18 81.92,83.73 96.08,83.73 96.84,84.49 104.11,84.49 104.19,84.58
GND on IN1 (solid shape): 107,101.4 107.02,101.35 107,101.3 106.18,100.49 106.18,99.29 106.74,98.73 107.55,98.73 107.85,98.44 109.98,98.44 110.36,98.06 113.48,98.06 113.73,97.82 113.73,97.43 113.66,97.36 113.47,97.36 113.26,97.56 109.04,97.56 109.04,97.57 109.04,97.67 108.74,97.97 108.17,97.97 107.87,97.67 107.87,97.57 107.87,97.56 107.72,97.56 107.72,97.57 107.72,97.67 107.42,97.97 106.85,97.97 106.55,97.67 106.55,97.57 106.52,97.56 106.4,97.68 105.48,97.68 105.31,97.84 105.31,98.13 106.1,98.92 106.1,99.77 105.73,100.15 104.86,100.15 104.25,100.76 103.2,100.76 103.16,100.8 103.13,100.85 103.15,100.91 105.6,100.91 106.1,101.4
GND on IN1 (solid shape): 141.62,131.04 141.69,131.06 141.74,131 141.89,130.71 142.2,130.59 143.8,130.59 143.88,130.6 143.92,130.56 143.81,130.45 142.28,130.45 141.39,129.56 141.39,128.02 141.35,127.98 141.31,127.98 141.28,128.01 141.28,128.22 141.03,128.47 140.31,128.47 140.25,128.5 140.24,128.57 140.25,128.71 140.2,128.84 141.3,129.94 141.3,130.19 141.3,130.19 141.3,130.52 141.3,130.52 141.3,130.73
GND on IN1 (solid shape): 168.59,120.04 168.61,120.07 168.66,120.06 169.57,119.15 170.51,119.15 171.4,118.26 171.92,118.26 172.85,117.33 172.85,116.45 172.82,116.42 172.43,116.64 172.67,116.26 172.67,112.78 172.62,112.71 172.54,112.72 171.03,114.23 168.98,114.23 168.83,114.37 168.83,119.47 168.61,119.7 168.61,119.92 168.6,119.95 168.59,119.99
GND on IN1 (solid shape): 148.23,118.32 148.32,118.31 148.42,118.2 148.42,117.77 149.49,116.71 149.51,116.62 149.44,116.58 148.82,116.58 148.74,116.63 148.73,116.73 148.76,116.87 148.69,117 148.68,117.01 148.68,117.04 148.19,117.53 147.07,117.53 146.91,117.69 146.89,117.8 146.98,117.86 147.83,117.86 148.1,117.98 148.19,118.25
GND on IN1 (solid shape): 193.45,120.22 193.49,120.24 193.51,120.24 193.54,120.23 193.56,120.22 193.57,120.2 193.58,120.16 193.58,117.01 188.46,111.88 188.43,111.86 188.4,111.86 188.38,111.87 188.35,111.88 188.34,111.9 188.33,111.94 188.33,114.54 191.72,117.94 191.72,118.49 191.86,118.63 192.46,118.63 192.46,118.57 192.47,118.52 192.49,118.47 192.51,118.43 192.54,118.39 192.58,118.35 192.62,118.32 192.67,118.29 192.72,118.28 192.77,118.27 192.82,118.27 192.87,118.28 192.92,118.29 192.97,118.32 193.01,118.35 193.04,118.39 193.07,118.43 193.1,118.47 193.11,118.52 193.12,118.57 193.12,118.63 193.11,118.68 193.1,118.73 193.07,118.77 193.04,118.82 193.01,118.85 192.97,118.88 192.92,118.91 192.87,118.92 192.82,118.93 192.77,118.93 192.72,118.92 192.67,118.91 192.62,118.88 192.58,118.85 192.54,118.82 192.51,118.77 192.49,118.73 192.47,118.68 192.46,118.63 191.86,118.63
GND on IN1 (solid shape): 151.6,128.72 151.6,128.65 150.96,128.01 150.96,125.47 149.81,124.32 149.74,124.3 149.69,124.36 149.6,124.49 149.45,124.54 149.44,124.54 149.4,124.58 149.4,126.13 149.45,126.2 149.53,126.19 149.61,126.15 149.71,126.15 149.77,126.13 149.8,126.07 149.8,125.82 149.74,125.76 149.72,125.76 149.55,125.37 149.94,125.54 149.94,125.56 150.09,125.7 150.09,125.73 150.14,125.8 150.22,125.79 150.35,125.66 150.35,125.64 150.74,125.47 150.57,125.87 150.56,125.87 150.28,126.14 150.28,126.66 150.01,126.93 150.01,128.67 150.25,128.91 151.42,128.91
GND on IN1 (solid shape): 110.39,94.59 110.47,94.61 110.52,94.54 110.53,94.5 110.54,94.47 110.53,94.4 110.46,94.36 109.25,94.36 109.09,94.2 106.44,94.2 106.15,93.91 106.15,93.77 106.13,93.76 106.04,93.42 106.38,93.38 106.41,93.39 106.43,93.38 106.7,93.36 106.81,93.6 106.82,93.67 106.88,93.69 109.39,93.69 109.45,93.76 110.85,93.76 111.11,93.51 111.91,93.51 111.89,93.47 111.84,93.32 111.9,93.17 111.92,93.09 111.85,93.04 110.82,93.04 110.52,93.35 107.19,93.35 106.67,92.83 106.03,92.83 105.87,92.92 105.7,92.86 105.67,92.85 105.64,92.86 105.45,92.92 105.29,92.8 105.23,92.77 105.16,92.8 105.11,92.87 105.04,92.91 105.02,92.92 105.02,93.39 104.86,93.54 104.86,94.4 104.99,94.53 110.33,94.53
GND on IN1 (solid shape): 147.3,130.01 147.38,129.99 147.43,129.94 148.3,129.94 148.3,126.93 148.26,126.89 148.23,126.84 148.22,126.81 148.16,126.81 148.16,126.91 147.7,127.36 147.24,126.91 147.24,125.31 147.7,124.85 148.16,125.31 148.16,126.53 148.2,126.6 148.29,126.59 148.43,126.53 148.58,126.57 148.66,126.58 148.7,126.51 148.7,126.17 148.67,126.17 148.5,125.88 148.8,125.73 148.87,125.72 148.91,125.66 148.91,125.37 147.35,123.81 147.27,123.79 147.22,123.86 147.22,124.45 146.63,125.04 146.63,129.58 146.67,129.65 146.75,129.65 147.09,129.64 147.25,129.93
GND on IN1 (solid shape): 161.8,128.38 161.85,128.45 161.93,128.43 161.97,128.39 166.28,128.39 166.51,128.15 166.51,127.8 166.51,127.77 166.52,127.73 166.52,127.37 166.41,127.37 166.33,127.46 166.33,128.05 166.1,128.28 165.87,128.05 165.87,127.5 165.82,127.43 165.74,127.45 165.55,127.63 165.55,127.83 165.54,128.19 165.19,128.08 165.19,128.08 165.16,128.04 165.12,128.08 164.87,128.14 164.73,127.93 164.69,127.87 164.63,127.86 164.44,127.85 164.28,127.74 164.23,127.71 164.17,127.73 163.77,127.77 163.62,127.39 163.61,127.33 163.55,127.29 163.5,127.29 163.5,127.34 163.5,127.35 163.43,127.66 163.12,127.6 163.06,127.56 163,127.59 162.55,128.04 161.95,128.04 161.89,128.03 161.83,128.05 161.8,128.11
GND on IN1 (solid shape): outline of 182 points within 151.12,114.15 163.86,119.6
GND on IN1 (solid shape): outline of 293 points within 98.21,98.16 104.76,107.31
GND on IN1 (solid shape): outline of 349 points within 189.22,89.8 199.42,102.54
GND on IN1 (solid shape): outline of 400 points within 160.01,125.86 196,137.28
GND on IN1 (solid shape): outline of 609 points within 177.33,109.58 197.34,126.85
GND on GND1 (solid shape): 142.32,78.33 142.16,78.33 141.84,78.45 141.67,78.75 139.1,80.93 136.53,78.75 136.36,78.45 136.04,78.33 135.79,78.33 135.79,81.87 142.32,81.87
GND on GND1 (solid shape): 44.28,78.49 43.7,78.86 43.29,79.4 42.76,80.07 39.35,79.63 40.18,76.29 40.68,75.92 41.04,75.41 37.87,75.41 37.87,81.44 44.28,81.44
GND on IN2 (solid shape): 162.25,107 163.56,107 163.63,106.95 163.61,106.87 163.5,106.76 159.52,106.76 159.27,106.51 159.27,105.68 159.24,105.64 154.17,105.64 153.72,106.09 153.72,107.61 152.22,109.11 152.22,109.54 152.49,109.81 159.44,109.81
GND on IN2 (solid shape): 205.04,123.84 205.11,123.81 205.11,123.73 205.1,123.71 204.85,123.71 204.46,123.32 204.46,122.88 204.29,122.71 202.79,122.71 202.73,122.65 202.65,122.63 202.6,122.7 202.6,123.02 203.21,123.63 204.6,123.63 204.82,123.84
GND on IN2 (solid shape): 13.72,79.8 13.76,79.81 13.79,79.77 13.79,79.68 12.36,78.26 12.36,73.6 11.69,72.93 11.61,72.55 11.98,72.27 11.97,72.19 7.54,67.76 7.04,67.76 6.9,67.9 6.9,68.63 12.19,73.91 12.19,78.27
GND on IN2 (solid shape): 198.83,128.53 198.9,128.55 198.96,128.5 199.04,128.37 199.17,128.29 199.22,128.24 199.2,128.17 197.3,126.27 196.39,126.27 190.21,120.09 190.01,120.09 189.31,119.39 185.04,119.39 184.69,119.73 179.22,119.73 175.75,116.27 175.66,116.25 175.62,116.33 175.62,116.39 179.14,119.91 184.77,119.91 185.11,119.56 189.18,119.56 190.01,120.39 190.25,120.39 196.71,126.84 197.62,126.84 198.52,127.74 198.52,128.22
GND on IN2 (solid shape): 203.16,134.24 203.16,133.48 200.68,131 195.77,131 194.59,129.81 194.05,129.81 193.9,129.66 193.82,129.64 193.77,129.72 193.77,130.33 193.94,130.5 194.3,130.5 194.91,131.11 194.99,131.13 195.04,131.08 195.5,130.87 195.64,131.35 196.02,131.35 197.23,132.56 197.23,134.19 197.98,134.94 202.46,134.94
GND on IN2 (solid shape): 211.96,132.49 212.03,132.44 212.01,132.36 212,132.34 211.98,132.31 210.26,132.31 209.19,131.24 208.25,131.24 206.64,129.63 202.22,129.63 202.03,129.44 199.34,129.44 198.24,128.34 198.24,127.86 197.5,127.13 196.59,127.13 190.56,121.1 190.47,121.08 190.43,121.16 190.42,121.26 190.38,121.36 190.37,121.43 190.43,121.48 190.91,121.65 190.65,122.09 195.22,126.65 195.29,126.65 195.94,127.3 197.43,127.3 198.06,127.93 198.06,128.41 199.12,129.47 199.25,129.61 201.94,129.61 202.15,129.81 206.16,129.81 207.84,131.49 209.19,131.49 210.19,132.49
GND on IN2 (solid shape): outline of 213 points within 146.24,110.57 151.82,112.46
GND on GND2 (solid shape): 142.26,78.33 142.16,78.33 141.84,78.45 141.67,78.75 139.1,80.93 136.53,78.75 136.36,78.45 136.04,78.33 135.72,78.33 135.72,81.96 142.26,81.96
GND on GND2 (solid shape): 44.28,78.49 43.7,78.86 43.29,79.4 42.76,80.07 39.35,79.63 40.18,76.29 40.68,75.92 41.04,75.41 37.87,75.41 37.87,81.44 44.28,81.44
GND on GND3 (solid shape): 142.34,78.33 142.16,78.33 141.84,78.45 141.67,78.75 139.1,80.93 136.53,78.75 136.36,78.45 136.04,78.33 135.96,78.33 135.96,81.99 142.34,81.99
GND on GND3 (solid shape): 44.28,78.49 43.7,78.86 43.29,79.4 42.76,80.07 39.35,79.63 40.18,76.29 40.68,75.92 41.04,75.41 37.87,75.41 37.87,81.44 44.28,81.44
GND on GND4 (solid shape): 142.35,78.33 142.16,78.33 141.84,78.45 141.67,78.75 139.1,80.93 136.53,78.75 136.36,78.45 136.04,78.33 135.67,78.33 135.67,81.82 142.35,81.82
GND on GND4 (solid shape): 44.28,78.49 43.7,78.86 43.29,79.4 42.76,80.07 39.35,79.63 40.18,76.29 40.68,75.92 41.04,75.41 37.87,75.41 37.87,81.44 44.28,81.44
GND on VCC (solid shape): 254.44,106.72 254.61,106.65 254.69,106.47 254.69,105 254.61,104.83 254.44,104.75 250.2,104.75 250.2,104.76 236.99,104.76 236.99,105.52 250.2,105.52 250.2,106.22 250.6,106.31 250.89,106.6 250.98,106.69 251.11,106.72
GND on VCC (solid shape): 147.36,137.58 147.36,136.8 147.12,136.56 145.58,136.56 145.33,136.8 145.33,136.95 146.44,136.95 146.44,136.91 146.45,136.86 146.47,136.83 146.49,136.79 146.52,136.76 146.56,136.74 146.59,136.72 146.64,136.71 146.68,136.71 146.72,136.72 146.76,136.73 146.8,136.75 146.83,136.78 146.86,136.81 146.88,136.85 146.89,136.89 146.9,136.93 146.89,136.97 146.89,136.99 146.92,136.99 146.97,136.99 147.02,137 147.07,137.02 147.11,137.05 147.15,137.08 147.19,137.12 147.21,137.16 147.24,137.21 147.25,137.26 147.25,137.31 147.25,137.36 147.24,137.41 147.22,137.46 147.2,137.5 147.17,137.54 147.13,137.58 147.09,137.61 147.04,137.63 146.99,137.65 146.94,137.65 146.89,137.65 146.84,137.64 146.79,137.62 146.74,137.6 146.7,137.57 146.67,137.53 146.64,137.49 146.61,137.44 146.6,137.39 146.59,137.34 146.59,137.29 146.6,137.24 146.62,137.19 146.63,137.17 146.61,137.16 146.57,137.15 146.53,137.13 146.5,137.1 146.47,137.07 146.45,137.03 146.44,136.99 146.44,136.95 145.33,136.95 145.33,137.59 145.58,137.83 147.12,137.83
GND on VCC (solid shape): outline of 290 points within 1.55,42.75 12.64,111.64
GND on VCC (solid shape): outline of 120 points within 38.54,19.97 207.78,86.34
GND on VCC (solid shape): outline of 1772 points within 34.28,104.72 256.25,150.65
GND on TOP: 182.04,119.36 181.92,119.25 179.83,119.25 179.75,119.32 179.75,120.53 179.89,120.67 181.83,120.67 182.04,120.46
GND on TOP: 160.76,121.83 163.05,121.83 163.3,121.57 163.3,121.19 163.18,121.06 160.76,121.06 160.64,121.19 160.64,121.7
GND on TOP: 179.18,132.37 180.45,132.37 180.57,132.24 180.57,131.48 180.45,131.35 179.18,131.35 179.05,131.48 179.05,132.24
GND on TOP: 184,133.38 187.05,133.38 187.69,132.75 187.69,131.1 187.43,130.84 184.51,130.84 184,131.35
GND on TOP: 85.2,123.22 85.2,121.95 84.94,121.7 83.42,121.7 83.29,121.83 83.29,122.21 83.04,122.46 82.15,122.46 81.9,122.21 81.9,121.64 82.11,121.42 82.11,120.85 82.07,120.81 80.44,120.81 80.18,121.06 78.21,121.06 77.77,120.62 77.77,118.08 77.7,118.02 76.88,118.02 76.82,118.08 76.82,121.32 78.09,122.59 78.09,122.86 78.44,123.22 78.92,123.22 78.97,123.27 78.97,123.47 80.89,125.39 83.86,125.39 84.1,125.15 84.1,124.32
GND on TOP: outline of 91 points within 63.53,87.03 155.73,150.65 ; 4 cut-outs
GND on TOP: 33.51,84.49 36.17,84.49 36.3,84.35 36.3,61.6 32.11,61.6 32.11,64.17 31.1,65.18 31.1,70.77 33,72.68 33,83.98
GND on TOP: 106.91,105.82 111.23,105.82 111.36,105.7 111.36,105.06 111.61,104.81 112.44,104.81 112.5,104.75 112.5,104.3 111.49,104.3 110.75,105.04 106.81,105.04 106.76,105.09 106.76,105.67
GND on TOP: 123.79,104.11 123.79,101.01 123.93,100.87 126.09,100.87 126.22,101 126.22,101.21 126.27,101.26 126.27,104.11
GND on TOP: 114.03,97.44 114.03,98.08 113.9,98.2 110.34,98.2 110.09,98.46 106.6,98.46 106.5,98.55 103.32,98.55 103.22,98.45 103.22,97.43 103.33,97.32 107.99,97.32 108.1,97.21 110.62,97.21 110.73,97.32 113.9,97.32
GND on TOP: 116.34,78.58 116.22,78.7 116.22,79.09 117.18,80.04 134.04,80.04 136.87,82.87 143,82.87 146.12,85.99 146.12,87.29 146.34,87.51 148.06,87.51 148.36,87.22 152.57,87.22 153.24,87.89 170.38,87.89 171.11,88.63 196.3,88.63 196.36,88.69 196.36,92.96 197.06,93.66 197.06,102.24 197.39,102.57 202.93,102.57 202.93,83.27 202.93,83.19 202.89,83.07 202.8,82.98 202.65,81.79 203.83,81.95 203.92,82.04 204.05,82.07 207.54,82.07 207.63,82.06 207.7,82.01 207.76,81.93 207.79,81.83 207.79,80.33 207.71,80.16 207.54,80.08 173.54,80.08 173.37,80.16 173.29,80.33 173.29,82.33 173.07,82.86 172.54,83.08 160.96,83.08 160.8,83.14 160.71,83.29 159.78,84.93 158,85.58 153,85.58 151.22,84.93 150.28,83.29 150.2,83.14 150.04,83.08 144.75,83.08 144.22,82.86 144,82.33 144,78.83 143.92,78.66 143.75,78.58 141.72,78.58 141.69,78.66 141.67,78.75 139.99,80.77 137.41,80.31 137.07,79.95 136.8,79.54 136.63,79.16 136.53,78.75 136.51,78.66 136.48,78.58
GND on TOP: 123.28,105.19 123.28,105.77 123.23,105.82 119.97,105.82 119.84,105.7 119.84,105.34 120.05,105.14 120.27,105.14 120.3,105.11 123.14,105.11 123.17,105.14 123.23,105.14
GND on TOP: 16.01,98.83 17.99,98.83 18.08,98.74 18.08,98.03 18.47,97.63 18.74,97.63 19.34,98.23 19.64,98.23 19.81,98.4 19.81,98.93 20.39,99.51 27.55,99.51 27.71,99.36 27.71,95.87 26.88,95.04 25.63,95.04 25.43,95.25 25.43,95.97 17.08,95.97 15.7,97.34 15.7,98.52
GND on TOP: 186.42,107.6 186.67,107.35 192.26,107.35 192.89,107.98 192.89,108.87 192.64,109.13 192,109.13 191.88,109 186.54,109 186.42,108.87
GND on TOP: 123.28,107.42 123.28,108.01 123.23,108.06 119.92,108.06 119.79,107.93 119.79,107.53 119.97,107.35 123.14,107.35 123.17,107.37 123.23,107.37
GND on TOP: 186.42,113.83 186.42,112.94 186.54,112.81 191.5,112.81 191.75,113.06 191.75,114.97 191.5,115.22 187.94,115.22 187.69,114.97 187.69,114.08 187.56,113.95 186.54,113.95
GND on TOP: 123.28,102.95 123.28,103.54 123.23,103.59 120.3,103.59 120.29,103.58 119.96,103.58 119.87,103.49 119.87,103.18 120.15,102.9 120.27,102.9 120.3,102.88 123.14,102.88 123.17,102.9 123.23,102.9
GND on TOP: 138.66,91.68 147.33,91.68 147.33,91.83 147.45,91.96 148.14,91.96 148.24,91.85 148.24,89.11 147.99,88.86 147.06,88.86 145.91,90.01 145.88,90.01 145.12,90.77 141.56,90.77 140.8,90.01 139.11,90.01 139.01,90.11 139.01,90.52 138.59,90.94 138.59,91.6
GND on TOP: 124.59,83.7 123.32,83.7 123.18,83.56 123.18,82.17 123.03,82.01 122.33,82.01 122.2,82.14 122.2,83.24 122.15,83.29 122.06,83.29 122,83.23 122,82.04 122.22,81.83 124.23,81.83 124.87,82.47 124.87,83.42
GND on TOP: 123.28,101.84 123.28,102.42 123.23,102.47 120.3,102.47 120.3,102.47 119.97,102.47 119.87,102.37 119.87,101.99 120.1,101.76 123.14,101.76 123.17,101.78 123.23,101.78
GND on TOP: 12.71,54.02 12.71,54.06 12.73,54.09 12.73,54.34 12.8,54.41 13.03,54.41 13.12,54.31 13.12,53.83 13.11,53.75 13.12,53.67 13.12,52.59 13.03,52.34 13.12,52.1 13.12,50.57 13.04,50.49 10.41,50.49 10.32,50.58 10.32,53.92 10.47,54.07 12.65,54.07
GND on TOP: 178.29,116.62 180.7,116.62 181.72,117.64 181.72,117.81 181.41,118.12 181.41,118.83 181.21,119.03 179.13,119.03 178.88,118.78 178.88,118.09 178.81,118.02 178.61,118.02 178.54,117.94 178.54,117.47 178.16,117.09 178.16,116.75
GND on TOP: 76.52,94.15 77.51,93.16 77.51,92.18 77.43,92.1 66.95,92.1 66.95,92.1 66.38,92.1 66.17,92.3 66.17,94.04 66.29,94.15
GND on TOP: 129.72,107.96 129.72,106.15 130.34,106.15 130.52,105.98 130.52,105.13 130.37,104.97 130.37,104.54 131.6,104.54 131.65,104.59 131.65,107.91 131.6,107.96 131.38,107.96 131.21,108.13 130.72,108.13 130.55,107.96
GND on TOP: 81.77,115.36 79.97,115.36 79.34,115.98 79.34,116.76 79.43,116.85 81.53,116.85 81.81,116.57 81.81,115.4
GND on TOP: 104.76,95.54 110.34,95.54 110.47,95.41 110.47,94.65 110.34,94.52 108.44,94.52 108.06,94.14 107.8,94.14 107.62,93.96 107.45,93.96 107.42,93.94 107.42,93.25 107.21,93.04 106.04,93.04 105.86,93.22 105.45,93.22 105.38,93.29 105.38,93.98 105.23,94.13 104.77,94.13 104.5,94.39 104.5,95.28
GND on TOP: 160.76,105.44 160.64,105.57 160.04,105.57 159.88,105.41 159.64,105.41 159.49,105.56 159.49,106.33 159.69,106.53 161.86,106.53 162.03,106.36 162.03,106.08 162.92,105.19 163.35,105.19 163.55,104.99 163.55,103.91 163.3,103.67 162.29,103.67 162.16,103.79 162.16,104.81 161.98,104.99 161.39,104.99 160.93,105.44
GND on TOP: 161.4,117.38 162.92,117.38 163.18,117.64 163.18,118.65 162.54,119.29 161.65,119.29 161.4,119.03 161.4,118.14 161.27,118.02 161.27,117.51
GND on TOP: 155.68,112.99 155.68,111.54 155.56,111.41 154.79,111.41 154.67,111.54 154.67,113.13 154.7,113.16 155.51,113.16
GND on TOP: 235.7,150.65 233.5,143.75 231.29,150.65
GND on TOP: 186.92,119.29 191.75,119.29 191.88,119.16 191.88,118.21 191.75,118.08 186.92,118.08 186.8,118.21 186.8,119.16
GND on TOP: 20.17,40.67 19.79,41.05 19.79,41.44 20.3,41.94 22.08,41.94 22.59,42.45 22.59,44.74 22.71,44.86 22.84,44.86 23.48,44.23 25.13,44.23 25.25,44.36 25.51,44.36 26.4,45.25 28.94,45.25 29.44,44.74 29.44,42.45 30.21,41.69 30.21,40.93 29.95,40.67 26.78,40.67 26.78,41.23 26.21,41.23 26.21,40.67 ; 5 cut-outs
GND on TOP: 112.45,85.76 113.75,85.76 113.82,85.83 113.82,86.65 113.44,87.03 113.29,87.03 113.19,86.93 112.91,86.93 112.76,87.08 112.38,87.08 112.35,87.06 112.35,86.76 112.4,86.71 112.4,85.81
GND on TOP: 79.41,113.22 79.7,113.22 79.93,113.44 85.45,113.44 86.21,112.68 86.21,110.78 85.93,110.5 83.88,110.5 83.75,110.64 83.75,111.16 83.65,111.26 82.25,111.26 82.09,111.1 82.09,110.82 82.43,110.47 82.43,109.96 80.93,109.96 80.31,110.58 78.64,110.58 78.43,110.79 78.43,111.97 78.54,112.09 78.54,112.35
GND on TOP: 162.87,130.84 163.81,130.84 163.94,130.72 163.94,129.83 163.77,129.66 162.96,129.66 162.81,129.81 162.81,130.78
GND on TOP: 174.98,115.46 174.98,115.32 175.1,115.21 175.24,115.21 175.62,114.82 175.62,110.41 175.37,110.16 174.48,110.16 174.47,110.17 174.47,110.76 174.48,110.78 174.48,113.01 173.39,114.1 172.66,114.1 172.65,114.12 172.58,114.12 172.29,114.4 172.29,115 172.48,115.19 174.04,115.19 174.4,115.55 174.9,115.55
GND on TOP: 113.06,101.89 114.79,101.89 114.92,101.76 114.92,101.25 114.03,100.36 110.6,100.36 110.34,100.11 109.58,100.11 109.45,100.24 109.45,101 109.2,101.25 107.09,101.25 106.53,100.69 106.53,100.13 106.48,100.08 106.09,100.08 105.62,99.61 104.71,99.61 104.68,99.64 104.68,100.54 106.41,102.27 107.17,102.27 107.42,102.01 110.75,102.01 111.23,102.5 112.45,102.5
GND on TOP: 115.55,128.56 116.31,128.56 116.44,128.68 116.44,130.08 117.33,130.97 117.33,131.1 117.2,131.22 113.73,131.22 113.73,130.02 114.14,129.61 114.14,129.04 114.09,128.99 113.61,128.99 113.41,129.19 112.88,129.19 112.72,129.35 111.61,129.35 111.36,129.1 109.56,129.1 109.49,129.03 109.49,127.35 109.6,127.24 112.08,127.24 112.5,127.67 112.5,128.18 112.76,128.43 113.39,128.43 113.53,128.57 115.54,128.57
GND on TOP: 13.72,24.7 13.04,24.7 12.81,24.93 12.81,35.69 13.05,35.93 14.85,35.93 15.14,36.23 15.94,36.23 16.03,36.14 16.03,35.39 15.87,35.24 15.37,35.24 15.09,34.96 15.09,32.93 15.1,32.92 15.1,32.82 14.99,32.72 14.99,30.6 14.22,29.83 14.22,28.98 14.05,28.81 14.05,28.16 13.96,28.08 13.96,24.85 13.82,24.7 13.73,24.7
GND on TOP: 180.7,98.33 192.6,98.33 192.75,98.18 192.75,97.35 192.66,97.26 180.89,97.26 180.5,97.65 180.5,98.13
GND on TOP: 17.69,47.96 17.02,47.96 16.79,48.2 16.79,49.98 16.89,50.09 17.27,50.09 17.39,49.98 17.39,49.24 17.72,48.91 17.72,47.99
GND on TOP: 94.48,121.91 94.66,122.08 95.73,122.08 95.91,121.91 95.91,113.41 95.43,112.94 92.44,112.94 92.18,113.19 92.18,113.95 92.56,114.33 94.43,114.33 94.76,114.66 94.76,116.93 94.48,117.21
GND on TOP: 123.28,106.31 123.28,106.89 123.23,106.94 119.94,106.94 119.82,106.82 119.82,106.36 119.92,106.26 120.27,106.26 120.3,106.23 123.14,106.23 123.17,106.26 123.23,106.26
GND on TOP: 85.83,91.85 89.36,91.85 89.81,91.41 89.81,87.14 90.91,86.04 90.91,84.23 90.53,83.85 85.55,83.85 85.34,84.07 85.34,91.36
GND on TOP: 61.7,101.89 61.54,101.72 52.47,101.72 52.31,101.89 52.31,103.07 52.47,103.23 59.22,103.23 59.36,103.09 60.22,103.09 60.28,103.09 60.31,103.12 60.31,109.43 60.44,109.56 61.46,109.56 61.7,109.32
GND on TOP: 123.55,128.14 123.01,128.14 122.03,129.13 122.03,129.82 122.08,129.87 122.72,129.87 122.76,129.82 122.76,129.18 123.02,128.92 123.54,128.92 123.62,128.84 123.62,128.22
GND on TOP: 153.65,128.05 154.29,128.05 154.41,127.92 154.41,126.4 154.29,126.27 154.07,126.27 153.95,126.15 150.34,126.15 149.97,126.53 149.97,128.81 150.09,128.94 151.11,128.94 151.24,128.81 151.24,127.92 151.24,127.92 151.24,127.82 151.52,127.54 153.14,127.54
GND on TOP: 162.03,91.35 162.03,89.82 161.65,89.44 158.47,89.44 158,89.9 158,91.5 158.23,91.73 161.65,91.73
GND on TOP: 149.71,114.4 149.59,114.52 149.59,118.78 149.97,119.16 153.41,119.16 153.61,119.37 154.79,119.37 155.3,119.88 155.3,120.38 155.39,120.46 156.06,120.46 156.14,120.39 156.14,118.98 155.85,118.69 154.62,118.69 154.33,118.4 151.49,118.4 151.11,118.02 151.11,114.52 150.98,114.4
GND on TOP: 123.74,104.55 123.74,108.05 126.28,108.05 126.28,104.55
GND on TOP: 36.84,56.69 36.13,55.98 33.08,55.98 32.66,55.56 32.66,51.96 33.08,51.54 35.85,51.54 36.81,50.58 36.81,43.85 36.94,43.72 39.96,43.72 40.06,43.82 40.06,56.6 39.97,56.69
GND on TOP: 124.41,93.33 126.8,93.33 126.87,93.39 126.87,95.43 126.79,95.51 126,95.51 125.93,95.43 125.93,94.12 125.83,94.02 124.54,94.02 124.37,93.86 124.37,93.37
GND on TOP: 151.58,96.26 151.09,96.26 150.72,95.89 150.72,94.48 150.41,94.18 150.41,93.4 150.5,93.32 151.09,93.32 151.17,93.4 151.71,93.4 151.75,93.44 151.75,93.85 151.64,93.95 151.64,96.2
GND on TOP: outline of 137 points within 186.04,103.19 256.25,150.65 ; 17 cut-outs
GND on TOP: 127.75,105.14 127.75,108.36 127.84,108.45 128.09,108.45 128.22,108.31 128.22,105.14
GND on TOP: 107.78,86.75 106.46,86.75 106.29,86.58 106.29,82.63 106.51,82.42 107.7,82.42 107.82,82.53 107.82,86.71
GND on TOP: 127.75,104.13 127.75,101.66 128.48,101.66 128.48,104.13
GND on TOP: 128.72,107.55 128.72,105.15 129.02,105.15 129.2,104.97 129.2,104.58 129.52,104.58 129.7,104.4 129.7,103.7 129.57,103.58 129.57,103.51 131.62,103.51 131.71,103.6 131.71,104.04 131.65,104.1 130.46,104.1 130.25,104.3 130.25,104.96 130.42,105.13 130.42,105.25 130.36,105.32 129.84,105.32 129.78,105.37 129.78,105.79 129.71,105.86 129.34,105.86 129.23,105.98 129.23,107.55
GND on TOP: 150.22,110.14 150.98,110.14 151.32,109.8 151.32,104.26 151.11,104.05 150.22,104.05 150.09,104.17 150.09,110.02
GND on TOP: 52.69,118.42 52.69,115.48 53.07,115.1 53.07,114.33 52.94,114.21 52.16,114.21 51.93,114.44 51.93,114.56 51.69,114.81 51.16,114.81 50.51,115.45 50.51,118.36 50.69,118.53 52.58,118.53
GND on TOP: 136.74,87.89 134.55,87.89 134.43,88.02 134.43,89.04 134.52,89.13 136.33,89.13 136.84,88.62 136.84,88
GND on TOP: 14.15,24.61 14.14,24.62 14.14,27.97 14.26,28.09 14.26,28.66 14.38,28.79 14.38,29 14.37,29.01 14.37,29.7 15.09,30.42 15.09,32.28 15.11,32.29 15.64,32.29 15.79,32.14 15.79,29.87 16.05,29.61 19.35,29.61 20.16,30.42 20.41,30.42 20.52,30.53 20.52,30.82 20.59,30.88 20.81,30.88 20.85,30.84 20.85,30.25 20.85,30.25 20.85,30.22 20.74,30.11 20.5,30.11 19.16,28.77 15.57,28.77 14.66,27.86 14.66,24.66 14.61,24.61
GND on TOP: 178.16,133.51 178.67,133.51 178.8,133.38 178.8,131.35 178.67,131.22 178.16,131.22 178.03,131.35 178.03,133.38
GND on TOP: 49.75,105.29 49.75,105.67 50.4,106.32 50.97,106.32 51.08,106.21 51.08,105.65 50.6,105.17 49.88,105.17
GND on TOP: 182.67,138.39 154.16,138.39 154.01,138.54 154.01,139.15 185.62,139.15 186.15,139.37 186.37,139.9 186.37,150.4 186.45,150.57 186.62,150.65 205.87,150.65 205.87,150.1 205.72,149.94 187.26,149.94 187.13,149.82 187.13,139.07 186.16,138.11 182.95,138.11
GND on TOP: 123.28,104.07 123.28,104.66 123.23,104.71 120.1,104.71 119.87,104.48 119.87,104.1 119.95,104.02 120.27,104.02 120.3,103.99 123.14,103.99 123.17,104.02 123.23,104.02
GND on TOP: 178.4,128.43 178.54,128.28 178.54,126.65 178.17,126.28 177.3,126.28 177.27,126.3 177.27,128.18 177.28,128.18 177.28,128.34 177.37,128.43
GND on TOP: 163.83,98.36 168.59,98.36 168.86,98.09 168.86,94.83 168.66,94.63 164.49,94.63 164.05,95.08 163.73,95.08 163.58,95.22 163.58,98.11
GND on TOP: 7,0.25 6.83,0.33 6.75,0.5 6.75,3.85 6.81,4 6.95,4.09 8.94,6.73 6.5,8.95 0.5,8.95 0.33,9.03 0.25,9.2 0.25,9.37 11.84,9.37 11.84,8.31 12.02,8.14 14.56,8.14 14.99,8.57 32.04,8.57 32.32,8.29 32.32,7.54 32.3,7.53 32.3,0.25 ; 1 cut-out
GND on TOP: 127.28,101.8 127.28,108.06 126.74,108.06 126.74,101.8
GND on TOP: 163.56,112.94 163.68,112.81 163.68,110.51 163.35,110.17 163.18,110.17 162.9,109.89 161.79,109.89 161.78,109.9 161.78,111.03 161.4,111.41 160.89,111.41 160.89,111.41 159.24,111.41 159.24,111.42 159.19,111.42 159.12,111.49 159.12,112.11 159.2,112.19 159.85,112.19 160.01,112.34 160.01,112.88 160.06,112.94
GND on BOTTOM: 125.91,108.69 126.65,108.69 126.85,108.49 126.85,107.98 126.73,107.86 126.47,107.86 126.35,107.73 126.35,99.93 126.32,99.91 125.86,99.91 125.84,99.93 125.84,108.62
GND on BOTTOM: outline of 251 points within 33.08,104.75 256.25,150.65 ; 3 cut-outs
GND on BOTTOM: outline of 110 points within 26.92,16.49 207.79,101.13 ; 8 cut-outs
GND on BOTTOM: 118.24,106.84 123.25,106.84 123.3,106.79 123.3,106.43 123.25,106.38 118.24,106.38 118.22,106.41 118.22,106.82
GND on BOTTOM: 200.39,142.49 201.45,142.49 202.01,141.93 202.01,138.11 201.1,137.19 198.61,137.19 198.19,137.61 198.19,140.29
GND on BOTTOM: 94.34,133.51 91.8,133.51 90.79,132.49 90.79,130.08 91.12,129.75 97.02,129.75 97.71,129.07 99.42,129.07 99.55,129.19 99.55,129.32 98.79,130.08 98.58,130.08 97.05,131.62 95.33,131.62 94.8,132.15 94.8,133.27 95.28,133.75 96.34,133.75 97.21,132.87 99.63,132.87 101.15,131.35 105.9,131.35 108.06,133.51 108.06,133.64 107.93,133.76 107.36,133.76 106.54,132.95 104.25,132.95 102.65,134.55 102.44,134.55 102.44,134.55 101.43,134.55 101.27,134.71 95.54,134.71
GND on BOTTOM: 29.83,69.38 32.37,71.92 34.65,71.92 35.16,71.41 35.16,69.5 37.57,67.09 37.57,65.57 36.94,64.93 30.46,64.93 28.05,67.34 23.35,67.34 22.84,66.84 22.84,64.3 22.59,64.04 17.89,64.04 17.63,64.3 17.63,68.11 18.9,69.38
GND on BOTTOM: 125.72,128.41 116.54,128.41 116.51,128.43 115.73,128.43 115.68,128.43 115.63,128.42 115.49,128.56 115.49,129.23 114.63,130.09 114.63,132.59 114.28,132.93 114.28,133.33 114.36,133.41 119.58,133.41 120.38,132.61 123.16,132.61 123.87,131.9 123.87,131.41 126.94,128.34 133.55,128.34 133.56,128.35 134.23,128.35 135.06,127.52 135.06,127.35 135.02,127.31 126.82,127.31
GND on BOTTOM: 7,0.25 6.83,0.33 6.75,0.5 6.75,3.85 6.81,4 6.95,4.09 8.95,6.49 6.96,8.91 6.98,8.93 6.97,8.93 7.73,9.69 15.81,9.69 17.55,7.95 17.55,0.62 17.18,0.25
GND on BOTTOM: 54.84,94.65 51.54,94.65 51.03,94.14 51.03,92.36 50.15,91.47 50.15,89.44 50.4,89.19 57.51,89.19 58.15,89.82 58.15,93.51 57.64,94.01 55.48,94.01
GND on BOTTOM: 26.09,39.82 26.09,41.03 28.86,41.03 29.18,40.7 29.18,38.21 28.28,37.31 27.84,37.31 27.81,37.34 27.81,37.91 27.68,38.03 26.24,38.03 25.99,38.29 25.99,39.72
GND on BOTTOM: 134.71,113.04 132.65,110.98 132.07,110.98 132.06,110.98 131.74,110.95 131.58,110.67 131.58,110.64 124.24,110.64 123.21,111.67 118.68,111.67 117.01,109.99 106.66,109.99 106.05,110.6 106.05,110.61 105.89,110.9 105.59,111.01 100.6,111.01 99.69,111.92 99.69,115.08 99.49,115.46 99.07,115.51 98.53,115.51 98.53,123.27 94.97,126.83 94.75,126.93 94.5,126.86 94.43,126.85 94.38,126.9 94.35,126.99 94.29,127.07 94.02,127.34 94.01,127.42 94.08,127.47 94.09,127.46 105.21,127.46 108.64,130.89 111.17,130.89 111.65,130.41 111.65,127.01 115.1,123.56 117.85,123.56 119.24,122.17 119.24,118.65 120.99,116.9 134.07,116.9 137.2,113.77 143.47,113.77 143.54,113.73 143.53,113.64 142.51,112.63 141.14,112.63 141.08,112.69 141.08,113.09 140.49,113.09 140.49,113.01 140.27,113.01 140.27,113.09 139.09,113.09 139.06,113.04 139,113.03 138.93,113.04 138.86,113.02 138.85,113.01 137.74,113.01 137.72,113.04
GND on BOTTOM: 22.54,40.51 23.9,40.51 23.95,40.45 23.95,39.89 23.76,39.7 23.76,39.23 23.79,39.2 23.94,38.81 23.57,38.59 23.53,38.55 23.51,38.49 23.51,38.22 23.54,38.2 23.98,38.2 24.17,38.01 24.34,38.01 24.48,38.14 24.48,39.35 24.57,39.44 24.57,40.84 24.38,41.03 22.54,41.03 22.46,40.95 22.46,40.58
GND on BOTTOM: 128.76,107.86 128.89,107.73 129.14,107.73 129.27,107.6 129.27,104.17 129.39,104.05 129.39,103.16 129.77,102.78 129.77,101.76 129.9,101.63 129.9,101 129.85,100.94 129.58,100.94 129.52,101 129.52,101.25 129.32,101.46 128.86,101.46 128.76,101.35 128.76,101.13 128.63,101 128.38,101 128.25,101.13 128.25,108.36 128.38,108.49 128.63,108.49 128.76,108.36
GND on BOTTOM: 118.29,108.06 123.25,108.06 123.3,108.01 123.3,107.65 123.25,107.6 118.28,107.6 118.24,107.64 118.24,108.01
GND on BOTTOM: 124.16,108.69 124.97,108.69 125.03,108.64 125.03,108.14 125,108.11 124.62,108.11 124.52,108.01 124.52,107.48 124.64,107.35 125,107.35 125.03,107.32 125.03,106.99 125,106.97 124.64,106.97 124.52,106.84 124.52,105.77 124.69,105.6 125,105.6 125.03,105.57 125.03,105.24 125,105.21 124.64,105.21 124.52,105.09 124.52,104.61 124.64,104.48 124.95,104.48 125.03,104.4 125.03,103.49 124.97,103.44 124.62,103.44 124.52,103.34 124.52,102.27 124.69,102.09 125,102.09 125.03,102.07 125.03,101.71 125,101.68 124.62,101.68 124.52,101.58 124.52,100.64 124.42,100.54 124.09,100.54 124.03,100.59 124.03,108.57
GND on BOTTOM: 193.65,117.99 200.32,124.66 207.18,124.66 207.6,124.24 207.6,120.47 206.3,119.18 204.51,119.18 203.38,118.04 199.4,118.04 197.35,116 197.35,115.08 194.76,112.5 193.9,112.5 193.65,112.75
GND on BOTTOM: 15.22,86.65 23.09,86.65 23.73,86.01 23.73,72.8 23.22,72.3 16.62,72.3 14.59,74.33 14.59,86.01
GND on BOTTOM: 118.88,100.77 118.85,100.8 118.85,101.13 118.9,101.18 122.69,101.18 122.82,101.3 122.82,101.91 122.69,102.04 118.32,102.04 118.27,102.09 118.27,102.45 118.29,102.47 123.25,102.47 123.3,102.42 123.3,101.33 122.74,100.77
GND on BOTTOM: 127.44,107.65 127.49,107.6 127.49,100.24 127.43,100.18 127.16,100.18 127.11,100.24 127.11,107.6 127.16,107.65
GND on BOTTOM: outline of 148 points within 126.35,114.49 166.03,129.15 ; 2 cut-outs
GND on BOTTOM: 9.31,37.55 7.8,37.55 7.38,37.97 9.02,40.69 6.6,42.75 4.25,42.75 4.08,42.83 4,43 4,58.19 3.78,58.72 3.25,58.94 3.18,58.94 3.01,59.02 2.93,59.19 2.93,59.55 2.71,60.08 2.18,60.3 1.8,60.3 1.63,60.38 1.55,60.55 1.55,61.63 1.55,61.63 1.55,99.71 1.63,99.88 1.8,99.96 2.1,99.96 2.63,100.18 2.86,100.71 2.86,111.4 2.93,111.57 3.1,111.65 12.4,111.65 12.57,111.57 12.64,111.4 12.64,107.08 12.61,106.95 12.52,106.86 12.36,105.68 13.55,105.83 13.64,105.92 13.76,105.96 13.95,105.96 13.95,98.84 11.92,96.81 11.92,88.81 13.57,87.16 13.57,71.15 12.6,70.18 12.6,62.6 12.29,62.29 9.84,62.29 6.08,58.53 6.08,51.21 6.97,50.33 6.97,48.29 7.35,47.91 13.6,47.91 13.81,47.7 13.81,47.43 13.96,47.28 18.9,47.28 19.41,46.77 19.41,42.88 18.88,42.35 14.1,42.35 10.58,38.83 10.58,38.82
GND on BOTTOM: 118.27,104.33 123.25,104.33 123.3,104.28 123.3,103.92 123.25,103.87 118.27,103.87 118.24,103.89 118.24,104.3
GND on BOTTOM: 118.24,105.55 123.25,105.55 123.3,105.49 123.3,105.19 123.25,105.14 118.24,105.14 118.22,105.16 118.22,105.52
GND on BOTTOM: 236.77,150.65 233.5,143.05 230.23,150.65
GND on BOTTOM: 204.05,103.88 203.92,103.91 203.83,104 203.23,104.38 202.58,104.09 202.53,104.06 202.47,104.08 201.71,104.84 201.69,104.91 201.74,104.97 201.94,105.37 201.55,105.6 201.53,105.6 201.24,105.88 200.82,105.88 200.82,106.11 202.38,106.11 202.93,105.56 202.93,105.55 203.19,105.32 203.51,105.45 203.57,105.48 203.64,105.43 204,105.26 204.26,105.58 210.96,105.58 211.01,105.53 219.32,105.53 219.32,105.3 213.38,105.3 213.38,104.75 208.54,104.75 208.04,104.57 207.71,103.94 207.55,103.88
GND on BOTTOM: 147.73,136.84 148.71,135.85 149.03,135.85 149.16,135.72 149.17,135.64 149.1,135.59 147.47,135.59 146.36,136.71 144.48,136.71 144.23,136.96 144.23,137.36 144.2,137.39 144.18,137.47 144.25,137.52 145.87,137.52 145.87,137.4 145.86,137.39 145.8,137.19 145.86,137 145.87,136.99 145.87,136.91 145.94,136.91 145.95,136.91 146.05,136.86 146.16,136.84
GND on BOTTOM: 128.81,109.89 128.94,110.02 129.42,110.02 129.44,109.99 129.44,109.61 129.42,109.58 129.06,109.58 128.89,109.41 118.7,109.41 118.68,109.43 118.68,109.86 118.7,109.89
GND on IN1: 24.44,94.46 24.46,94.46 24.58,94.5 24.65,94.6 24.71,94.65 24.78,94.63 25.54,93.87 27.15,93.87 30.55,97.27 31.29,97.27 31.44,97.12 31.44,96.34 31.16,96.06 30.6,96.06 27.58,93.04 27.24,93.04 25.43,91.24 23.53,91.24 23.31,91.02 22.01,91.02 21.9,91.12 21.9,93.89 22.48,94.46
GND on IN1: 45.89,115.64 45.89,118.59 45.68,118.8 45.68,120.33 45.72,120.4 45.8,120.39 46.03,120.32 46.24,120.42 46.3,120.44 46.35,120.42 46.89,120.69 46.33,120.9 46.28,120.88 46.22,120.9 46.01,120.98 45.8,120.9 45.72,120.9 45.68,120.96 45.68,121.31 45.89,121.53 45.89,121.85 45.56,121.85 45.45,121.73 45.37,121.72 45.32,121.79 45.32,124.55 44.91,124.96 44.59,124.96 44.59,124.64 44.86,124.36 44.86,122.93 44.81,122.86 44.73,122.88 44.51,123.01 44.26,122.94 44.18,122.93 44.14,123 44.14,125.99 45.5,127.34 45.98,127.83 45.98,128 45.9,128.07 45.58,128.07 43.68,126.18 43.68,124.4 43.63,124.33 43.55,124.35 43.43,124.47 43.12,124.47 43.09,124.47 43.02,124.48 43,124.54 43,125.81 44.25,127.06 44.25,128.89 45.43,130.07 45.43,130.08 46.43,131.07 47.02,131.07 47.49,130.6 47.49,128.6 48.46,127.63 48.46,126.55 49.31,125.7 49.31,122.79 46.05,119.53 46.05,115.64
GND on IN1: 46.73,101.83 46.66,101.87 46.68,101.96 47.44,102.72 47.44,103.39 47.5,103.48 47.62,103.46 48.03,103.39 48.17,103.78 48.18,103.85 48.25,103.88 48.37,103.91 48.48,103.98 48.53,104.01 48.81,103.91 49.08,104.02 49.14,104 49.69,104.26 49.13,104.48 49.07,104.46 48.79,104.57 48.51,104.44 48.46,104.46 48.23,104.54 48.01,104.45 47.96,104.43 47.91,104.45 47.74,104.54 47.55,104.51 47.47,104.52 47.44,104.58 47.44,104.67 48.97,106.2 48.97,108.06 50.35,109.44 50.42,109.46 50.47,109.42 50.84,109.36 50.78,109.73 50.74,109.78 50.76,109.85 51.5,110.59 51.5,112.05 53.14,113.69 53.14,116.66 54.61,118.13 58.8,118.13 59.2,117.73 60.84,117.73 61.09,117.48 61.09,112.79 59.07,110.77 59.07,103.34 58.32,102.59 49.65,102.59 48.88,101.83
GND on IN1: 129.72,107.96 129.72,106.15 130.34,106.15 130.52,105.98 130.52,105.13 130.37,104.97 130.37,104.54 131.73,104.54 131.73,105.77 131.77,105.82 132.37,105.82 132.56,106.01 132.56,106.15 132.46,106.25 131.76,106.25 131.73,106.28 131.73,107.96 131.19,107.96 131.16,108 130.78,108 130.74,107.96
GND on IN1: 123.89,100.87 124.2,100.87 124.23,100.91 124.23,103.89 124.2,103.93 123.89,103.93 123.85,103.89 123.85,100.91
GND on IN1: 116.27,130.86 116.2,130.91 116.21,130.99 116.42,131.21 120.29,131.21 122.09,133 124.34,133 124.34,132.18 125.02,132.18 125.02,131.47 123.3,131.47 122.75,130.91 116.75,130.91 116.7,130.86
