# Allegro board LAC321PR10-0907B.brd (continued)
## Nets (continued)
3.3V_NGFF1_EN: D11.3 U27.G4
+0.85V_PRIM: PJP601.2 RC162.1
+1.0V_APLL: CC21.1 CC22.1 CC163.1 RC199.2 UC1.AA18 UC1.AA19
+1.0V_MPHYGT: CC19.1 CC20.1 CC25.1 RC157.2 UC1.AA21 UC1.AA23 UC1.AK23 UC1.AL23 UC1.AN23 UC1.AR23 UC1.T1 UC1.T15 UC1.T16 UC1.U2
+1.0V_MPHYPLL: CC132.1 CC133.1 CC134.1 CC135.1 RC163.2 UC1.R15 UC1.R16 UC1.V15 UC1.V16
+1.0V_PRIM: C1228.1 C1233.1 PJP603.1 R5753.1 RC154.1 RC159.1 RC160.1 RC199.1 U40.1 U40.2 U40.6 U40.7 U709.1 U709.2 U709.7
+1.0V_VCCSFR: CC17.1 RC106.2 UC1.R27 UC1.T27
+1.0V_VCCST: C187.1 C255.1 C1229.1 PR746.2 PR802.1 PR803.1 R90.1 RC106.1 RC142.1 RC144.2 RH66.1 U27.B11 U40.13 U40.14 UC1.V26 UC1.Y26
+1.0V_XDP: JXDP2.43 JXDP2.44 RC154.2
+1.0VA_GATE: C249.1 C1232.1 R5753.2 RC157.1 RC163.1 U40.8 U40.9
+1.0VA_S: PC638.1 PC639.1 PC640.1 PC641.1 PC642.1 PJP603.2 PL607.1 PU500.M6
+1.0VS_VCCIO: CC104.2 CC105.2 CC106.2 CC107.2 CC108.2 CC109.2 CC110.2 CC111.2 CC112.2 CC113.2 CC114.2 CC115.2 CC116.2 CC117.1 CC118.1 CC119.2 CC120.2 CC121.2 CC122.2 CC123.2 CC124.2 CC125.2 CC126.2 CC127.2 CC128.2 PJP500.1 RC4.2 RC97.1 UC1.AC23 UC1.AC24 UC1.AE23 UC1.AE24 UC1.AE26 UC1.AF24 UC1.AF26 UC1.AH26 UC1.AK26 UC1.AL26 UC1.AN26 UC1.AR26 UC1.AT26 UC1.AV26 UC1.AV28 UC1.AV30 UC1.AV32 UC1.AV34 UC1.AV36 UC1.AV38 UC1.AV40 UC1.AV42 UC1.AV44 UC1.AV46 UC1.AV48 UC1.AV50 UC1.AW27 UC1.AW29 UC1.AW31 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW39 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51
+1.0VS_VCCIO_S: PC508.1 PC509.1 PC510.1 PC511.1 PC512.1 PJP500.2 PL502.1 PR505.1
+1.0VS_VCCSTG: C1235.1 CC18.1 PR714.2 PR747.2 PR800.1 R1027.2 RC13.1 RC18.2 RC19.2 RC20.2 RC25.2 RC34.2 RC37.2 RC38.2 RC40.1 RC140.2 UC1.R26 UC1.T26
+1.2V_KEYSSA: C242.1 C1242.1 C1243.1 JPOGO.21 JPOGO.23 R327.2 R5704.1
+1.2V_KEYSSA_DP: C1388.1 JPOGO.22 JPOGO.24 R5729.2
+1.2V_VCCSFR_OC: C1237.1 R1029.2 R1069.2 RC102.1 UC1.AE27 UC1.AF27
+1.2V_VDDQ: C17.1 C18.1 C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C241.1 C1390.1 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 PC621.1 PC633.1 PJP602.1 PU500.E1 PU500.E2 PU500.F3 R6.1 R7.1 R14.1 R1069.1 RH61.1 U3.A6 U3.A7 U3.A9 U3.A11 U3.A13 U3.B9 U3.B12 U3.B17 U3.C3 U3.C12 U3.C17 U3.E1 U3.E17 U3.G2 U3.G12 U3.G17 U3.H1 U3.H16 U3.K1 U3.K12 U3.K17 U3.L1 U3.L17 U3.M2 U3.M3 U3.M7 U3.M10 U3.M12 U3.N1 U3.P17 U3.R15 U3.T8 U3.U2 U3.U3 U3.U5 U3.U7 U3.U10 U3.U11 U3.U14 U4.A6 U4.A7 U4.A9 U4.A11 U4.A13 U4.B9 U4.B12 U4.B17 U4.C3 U4.C12 U4.C17 U4.E1 U4.E17 U4.G2 U4.G12 U4.G17 U4.H1 U4.H16 U4.K1 U4.K12 U4.K17 U4.L1 U4.L17 U4.M2 U4.M3 U4.M7 U4.M10 U4.M12 U4.N1 U4.P17 U4.R15 U4.T8 U4.U2 U4.U3 U4.U5 U4.U7 U4.U10 U4.U11 U4.U14 U33.1 U33.2 U710.1 U710.2 U710.7 U721.1 U721.2 UC1.AH64 UC1.AK64 UC1.AT64 UC1.AV64 UC1.BA25 UC1.BA27 UC1.BA29 UC1.BA31 UC1.BA33 UC1.BA35 UC1.BA37 UC1.BA41 UC1.BA43 UC1.BA45 UC1.BA47 UC1.BA49 UC1.BA51 UC1.BN64 UC1.BP24 UC1.BP26 UC1.BP32 UC1.BP34 UC1.BP40 UC1.BP42 UC1.BP48 UC1.BP50 UC1.BP56 UC1.BP58 UC1.BP64
+1.2V_VDDQ_S: PC622.1 PC623.1 PC624.1 PC625.1 PC626.1 PC627.1 PC628.1 PJP602.2 PL605.1 PU500.H3
+1.8V_MEM: C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 PJP600.1 U3.A15 U3.A16 U3.B2 U3.R1 U3.T1 U3.T16 U4.A15 U4.A16 U4.B2 U4.R1 U4.T1 U4.T16
+1.8V_MEM_S: PC609.1 PC610.1 PC611.1 PJP600.2 PL602.1 PU500.C10
+1.8V_PCH_GPP: CC43.1 RC158.2 UC1.AE15 UC1.AE16 UC1.AN2 UC1.AP1
+1.8V_PRIM: C250.1 C252.1 C256.1 PJP503.2 R61.1 R219.1 R228.1 R231.1 RC158.1 RC165.1 RH24.2 RH72.1 RH73.1 RH80.1 RH81.1 RH118.2 RH144.2 RH149.2 RH150.2 RH182.2 RH184.2
+1.8VA_S: PC528.1 PC529.1 PC530.1 PJP503.1 PL507.2 PU500.C6
+1.8VS: C257.1 PU500.E9 R47.1 R48.1 R52.1 RH70.2 RH71.2 U41.13 U41.14
+1.8VS_AUDIO: C276.1 CA2.1 CA5.1 R211.2 RA6.1 UA1.24
+1.8VS_AUDIO_AMP: C274.1 CA102.1 CA103.1 CA115.1 R206.2 UA2.13 UA2.17
+3.3V_PCH_GPP: CC28.1 RC156.2 UC1.AA2 UC1.AB1 UC1.AF1 UC1.AG2 UC1.AH1 UC1.AJ2 UC1.AN15 UC1.AP13 UC1.AT1 UC1.AU2 UC1.AV1 UC1.AW2
+3.3V_SPI: CH32.1 JSPI1.15 RC59.1 RH90.1 RH91.1 U18.8
+3.3V_VCCSPI: CC30.1 RC128.2 UC1.AT15 UC1.AV15
+3.3VDX_SSD: C89.1 C90.1 C91.1 C92.1 C93.1 C238.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.70 JNGFF2.72 JNGFF2.74 R222.2 R1377.2 R1378.2 U712.5
+3V_1.8V_HDA: CC23.1 RC164.2 RC165.2 UC1.AT23 UC1.AV22
+3V_DD: PC203.1 PD205.1 PR256.1 PR257.2 PR258.1
+3V_LDO: PC201.1 PQ209.1 PR239.1 PR255.1 PU200.5
+3V_PDLDO: PC134.1 PQ113.1 PR156.1 PU102.5
+3V_PDLDO_OUT: PC131.2 PC132.1 PQ113.3 PQ114.3 PR149.2 PR153.1 R5698.1 R5731.1
+3V_PRIM: C96.1 C97.1 C1387.1 CC164.1 JAPS2.1 JAPS2.7 JSPI1.16 PC567.1 PJP501.2 Q10.6 Q343.2 R108.1 R111.1 R115.1 R201.1 R1136.2 R1224.1 R1225.1 R5711.2 R5718.2 RC7.1 RC9.1 RC50.1 RC59.2 RC81.2 RC82.2 RC83.1 RC84.1 RC85.1 RC128.1 RC156.1 RC164.1 RC166.1 RH27.2 RH41.2 RH74.2 RH75.2 RH94.2 RH95.2 RH96.2 RH97.2 RH98.2 RH99.2 RH100.2 RH101.2 RH102.2 RH114.1 RH122.2 RH123.2 RH124.2 RH125.2 RH126.2 RH127.2 RH128.2 RH146.1 RH148.2 RH151.2 RH177.2 UH2.5
+3V_SKYCAM: C98.1 C99.1 C100.1 C101.1 C102.2 C103.1 C1409.1 R115.2 U16.A7 U16.B5 U16.B6 U16.D1 U16.G6 U16.H5 U713.8
+3V_TBT: C1287.2 C1288.1 C1289.1 C1290.1 C1291.1 L64.2 R1388.2 R1389.2 R1390.2 R1407.2 R1411.2 R1412.2 R5670.2 R5673.1 R5696.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3V_TBT_SX: C1284.1 R1397.2 R1398.2 R1399.2 R1400.2 R1401.2 R1402.2 R1404.2 R1406.2 R1422.2 R1423.2 R5745.1 R5756.2 UT1.F8
+3VA_S: PC513.1 PC514.1 PC515.1 PC557.1 PC558.1 PJP501.1 PL503.2 PU500.F12
+3VALW: C37.1 C216.1 C219.1 C222.1 C229.1 C231.1 C235.1 C240.1 C243.1 C1223.1 JAPS2.3 PJP504.1 PQ211.1 PR428.1 PU500.D5 PU500.E4 R157.1 R218.1 R1423.1 RA51.2 U7.4 U7.5 U30.1 U30.2 U31.1 U31.2 U32.1 U32.2 U32.6 U32.7 U33.6 U33.7 U34.1 U34.2 U34.6 U34.7 U36.1 U36.2 U711.6
+3VALW_DSW: C94.1 C95.1 C161.1 C179.1 C218.1 CC131.1 PC129.2 PC202.2 PC205.2 PC211.2 PC212.2 PC214.1 PC218.1 PD204.2 PQ114.1 PR150.1 PR210.1 PR225.1 PR227.1 PR238.1 PR240.1 PR259.1 PR709.2 PR710.2 PR816.1 PR829.2 PU101.5 PU201.5 PU204.5 PU205.5 PU206.8 PU207.8 PU209.5 PU800.B3 R204.2 R514.1 R1014.2 R1422.1 R5699.1 R5717.2 R5730.1 R5746.1 RH68.1 RH82.1 RH115.1 RH116.1 RH117.1 U24.4 UC1.AL15 UC1.AM13
+3VALW_EC: C177.1 C178.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 C1386.1 JLVDS1.4 L19.1 PR120.2 PU500.L7 Q330.3 R130.1 R155.1 R167.2 R168.2 R169.2 R170.2 R171.1 R178.1 R192.1 R195.1 R514.2 R515.2 R1037.2 R1040.1 R1041.1 R1044.2 R1045.1 R1046.1 R1047.1 R1049.2 R1050.2 R1053.2 R1055.2 R1057.2 R1059.2 R1060.2 R1065.1 R1066.1 R1067.1 R1068.1 R1074.1 R1079.2 R1080.2 R1082.2 R1083.2 R1087.2 R1138.2 R5676.1 R5677.1 R5703.1 R5738.1 U27.A6 U27.F3 U27.F12 U27.K1 U27.K2 U27.K4 U27.K12 U27.L4 U27.N4
+3VALW_EC_L: C176.1 L19.2 U27.H3
+3VALW_S: PC543.1 PC544.1 PC545.1 PC546.1 PC547.1 PC550.1 PC551.1 PC563.1 PC564.1 PC565.1 PC566.1 PJP504.2 PL509.1 PU500.K13
+3VLDO: PC213.1 PC215.2 PD301.2 PQ209.3 PQ211.3 PR202.1 PR213.1 PR218.1 PR220.1 PR224.2 PR237.1 PR239.2 PR241.1 PR242.1 PR245.1 PR247.1 R515.1 R5588.1
+3VLDO_BATT: D406.2 PD302.2 PR161.1
+3VS: C35.1 C36.1 C139.1 C140.1 C150.1 C151.1 C156.1 C159.1 C160.1 C230.1 C1391.1 JLPDE1.1 JLPDE1.2 JSER.18 PR228.2 PU500.F9 Q43.2 Q86.2 Q89.5 Q345.2 Q345.5 R34.1 R36.1 R38.2 R39.2 R83.1 R84.1 R85.1 R91.1 R103.1 R104.1 R126.2 R127.2 R183.1 R185.1 R187.1 R189.1 R191.1 R196.1 R198.1 R199.1 R200.1 R216.2 R395.2 R396.2 R1048.1 R5673.2 R5754.1 R5755.1 RC6.1 RC10.1 RC16.1 RC32.1 RC33.1 RC86.1 RC90.2 RC200.1 RC201.1 RC202.1 RC203.1 RC242.1 RH13.2 RH14.2 RH15.2 RH25.2 RH28.1 RH29.2 RH30.1 RH33.1 RH35.1 RH37.1 RH92.2 RH93.2 RH113.1 RH119.2 RH120.2 RH130.2 RH131.2 RH132.1 RH134.2 RH140.2 RH141.2 RH181.2 U20.1 U20.3 U20.22 U20.23 U23.5 U23.21 U23.30 U23.51 U23.57 U30.6 U30.7 UH1.5
+3VS_AUDIO: C277.1 C278.1 CA6.1 JDMIC1.2 LA4.1 R227.2 RA13.1 RA27.1
+3VS_CAM: C51.1 C129.1 C130.1 C215.1 JCAM2.9 JCAM2.10 R205.2
+3VS_CR: C248.1 CR2.1 CR3.1 CR7.1 CR11.1 R224.2 RR1.2 RR9.1 UR1.11 UR1.27
+3VS_TPM: C210.1 Q344.3 R200.2 R201.2 U15.8
+3VS_TS: C59.1 C233.1 C415.1 C1222.1 JITOUCH.1 JLVDS1.5 R221.2 R5757.1 RC238.2 RC239.2
+3VS_WLAN: C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C223.1 JNGFF3.2 JNGFF3.4 JNGFF3.64 JNGFF3.66 R212.2 U13.5
+3VS_WWAN: C71.1 C72.1 C73.1 C75.1 C76.1 C77.1 C78.1 C79.1 C377.1 C1384.1 C1385.1 JNGFF1.2 JNGFF1.4 JNGFF1.62 JNGFF1.64 JNGFF1.66 Q89.2 R46.1 R51.1 R1070.2
+5VALW: C157.1 C211.1 C246.1 C1227.1 C1234.1 C1236.1 C1426.1 JDEBUG1.1 JDEBUG1.2 JDMIC1.6 JPB1.3 JPB1.4 PC221.1 PC525.1 PC526.1 PC527.1 PC802.1 PC803.1 PC900.1 PC1002.1 PJP502.1 PQ212.2 PR812.1 PR813.1 PR817.1 PR832.2 PR919.2 PU800.A6 PU800.E10 PU801.4 PU901.4 R1.2 R18.1 R19.1 R21.1 R22.1 R1424.1 U30.4 U31.4 U32.4 U33.4 U34.4 U36.4 U36.6 U36.7 U37.4 U37.6 U37.7 U38.4 U40.4 U41.4 U41.6 U41.7 U709.3 U710.3 U721.4
+5VALW_S: PC531.1 PC532.1 PC533.1 PC534.1 PC535.1 PC536.1 PJP502.2 PL506.1 PU500.B9
+5VS: C212.1 R202.2
+5VS_AUDIO: CA12.1 CA13.1 LA1.2 LA2.1 LA3.1 R229.2
+5VS_AUDIO_AMP: C275.1 LA18.2 LA19.2 R234.2
+AVDD1: CA1.1 CA3.1 CA4.1 LA1.1 UA1.45
+DVDD: CA37.1 CA38.1 LA4.2 RA23.1 RA25.1 RA26.1 UA1.7
+DVDDIO: CA43.1 CA44.1 CA113.1 CA114.1 Q349.2 Q349.5 RA27.2 RA64.1 RA70.2 RA71.2 UA1.19 UA2.12
+PVDD: CA106.1 CA107.1 CA108.1 LA18.1 UA2.41 UA2.44
+V0.85A_S: PC612.1 PC613.1 PC614.1 PC615.1 PJP601.1 PL603.2 PU500.N11
+VCC_CORE: PC807.2 PC814.1 PC1110.1 PC1111.1 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1116.1 PC1117.1 PC1118.1 PC1119.1 PC1125.1 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1137.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1157.1 PC1158.1 PC1159.1 PC1160.1 PC1161.1 PC1162.1 PC1163.1 PC1164.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1182.1 PC1183.1 PC1184.1 PC1185.1 PC1205.1 PC1206.1 PC1250.1 PC1251.1 PC1252.1 PH800.2 PL802.2 PR811.2 PR814.2 PR833.2 PR834.2 RC147.1 UC1.A64 UC1.AA32 UC1.AA41 UC1.AC32 UC1.AC41 UC1.AE32 UC1.AE33 UC1.AE35 UC1.AE36 UC1.AE38 UC1.AE40 UC1.AE41 UC1.AF32 UC1.AF41 UC1.AH32 UC1.AH41 UC1.AK32 UC1.AK41 UC1.AL32 UC1.AL41 UC1.AN32 UC1.AN41 UC1.AR32 UC1.AR41 UC1.AT32 UC1.AT33 UC1.AT35 UC1.AT36 UC1.AT38 UC1.AT40 UC1.AT41 UC1.B64 UC1.D64 UC1.F64 UC1.H63 UC1.J64 UC1.L40 UC1.L42 UC1.L44 UC1.L46 UC1.L48 UC1.L50 UC1.L52 UC1.L54 UC1.L63 UC1.M33 UC1.M35 UC1.M37 UC1.M39 UC1.M41 UC1.M43 UC1.M45 UC1.M47 UC1.M49 UC1.M51 UC1.M53 UC1.M56 UC1.M58 UC1.M60 UC1.M62 UC1.M64 UC1.N32 UC1.N34 UC1.N36 UC1.N38 UC1.N40 UC1.N42 UC1.N54 UC1.N55 UC1.N57 UC1.N59 UC1.N61 UC1.N63 UC1.P56 UC1.P58 UC1.P60 UC1.P62 UC1.P64 UC1.R32 UC1.R41 UC1.R57 UC1.R59 UC1.R61 UC1.R63 UC1.T32 UC1.T41 UC1.V32 UC1.V41 UC1.Y32 UC1.Y41
+VCC_GT: PC904.2 PC912.1 PC1100.1 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1109.1 PC1120.1 PC1121.1 PC1122.1 PC1123.1 PC1124.1 PC1135.1 PC1136.1 PC1151.1 PC1152.1 PC1155.1 PC1156.1 PC1165.1 PC1166.1 PC1167.1 PC1168.1 PC1169.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PC1175.1 PC1186.1 PC1187.1 PC1188.1 PC1204.1 PC1207.1 PC1208.1 PC1209.1 PC1216.1 PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1246.1 PC1247.1 PC1248.1 PC1249.1 PH900.2 PL902.2 PR906.2 PR907.2 PR920.2 PR921.2 RC139.1 UC1.AA53 UC1.AB54 UC1.AB56 UC1.AB58 UC1.AB60 UC1.AB62 UC1.AB64 UC1.AC43 UC1.AC44 UC1.AC46 UC1.AC47 UC1.AC49 UC1.AC50 UC1.AC51 UC1.AC53 UC1.AC55 UC1.AC57 UC1.AC59 UC1.AC61 UC1.AC63 UC1.AD54 UC1.AD56 UC1.AD58 UC1.AD60 UC1.AD62 UC1.AD64 UC1.AE53 UC1.AE55 UC1.AE57 UC1.AE59 UC1.AE61 UC1.AE63 UC1.AF43 UC1.AF44 UC1.AF46 UC1.AF47 UC1.AF49 UC1.AF50 UC1.AF51 UC1.AG53 UC1.AJ53 UC1.AK43 UC1.AK44 UC1.AK46 UC1.AK47 UC1.AK49 UC1.AK50 UC1.AK51 UC1.AN43 UC1.AN44 UC1.AN46 UC1.AN47 UC1.AN49 UC1.AN50 UC1.AN51 UC1.AT43 UC1.AT44 UC1.AT46 UC1.AT47 UC1.AT49 UC1.AT50 UC1.AT51 UC1.N44 UC1.N46 UC1.N48 UC1.N50 UC1.R51 UC1.R53 UC1.T43 UC1.T44 UC1.T46 UC1.T47 UC1.T49 UC1.T50 UC1.T51 UC1.T54 UC1.U53 UC1.U55 UC1.U57 UC1.U59 UC1.U61 UC1.U63 UC1.V54 UC1.V56 UC1.V58 UC1.V60 UC1.V62 UC1.V64 UC1.W53 UC1.W55 UC1.W57 UC1.W59 UC1.W61 UC1.W63 UC1.Y43 UC1.Y44 UC1.Y46 UC1.Y47 UC1.Y49 UC1.Y50 UC1.Y51 UC1.Y54 UC1.Y56 UC1.Y58 UC1.Y60 UC1.Y62 UC1.Y64
+VCC_SA: PC1004.2 PC1015.1 PC1189.1 PC1190.1 PC1191.1 PC1192.1 PC1193.1 PC1194.1 PC1195.1 PC1196.1 PC1197.1 PC1198.1 PC1199.1 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1253.1 PC1254.1 PH1000.2 PL1001.2 PR1005.2 PR1007.2 RC149.1 RC167.1 UC1.AA29 UC1.AC29 UC1.AC30 UC1.AE29 UC1.AF29 UC1.AF30 UC1.AH29 UC1.AK29 UC1.AK30 UC1.AL29 UC1.AN29 UC1.AN30 UC1.AR29 UC1.L30 UC1.M31 UC1.N30 UC1.R29 UC1.T29 UC1.T30 UC1.V29 UC1.Y29 UC1.Y30
+VCCCLK: CC24.1 CC26.1 CC38.1 CC51.1 RC159.2 RH32.2 UC1.R19 UC1.R21 UC1.R23 UC1.T19 UC1.V18 UC1.V19 UC1.V21 UC1.V23 UC1.Y18 UC1.Y19 UC1.Y21 UC1.Y23
+VCCCOREG0: CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 UC1.AA35 UC1.AA38 UC1.AC35 UC1.AC38 UC1.R35 UC1.R38 UC1.T35 UC1.T38 UC1.V35 UC1.V38 UC1.Y35 UC1.Y38
+VCCCOREG1: CC92.2 CC93.2 CC94.2 CC95.2 CC96.2 CC97.2 CC98.2 CC99.2 CC100.2 CC101.2 CC102.2 CC103.2 UC1.AF35 UC1.AF38 UC1.AH35 UC1.AH38 UC1.AK35 UC1.AK38 UC1.AL35 UC1.AL38 UC1.AN35 UC1.AN38 UC1.AR35 UC1.AR38
+VCCPRIM_1P0: CC32.1 CC34.1 CC35.1 CC36.1 CC37.1 CC48.1 RC160.2 UC1.AA15 UC1.AA16 UC1.AH13 UC1.AH15 UC1.AH18 UC1.AH19 UC1.AK18 UC1.AL18 UC1.AR21 UC1.AT21 UC1.V1 UC1.W2
+VCCPRIM_3P3: CC44.1 CC52.1 CC53.1 CC54.1 CC158.1 RC166.2 UC1.AC2 UC1.AD1 UC1.AH21 UC1.AK19 UC1.AK21 UC1.AL19
+VCCPRIM_CORE: CC129.1 CC130.1 RC162.2 UC1.AE18 UC1.AE19 UC1.AF18 UC1.AF19 UC1.AR16 UC1.AT16
+VDDQ_CPU_CLK: CC9.1 CC16.1 RC102.2 RH61.2 UC1.BA39
AGND: CA1.2 CA2.2 CA3.2 CA4.2 CA5.2 CA10.2 CA11.2 CA16.2 CA17.2 CA24.2 CA25.2 CA26.2 CA27.2 CA28.2 CA29.2 CA30.2 CA31.2 CA33.2 CA34.2 JHP1.9 JHP1.11 JHP1.12 JPA1.2 JPA2.2 JPA3.2 Q68.3 QA1.1 QA1.4 RA3.2 RA4.2 RA19.2 UA1.20 UA1.30 UA1.42
AGND_CAM: J3.1 JPA4.2
DV12S: CR4.2 CR5.1 CR6.1 UR1.10 UR1.14
DV33_18: CR1.2 UR1.18
GND: C1.1 C2.2 C3.2 C4.2 C5.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C41.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.1 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C110.2 C111.2 C113.2 C114.2 C115.2 C116.2 C117.1 C118.1 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C129.2 C130.2 C135.2 C139.2 C140.2 C148.2 C149.2 C150.2 C151.2 C153.2 C156.2 C157.2 C159.2 C160.2 C161.2 C162.2 C165.2 C169.2 C170.2 C171.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C203.2 C205.2 C207.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C222.2 C223.2 C224.2 C225.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.1 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.1 C254.2 C255.2 C256.2 C257.2 C261.1 C263.2 C267.2 C268.2 C269.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C283.2 C284.2 C288.2 C289.2 C290.2 C291.2 C377.2 C415.2 C715.2 C1164.2 C1222.2 C1223.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1234.2 C1235.2 C1236.2 C1237.2 C1238.2 C1242.2 C1243.2 C1244.2 C1245.2 C1248.2 C1249.2 C1250.2 C1259.2 C1260.2 C1271.1 C1284.2 C1285.2 C1286.2 C1287.1 C1288.2 C1289.2 C1290.2 C1291.2 C1292.1 C1293.1 C1294.1 C1295.1 C1296.1 C1297.1 C1298.1 C1299.1 C1300.1 C1301.1 C1302.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1315.1 C1319.2 C1320.2 C1323.1 C1324.1 C1325.1 C1326.1 C1327.1 C1328.2 C1329.2 C1330.2 C1331.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1339.2 C1340.2 C1341.2 C1342.2 C1343.2 C1344.2 C1345.2 C1346.2 C1347.2 C1348.2 C1349.2 C1350.2 C1351.2 C1352.2 C1353.2 C1354.2 C1355.2 C1358.2 C1359.1 C1360.1 C1361.1 C1362.1 C1363.1 C1364.1 C1365.1 C1366.1 C1384.2 C1385.2 C1386.2 C1387.2 C1388.2 C1389.2 C1390.2 C1391.2 C1392.2 C1393.2 C1394.2 C1397.2 C1398.2 C1399.1 C1400.1 C1401.2 C1402.2 C1403.2 C1404.2 C1405.2 C1406.1 C1407.1 C1408.2 C1409.2 C1410.2 C1411.1 C1412.1 C1413.1 C1414.1 C1415.1 C1416.1 C1417.1 C1418.1 C1419.2 C1420.2 C1421.2 C1422.2 C1423.2 C1424.2 C1425.2 C1426.2 C1427.2 C1428.2 C1429.2 C1430.2 C1431.2 C1432.2 CA6.2 CA9.2 CA12.2 CA13.2 CA15.2 CA21.2 CA22.2 CA23.2 CA32.2 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA41.2 CA42.2 CA43.2 CA44.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.2 CA52.2 CA90.2 CA99.2 CA102.2 CA103.2 CA104.2 CA105.2 CA106.2 CA107.2 CA108.2 CA109.2 CA110.2 CA111.2 CA112.2 CA113.2 CA114.2 CA115.2 CA116.2 CA117.2 CA138.2 CC9.2 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC28.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC42.2 CC43.2 CC44.2 CC48.2 CC51.2 CC52.2 CC53.2 CC54.2 CC59.1 CC60.1 CC61.2 CC62.1 CC63.1 CC64.1 CC65.1 CC66.1 CC67.1 CC68.1 CC69.1 CC70.1 CC71.1 CC72.1 CC73.1 CC74.1 CC75.1 CC76.1 CC77.1 CC78.1 CC79.1 CC80.1 CC81.1 CC82.1 CC83.1 CC84.1 CC85.1 CC86.1 CC87.1 CC88.1 CC89.1 CC90.1 CC91.1 CC92.1 CC93.1 CC94.1 CC95.1 CC96.1 CC97.1 CC98.1 CC99.1 CC100.1 CC101.1 CC102.1 CC103.1 CC104.1 CC105.1 CC106.1 CC107.1 CC108.1 CC109.1 CC110.1 CC111.1 CC112.1 CC113.1 CC114.1 CC115.1 CC116.1 CC117.2 CC118.2 CC119.1 CC120.1 CC121.1 CC122.1 CC123.1 CC124.1 CC125.1 CC126.1 CC127.1 CC128.1 CC129.2 CC130.2 CC131.2 CC132.2 CC133.2 CC134.2 CC135.2 CC158.2 CC161.1 CC162.1 CC163.2 CC164.2 CH3.2 CH4.2 CH5.1 CH6.2 CH7.2 CH8.2 CH32.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH46.2 CH49.2 CH50.2 CLRP3.1 CLRP4.2 CR1.1 CR2.2 CR3.2 CR4.1 CR5.2 CR6.2 CR7.2 CR8.2 CR11.2 CR14.2 CR15.2 CR16.1 CR17.2 CR18.2 CR19.2 CR20.2 CR21.2 CR22.2 CR23.2 CT1.2 CT2.2 CT3.2 CT4.2 D6.2 D17.1 D74.1 D75.2 D76.1 D77.2 D78.1 D79.2 D80.1 D81.2 D82.1 D83.2 D84.1 D85.2 D86.1 D87.2 D88.1 D89.2 D90.1 D95.2 D407.2 D408.1 D409.2 D410.1 D411.2 D412.1 D413.2 D414.1 D415.2 D416.1 D417.2 D418.1 D419.1 D420.2 D421.1 D422.2 D423.1 D424.2 D425.2 DA1.2 DA2.2 DA3.2 DA4.2 DA5.1 DA6.1 DA8.2 DH5.2 DI4.1 DI5.1 DI6.1 DI7.1 H2.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H23.1(TP-1) H24.1(TP-1) J3.2 J3.4 J3.5 J3.9 J3.10 J3.16 J3.17 J3.22 J3.23 J3.24 JAPS2.8 JAPS2.10 JAPS2.12 JAPS2.14 JAPS2.19 JAPS2.20 JAR1.5 JAR1.6 JAR1.7 JAR1.8 JBAT100.8 JBAT100.9 JBAT100.10 JBAT100.11 JBAT100.12 JCAM2.1 JCAM2.4 JCAM2.7 JCAM2.11 JCAM2.12 JCR1.6 JCR1.10 JCR1.11 JCR1.12 JCR1.15 JCR1.18 JCR1.21 JCR1.22 JCR1.23 JDEBUG1.5 JDEBUG1.8 JDEBUG1.11 JDEBUG1.12 JDEG1.10 JDEG1.11 JDEG1.12 JDMIC1.4 JDMIC1.5 JDMIC1.7 JDMIC1.10 JDMIC1.12 JDMIC1.13 JDMIC1.14 JDMIC1.15 JDMIC1.16 JITOUCH.3 JITOUCH.10 JITOUCH.11 JITOUCH.12 JLPDE1.9 JLPDE1.11 JLPDE1.12 JLVDS1.2 JLVDS1.20 JLVDS1.21 JLVDS1.22 JLVDS1.23 JLVDS1.25 JLVDS1.26 JLVDS1.27 JLVDS1.28 JLVDS1.37 JLVDS1.40 JLVDS1.43 JLVDS1.46 JLVDS1.49 JLVDS1.51 JLVDS1.52 JLVDS1.53 JLVDS1.54 JLVDS1.55 JNGFF1.3 JNGFF1.5 JNGFF1.11 JNGFF1.19 JNGFF1.25 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.63 JNGFF1.65 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.75 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.7 JNGFF3.18 JNGFF3.25 JNGFF3.31 JNGFF3.37 JNGFF3.43 JNGFF3.49 JNGFF3.55 JNGFF3.61 JNGFF3.67 JNGFF3.68 JNGFF3.69 JP1.2 JP1.3 JP1.8 JP1.9 JP1.13 JP1.14 JP1.20 JP1.21 JP1.26 JP1.29 JPA1.1 JPA2.1 JPA3.1 JPA4.1 JPB1.2 JPB1.7 JPB1.8 JPOGO.1 JPOGO.2 JPOGO.7 JPOGO.8 JPOGO.13 JPOGO.14 JPOGO.19 JPOGO.20 JPOGO.25 JPOGO.26 JPOGO.27 JPOGO.28 JPOGO.29 JPOGO.30 JPOGO.31 JPOGO.32 JPOGO.53 JPOGO.54 JPOGO.55 JPOGO.56 JPOGO.57 JPOGO.58 JPOGO.59 JPOGO.60 JPOGO.61 JPOGO.62 JPOGO.63 JPOGO.67 JPOGO.68 JPOGO.73 JPOGO.74 JPOGO.79 JPOGO.80 JPOGO.81 JPOGO.82 JPOGO.83 JPOGO.84 JRTC1.2 JRTC1.3 JRTC1.4 JSER.5 JSER.10 JSER.17 JSER.19 JSER.20 JSIM1.4 JSIM1.7 JSIM1.9 JSIM1.10 JSIM1.11 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.3 JSPK1.4 JSPK2.3 JSPK2.4 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JVB1.3 JVB1.4 JVOL1.3 JVOL1.4 JVOL1.6 JVOL1.7 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 LT1.2 LT2.2 MC1.1 MC2.2 MD1.3 MD4.3 MD6.3 PC100.2 PC101.2 PC102.2 PC103.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.1 PC118.2 PC119.2 PC120.2 PC125.1 PC126.2 PC127.2 PC128.2 PC129.1 PC130.2 PC132.2 PC133.2 PC134.2 PC135.2 PC200.2 PC201.2 PC202.1 PC203.2 PC204.2 PC205.1 PC206.1 PC207.1 PC208.2 PC209.2 PC211.1 PC212.1 PC213.2 PC214.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC227.2 PC228.2 PC229.2 PC230.2 PC231.2 PC232.2 PC233.2 PC300.2 PC400.2 PC401.2 PC402.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC408.2 PC414.2 PC415.2 PC418.2 PC419.2 PC421.1 PC424.2 PC425.2 PC426.2 PC432.2 PC434.2 PC436.2 PC437.2 PC438.2 PC439.2 PC440.2 PC441.2 PC442.2 PC443.2 PC444.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC525.2 PC526.2 PC527.2 PC528.2 PC529.2 PC530.2 PC531.2 PC532.2 PC533.2 PC534.2 PC535.2 PC536.2 PC537.2 PC538.2 PC539.2 PC540.2 PC541.2 PC543.2 PC544.2 PC545.2 PC546.2 PC547.2 PC548.2 PC549.2 PC550.2 PC551.2 PC552.2 PC553.2 PC554.2 PC555.2 PC556.2 PC557.2 PC558.2 PC559.2 PC560.2 PC561.2 PC562.2 PC563.2 PC564.2 PC565.2 PC566.2 PC567.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC607.2 PC609.2 PC610.2 PC611.2 PC612.2 PC613.2 PC614.2 PC615.2 PC616.2 PC617.2 PC618.2 PC619.2 PC621.2 PC622.2 PC623.2 PC624.2 PC625.2 PC626.2 PC627.2 PC628.2 PC629.2 PC630.2 PC631.2 PC632.2 PC634.2 PC635.2 PC636.2 PC638.2 PC639.2 PC640.2 PC641.2 PC642.2 PC643.2 PC644.2 PC645.2 PC646.2 PC648.2 PC649.2 PC708.2 PC712.1 PC713.1 PC715.2 PC716.2 PC802.2 PC803.2 PC806.2 PC814.2 PC817.2 PC818.2 PC820.2 PC821.2 PC822.2 PC823.2 PC824.2 PC900.2 PC903.2 PC910.2 PC911.2 PC912.2 PC1002.2 PC1003.2 PC1013.2 PC1014.2 PC1015.2 PC1017.2 PC1018.2 PC1100.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1151.2 PC1152.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1162.2 PC1163.2 PC1164.2 PC1165.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1182.2 PC1183.2 PC1184.2 PC1185.2 PC1186.2 PC1187.2 PC1188.2 PC1189.2 PC1190.2 PC1191.2 PC1192.2 PC1193.2 PC1194.2 PC1195.2 PC1196.2 PC1197.2 PC1198.2 PC1199.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PD100.1 PD101.1 PQ104.1 PQ104.4 PQ109.1 PQ110.1 PQ110.4 PQ111.1 PQ112.1 PQ115.1 PQ115.4 PQ120.1 PQ120.4 PQ204.1 PQ204.4 PQ205.1 PQ205.4 PQ206.1 PQ206.4 PQ210.3 PQ214.1 PQ214.4 PQ300.3 PQ400.5 PQ400.6 PQ400.7 PQ500.5 PQ500.6 PQ500.7 PQ501.5 PQ501.6 PQ501.7 PQ502.5 PQ502.6 PQ502.7 PQ600.5 PQ600.6 PQ600.7 PQ601.5 PQ601.6 PQ601.7 PQ800.5 PQ800.6 PQ800.7 PQ900.5 PQ900.6 PQ900.7 PQ1000.5 PQ1000.6 PQ1000.7 PR105.2 PR109.2 PR110.2 PR111.2 PR112.2 PR113.2 PR117.1 PR129.2 PR132.2 PR134.2 PR137.2 PR142.1 PR162.2 PR204.2 PR211.1 PR217.2 PR219.2 PR222.2 PR244.2 PR246.2 PR252.2 PR255.2 PR258.2 PR301.2 PR306.2 PR424.2 PR507.1 PR518.2 PR604.1 PR612.2 PR704.1 PR733.1 PR745.2 PR1029.2 PU100.4 PU101.3 PU102.2 PU200.2 PU201.3 PU202.2 PU203.3 PU204.3 PU205.3 PU206.4 PU207.4 PU208.2 PU209.3 PU300.4 PU300.6 PU400.22 PU500.A1 PU500.A2 PU500.A3 PU500.A12 PU500.A13 PU500.A14 PU500.B1 PU500.B2 PU500.B3 PU500.B6 PU500.B12 PU500.B13 PU500.B14 PU500.C1 PU500.C2 PU500.C13 PU500.C14 PU500.D12 PU500.G8 PU500.G10 PU500.H2 PU500.H9 PU500.H10 PU500.M1 PU500.M2 PU500.M13 PU500.M14 PU500.N1 PU500.N2 PU500.N5 PU500.N10 PU500.N13 PU500.N14 PU500.P1 PU500.P2 PU500.P10 PU500.P13 PU500.P14 PU800.A1 PU800.A2 PU800.A8 PU800.A9 PU800.A10 PU800.B1 PU800.B2 PU800.B8 PU800.B9 PU800.B10 PU800.C10 PU800.E6 PU800.J1 PU800.J2 PU800.J3 PU800.J4 PU800.J9 PU800.J10 PU800.K1 PU800.K2 PU800.K9 PU800.K10 PU801.6 PU801.9 PU901.6 PU901.9 Q10.4 Q25.3 Q340.3 Q341.1 Q341.4 Q342.1 Q342.4 Q347.4 QR1.3 QT18.3 QT20.1 QT20.4 QT21.1 QT21.4 R2.2 R3.2 R4.2 R5.2 R10.2 R11.2 R12.2 R13.2 R16.2 R17.2 R25.2 R29.2 R31.2 R32.2 R33.2 R41.2 R42.2 R43.2 R60.2 R62.1 R67.2 R73.1 R78.1 R106.2 R109.2 R110.2 R112.2 R129.2 R137.2 R161.1 R162.1 R173.1 R174.2 R181.2 R186.1 R188.1 R190.1 R193.2 R194.1 R197.1 R203.1 R207.1 R208.1 R209.1 R217.1 R220.1 R223.1 R225.1 R232.1 R238.1 R389.1 R391.2 R392.2 R924.2 R1032.2 R1056.2 R1062.1 R1063.1 R1064.1 R1076.2 R1101.2 R1391.2 R1392.1 R1393.1 R1394.2 R1395.2 R1396.2 R1403.2 R1405.2 R1408.2 R1409.2 R1413.2 R1414.2 R1415.2 R1416.2 R1418.2 R1419.2 R1420.2 R1421.2 R1445.2 R1450.2 R1468.2 R1473.2 R1474.1 R1475.1 R1476.1 R1479.1 R1481.1 R1482.1 R1483.1 R1484.1 R1485.1 R5671.1 R5682.1 R5683.1 R5684.2 R5686.2 R5716.2 R5719.2 R5728.1 R5732.1 R5742.1 RA28.2 RA62.2 RA67.1 RA72.2 RC2.1 RC3.1 RC11.2 RC14.2 RC15.2 RC23.2 RC24.2 RC35.2 RC41.2 RC45.2 RC46.2 RC47.2 RC48.1 RC60.1 RC61.1 RC64.1 RC87.2 RC91.2 RC98.2 RC136.2 RC141.1 RC148.1 RC150.1 RC151.2 RC152.1 RC153.2 RC237.2 RH1.1 RH44.1 RH46.2 RH47.1 RH49.1 RH50.1 RH129.1 RH139.1 RH142.2 RH143.2 RH145.1 RH147.2 RH178.2 RH183.1 RH185.1 RR6.1 RT2.2 RT3.2 RT11.1 RT12.1 RT13.2 SW1.2 SW1.4 U3.A2 U3.A3 U3.A4 U3.A5 U3.A8 U3.A12 U3.A14 U3.B1 U3.B3 U3.B4 U3.C1 U3.C2 U3.C4 U3.D1 U3.D2 U3.D3 U3.D4 U3.D12 U3.D14 U3.D17 U3.E5 U3.E6 U3.E7 U3.E8 U3.E9 U3.E10 U3.E11 U3.E12 U3.F1 U3.F5 U3.F12 U3.F13 U3.F17 U3.G1 U3.G5 U3.G15 U3.G16 U3.H5 U3.H12 U3.H14 U3.H15 U3.J5 U3.J17 U3.K5 U3.L5 U3.L12 U3.L14 U3.M1 U3.M4 U3.M5 U3.M6 U3.M8 U3.M11 U3.M17 U3.N6 U3.N13 U3.N17 U3.P1 U3.P4 U3.P8 U3.P11 U3.P14 U3.R7 U3.R8 U3.R16 U3.R17 U3.T7 U3.T15 U3.T17 U3.U4 U3.U6 U3.U9 U3.U12 U3.U13 U3.U15 U3.U16 U4.A2 U4.A3 U4.A4 U4.A5 U4.A8 U4.A12 U4.A14 U4.B1 U4.B3 U4.B4 U4.C1 U4.C2 U4.C4 U4.D1 U4.D2 U4.D3 U4.D4 U4.D12 U4.D14 U4.D17 U4.E5 U4.E6 U4.E7 U4.E8 U4.E9 U4.E10 U4.E11 U4.E12 U4.F1 U4.F5 U4.F12 U4.F13 U4.F17 U4.G1 U4.G5 U4.G15 U4.G16 U4.H5 U4.H12 U4.H14 U4.H15 U4.J5 U4.J17 U4.K5 U4.L5 U4.L12 U4.L14 U4.M1 U4.M4 U4.M5 U4.M6 U4.M8 U4.M11 U4.M17 U4.N6 U4.N13 U4.N17 U4.P1 U4.P4 U4.P8 U4.P11 U4.P14 U4.R7 U4.R8 U4.R16 U4.R17 U4.T7 U4.T15 U4.T17 U4.U4 U4.U6 U4.U9 U4.U12 U4.U13 U4.U15 U4.U16 U7.2 U13.3 U15.9 U15.16 U15.23 U15.32 U15.33 U16.A2 U16.B4 U16.F4 U16.F7 U16.G4 U16.H7 U18.4 U20.14 U20.15 U20.16 U20.17 U20.18 U20.19 U20.20 U21.6 U21.18 U21.19 U21.20 U21.21 U23.2 U23.11 U23.19 U23.52 U23.61 U24.2 U24.7 U27.A2 U27.A3 U27.F4 U27.F11 U27.G2 U27.H4 U27.J4 U27.N3 U30.11 U30.15 U31.5 U31.9 U32.11 U32.15 U33.11 U33.15 U34.11 U34.15 U36.11 U36.15 U37.11 U37.15 U38.5 U38.9 U40.11 U40.15 U41.11 U41.15 U709.5 U710.5 U711.5 U712.3 U713.4 U713.9 U715.2 U716.4 U716.9 U717.A1 U717.B8 U717.D6 U717.D8 U717.E5 U717.E6 U717.E7 U717.E8 U717.F5 U717.F6 U717.F7 U717.F8 U717.G5 U717.G6 U717.G7 U717.G8 U717.H4 U717.H5 U717.H8 U717.L1 U717.L11 U718.4 U718.9 U719.A1 U719.B8 U719.D6 U719.D8 U719.E5 U719.E6 U719.E7 U719.E8 U719.F5 U719.F6 U719.F7 U719.F8 U719.G5 U719.G6 U719.G7 U719.G8 U719.H4 U719.H5 U719.H8 U719.L1 U719.L11 U721.5 U721.9 UA1.57 UA2.15 UA2.16 UA2.20 UA2.38 UA2.47 UA2.49 UC1.A5 UC1.A14 UC1.AA24 UC1.AA27 UC1.AA30 UC1.AA33 UC1.AA36 UC1.AA40 UC1.AA43 UC1.AA44 UC1.AA46 UC1.AA47 UC1.AA49 UC1.AA50 UC1.AA51 UC1.AA55 UC1.AA57 UC1.AA59 UC1.AA61 UC1.AA63 UC1.AB13 UC1.AC15 UC1.AC16 UC1.AC18 UC1.AC19 UC1.AC21 UC1.AC27 UC1.AC33 UC1.AC36 UC1.AC40 UC1.AD13 UC1.AE2 UC1.AE4 UC1.AE8 UC1.AE10 UC1.AE21 UC1.AE30 UC1.AE43 UC1.AE44 UC1.AE46 UC1.AE47 UC1.AE49 UC1.AE50 UC1.AE51 UC1.AF13 UC1.AF15 UC1.AF16 UC1.AF21 UC1.AF23 UC1.AF33 UC1.AF36 UC1.AF40 UC1.AF54 UC1.AF56 UC1.AF58 UC1.AF60 UC1.AF62 UC1.AF64 UC1.AG59 UC1.AH16 UC1.AH23 UC1.AH24 UC1.AH27 UC1.AH30 UC1.AH33 UC1.AH36 UC1.AH40 UC1.AH43 UC1.AH44 UC1.AH46 UC1.AH47 UC1.AH49 UC1.AH50 UC1.AH51 UC1.AH54 UC1.AJ59 UC1.AK1 UC1.AK3 UC1.AK5 UC1.AK7 UC1.AK9 UC1.AK11 UC1.AK13 UC1.AK15 UC1.AK16 UC1.AK24 UC1.AK27 UC1.AK33 UC1.AK36 UC1.AK40 UC1.AK54 UC1.AL16 UC1.AL21 UC1.AL24 UC1.AL27 UC1.AL30 UC1.AL33 UC1.AL36 UC1.AL40 UC1.AL43 UC1.AL44 UC1.AL46 UC1.AL47 UC1.AL49 UC1.AL50 UC1.AL51 UC1.AL53 UC1.AL59 UC1.AM54 UC1.AM64 UC1.AN16 UC1.AN18 UC1.AN19 UC1.AN21 UC1.AN24 UC1.AN27 UC1.AN33 UC1.AN36 UC1.AN40 UC1.AN59 UC1.AP54 UC1.AP64 UC1.AR2 UC1.AR4 UC1.AR6 UC1.AR8 UC1.AR10 UC1.AR12 UC1.AR15 UC1.AR18 UC1.AR27 UC1.AR30 UC1.AR33 UC1.AR36 UC1.AR40 UC1.AR43 UC1.AR44 UC1.AR46 UC1.AR47 UC1.AR49 UC1.AR50 UC1.AR51 UC1.AR59 UC1.AT27 UC1.AT54 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AU61 UC1.AU63 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV52 UC1.AV54 UC1.AW17 UC1.AW19 UC1.AW21 UC1.AW23 UC1.AW25 UC1.AY16 UC1.AY24 UC1.AY26 UC1.AY28 UC1.AY30 UC1.AY32 UC1.AY34 UC1.AY36 UC1.AY38 UC1.AY40 UC1.AY42 UC1.AY44 UC1.AY46 UC1.AY48 UC1.AY50 UC1.AY52 UC1.BA1 UC1.BA3 UC1.BA5 UC1.BA7 UC1.BA9 UC1.BA11 UC1.BA53 UC1.BA58 UC1.BA64 UC1.BB20 UC1.BB22 UC1.BB24 UC1.BB26 UC1.BB28 UC1.BB30 UC1.BB32 UC1.BB34 UC1.BB36 UC1.BB38 UC1.BB40 UC1.BB42 UC1.BB44 UC1.BB46 UC1.BB48 UC1.BB50 UC1.BB52 UC1.BB54 UC1.BB59 UC1.BC17 UC1.BC29 UC1.BC47 UC1.BD20 UC1.BD38 UC1.BD56 UC1.BD63 UC1.BE12 UC1.BE29 UC1.BE31 UC1.BE33 UC1.BE35 UC1.BE47 UC1.BF20 UC1.BF38 UC1.BF56 UC1.BF59 UC1.BG2 UC1.BG4 UC1.BG6 UC1.BG8 UC1.BG12 UC1.BG15 UC1.BG17 UC1.BG29 UC1.BG63 UC1.BH20 UC1.BH22 UC1.BH24 UC1.BH26 UC1.BH28 UC1.BH32 UC1.BH34 UC1.BH36 UC1.BH38 UC1.BH40 UC1.BH42 UC1.BH44 UC1.BH46 UC1.BH48 UC1.BH50 UC1.BH52 UC1.BH54 UC1.BH56 UC1.BH59 UC1.BJ29 UC1.BJ47 UC1.BJ62 UC1.BK20 UC1.BK38 UC1.BK56 UC1.BL1 UC1.BL8 UC1.BL29 UC1.BL31 UC1.BL33 UC1.BL35 UC1.BL47 UC1.BM11 UC1.BM14 UC1.BM16 UC1.BM18 UC1.BM20 UC1.BM38 UC1.BN6 UC1.BN29 UC1.BP1 UC1.BP22 UC1.BP28 UC1.BP30 UC1.BP36 UC1.BP38 UC1.BP44 UC1.BP46 UC1.BP52 UC1.BP54 UC1.BP60 UC1.BP62 UC1.C14 UC1.C40 UC1.D1 UC1.D6 UC1.D8 UC1.D10 UC1.D62 UC1.E14 UC1.E16 UC1.E18 UC1.E20 UC1.E22 UC1.E24 UC1.E26 UC1.E28 UC1.E30 UC1.E32 UC1.E34 UC1.E36 UC1.E38 UC1.E40 UC1.E42 UC1.E44 UC1.E46 UC1.E48 UC1.E50 UC1.E52 UC1.E54 UC1.E56 UC1.E59 UC1.F62 UC1.G14 UC1.J3 UC1.J5 UC1.J7 UC1.J9 UC1.J14 UC1.J62 UC1.K15 UC1.K17 UC1.K19 UC1.K21 UC1.K23 UC1.K25 UC1.K27 UC1.K29 UC1.K31 UC1.K33 UC1.K35 UC1.K37 UC1.K39 UC1.K41 UC1.K43 UC1.K45 UC1.K47 UC1.K49 UC1.K51 UC1.K53 UC1.K55 UC1.L14 UC1.L57 UC1.L59 UC1.L61 UC1.M3 UC1.N14 UC1.N16 UC1.N18 UC1.N20 UC1.N22 UC1.N24 UC1.N26 UC1.P54 UC1.R2 UC1.R4 UC1.R6 UC1.R8 UC1.R10 UC1.R18 UC1.R24 UC1.R30 UC1.R33 UC1.R36 UC1.R40 UC1.R43 UC1.R44 UC1.R46 UC1.R47 UC1.R49 UC1.R50 UC1.R55 UC1.T13 UC1.T18 UC1.T21 UC1.T23 UC1.T24 UC1.T33 UC1.T36 UC1.T40 UC1.T56 UC1.T58 UC1.T60 UC1.T62 UC1.T64 UC1.V13 UC1.V24 UC1.V27 UC1.V30 UC1.V33 UC1.V36 UC1.V40 UC1.V43 UC1.V44 UC1.V46 UC1.V47 UC1.V49 UC1.V50 UC1.V51 UC1.Y1 UC1.Y3 UC1.Y5 UC1.Y7 UC1.Y9 UC1.Y11 UC1.Y13 UC1.Y15 UC1.Y16 UC1.Y24 UC1.Y27 UC1.Y33 UC1.Y36 UC1.Y40 UH1.3 UH2.3 UR1.33 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 Y1.2 Y1.4 Y4.2 Y4.4 YH1.2 YH1.4
GNDA_CHG: PC409.1 PC411.2 PC422.2 PC427.2 PC428.2 PC429.1 PC431.2 PC433.2 PQ402.1 PQ402.4 PR405.2 PR414.2 PR419.2 PR424.1 PR425.2 PR426.1 PU400.29
SGND4: PR507.2 PR508.2 PU500.K3
SGND11: PR612.1 PU500.M7
SGND12: PR604.2 PU500.P11
VBUS1_ACOK: PC103.1 PR126.2 PR130.2 PR143.2 PU100.7 U27.N9
VBUS2_ACOK: PC102.1 PR115.2 PR128.2 PR144.1 PR147.2 PU100.1 U27.B4
VCC0V9_CIO: C1323.2 C1324.2 C1325.2 UT1.R8 UT1.R9 UT1.R11 UT1.R12
VCC0V9_DP: C1292.2 C1293.2 C1295.2 C1296.2 C1297.2 C1298.2 C1299.2 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
VCC0V9_LVR_OUT: C1319.1 C1320.1 C1406.2 C1407.2 UT1.F18 UT1.H11 UT1.H18 UT1.J11
VCC0V9_PCIE: C1294.2 C1307.2 C1308.2 C1309.2 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
VCC0V9_SVR: C1300.2 C1301.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1403.1 C1404.1 C1405.1 L63.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
VCC0V9_USB: C1315.2 UT1.R15 UT1.R16
VCC1V8A_TBTA_LDO: C1335.1 U717.K1
VCC1V8A_TBTB_LDO: C1351.1 U719.K1
VCC1V8D_TBTA_LDO: C1336.1 R5685.2 U717.A2
VCC1V8D_TBTB_LDO: C1352.1 R5687.2 U719.A2
VCC3V3_ANA_PCIE: C1326.2 UT1.L16
VCC3V3_ANA_USB2: C1327.2 UT1.J16
VCC3V3_LC: C1271.2 C1285.1 R1379.2 R1380.2 R1381.2 R1382.2 R1383.1 R1384.1 R1385.1 R1386.1 U716.8 UT1.R6
VCC3V3_PD_LDO: PC120.1 PD103.1 PD104.1 PR115.1 PR126.1 PR133.1 PR138.1 PR156.2 PU100.8
VCC3V3_SX_SYS_A: C1338.1 R5698.2 R5699.2 R5700.2 U717.B1 U717.H1
VCC3V3_SX_SYS_B: C1354.1 R5701.2 R5730.2 R5731.2 U719.B1 U719.H1
VCC3V3_TBTA_LDO: C1330.1 C1342.1 PD103.2 R210.1 R213.1 R214.1 R215.1 R1449.1 R1459.1 R1462.1 R1463.1 R1480.1 R5700.1 R5759.2 U717.G1 U718.8
VCC3V3_TBTA_SX: C1329.1 U717.H2
VCC3V3_TBTB_LDO: C1346.1 PD104.2 R1454.1 R1460.1 R1461.1 R1464.1 R1477.1 R1478.1 R5701.1 R5760.2 U719.G1
VCC3V3_TBTB_SX: C1345.1 U719.H2
VCC5V0_SYS: C1331.1 C1332.1 C1333.1 C1334.1 C1347.1 C1348.1 C1349.1 C1350.1 R1424.2 U717.A11 U717.B11 U717.C11 U717.D11 U717.H10 U719.A11 U719.B11 U719.C11 U719.D11 U719.H10
VCCGT_SENSE: PR913.2 RC139.2 UC1.N52
VCCGT_SENSE_1: PC905.1 PR908.1 PR913.1 PU800.D1
VCCIO_SENSE: PR509.1 RC97.2 UC1.AT24
VCCPRIM_VID0: U27.J11 UC1.BA13
VCCPRIM_VID1: U27.C3 UC1.BB12
VCCSA_SENSE: PR1024.2 RC149.2 UC1.M29
VCCSA_SENSE_1: PC1005.1 PR1008.1 PR1024.1 PU800.G7
VCCSENSE: PR826.2 RC147.2 UC1.L34
VCCSENSE_1: PC809.1 PR821.1 PR826.1 PU800.C2
VDDTAB3: PC229.1 PR221.2 PR222.1 PR230.1 PU206.3
VDDTAB4: PC228.1 PR220.2 PR221.1 PR256.2 PU206.6
VIN9: PC600.1 PC601.1 PC645.1 PL600.2 PU500.A10 PU500.B10
VIN12: PC602.1 PC603.1 PC649.1 PL601.1 PU500.N8 PU500.P8
VINTAB: C1419.1 C1420.1 C1421.1 C1422.1 D17.2 D17.3 JPOGO.33 JPOGO.34 JPOGO.35 JPOGO.36 JPOGO.37 JPOGO.38 JPOGO.39 JPOGO.40 JPOGO.41 JPOGO.42 JPOGO.43 JPOGO.44 JPOGO.45 JPOGO.46 JPOGO.47 JPOGO.48 JPOGO.49 JPOGO.50 JPOGO.51 JPOGO.52 PC227.1 PQ202.5
VSSGT_SENSE: PR914.2 RC141.2 UC1.P52
VSSGT_SENSE_1: PR914.1 PU800.C1
VSSIO_SENSE: PR508.1 RC98.1 UC1.AR24
VSSSA_SENSE: PR1028.2 RC150.2 UC1.N28
VSSSA_SENSE_1: PR1028.1 PU800.H7
VSSSENSE: PR827.2 RC148.2 UC1.L32
VSSSENSE_1: PR827.1 PU800.D2
+AMP_AVDD1: CA109.1 CA110.1 LA19.1 UA2.42 UA2.43
+BATT: JBAT100.1 JBAT100.2 JBAT100.3 PC108.1 PC109.1 PR165.2 PR166.2 PR167.2
+DCIN: PC421.2 PR403.2 PU400.28
+EDP_COM: RC4.1 UC1.A50
+INV_PWR_SRC: C49.1 C52.1 C58.1 JLVDS1.12 JLVDS1.13 JLVDS1.14 R5705.2
+IO_OUT: C108.1 RH78.1 RH79.1 U16.E7
+LCDVDD: C38.1 C41.1 C46.1 C47.1 C48.1 JLVDS1.30 JLVDS1.31 JLVDS1.32 JLVDS1.33 R24.2 RC240.2 RC241.2
+ODR_PWR: CR17.1 CR18.1 JCR1.4 UR1.12
+PBATT: PC107.1 PD400.2 PQ401.5 PR165.1 PR166.1 PR167.1 PR422.2
+PD_VBUS_A: PD106.2 R1428.2 U717.A6 U717.A7 U717.A8 U717.B7
+PD_VBUS_B: PD105.2 R1427.2 U719.A6 U719.A7 U719.A8 U719.B7
+PWR_SRC_AC: PC400.1 PC401.1 PC402.1 PC403.1 PC404.1 PC405.1 PC406.1 PC407.1 PC408.1 PL400.2 PQ208.5 PQ400.2 PQ400.3 PQ400.4 PQ400.10
+RTCBATT: C1425.1 JRTC1.1 PU500.M11 R716.2
+RTCVCC: C715.1 CC33.1 CLRP4.1 PC715.1 PR719.2 PR742.1 R156.1 R5758.1 RA15.1 RH42.1 RH45.1 RH64.1 UC1.AR19 UC1.AT19
+RTCVCC_EC: C188.1 R156.2 R157.2 R182.1 R1061.1 R1081.1 R5588.2 U27.B2
+SD_VDD2: CR14.1 CR15.1 JCR1.13 UR1.13
+SIM_PWR: C80.1 C81.1 D6.5 JNGFF1.28 JSIM1.1
+V_DDR_0_DQ_VREF: C6.1 R8.1 UC1.AN53
+V_DDR_1_DQ_VREF: C8.1 R15.1 UC1.AW53
+V_DDR_VREF_CA: C7.1 R9.1 UC1.AR53
+V_VDDQ_VTT: PC631.1 PC632.1 PU500.D1 PU500.D2 PU500.E3
+VR_CAP: C196.1 U27.H1
AC_DIS: PR118.1 PR131.1 U27.B6
AC_PRESENT: RH58.2 RH115.2 T37.1(TP-1) U27.N8
AC_PRESENT_R: RH58.1 UC1.BD14
ACCEL_INT1#: R398.2 R399.1 UC1.BF11
ACCEL_INT1#_L: JSER.7 R391.1 R395.1 R399.2 U20.11
ACCEL_INT2#: DH6.2 R400.1 UC1.BD2
ACCEL_INT2#_L: JSER.6 R392.1 R396.1 R400.2 U20.12
ACTIV_LED: JDMIC1.8 Q343.1
ACTIV_LED_L: C1408.1 Q343.3 R66.2 R5711.1 R5712.2
ALERT_B: PR838.1 PU800.K4
ALLSYS_PWRGD: PR801.1 PR804.1 PU500.J6 R176.1
ALWON: D22.2 PU500.M10 R184.2 R208.2 R1062.2 U31.3
AMP_ASEL: RA62.1 RA64.2 UA2.14
AMP_I2S_BCLK: CA49.1 RA50.1 UA2.6
AMP_I2S_BCLK_R: RA50.2 UA1.56
AMP_I2S_MCLK: CA48.1 RA49.1 UA2.5
AMP_I2S_MCLK_R: RA49.2 UA1.55
AMP_LDO_A1.5V: CA105.1 CA138.1 UA2.18
ANA2_EN: U16.C4 U713.5
AUDIO_IRQ: RA26.2 RA28.1 UA1.6
AUDIO_PWR_EN: R232.2 R5755.2 U36.3 U36.5 U37.3 U37.5 U38.3 UC1.BL3
AUX_EN_WLAN: D10.3 U27.L13
B4_SLP_S0#: R166.1 UC1.BC11
B+: C50.1 PC414.1 PC415.1 PC419.1 PC434.1 PC436.1 PC437.1 PC438.1 PC439.1 PC440.1 PC441.1 PC442.1 PC443.1 PC444.1 PC700.1 PD203.2 PL401.2 PL500.2 PL501.1 PL504.2 PL505.1 PL508.1 PL600.1 PL601.2 PL604.1 PQ207.5 PR300.1 PR410.1 PR700.1 PR839.1 PR840.1 PR841.1 PU500.H12 PU500.H14 U711.3 U711.4
B+_PMIC: PC503.1 PC504.1 PC552.1 PC635.1 PC636.1 PC648.1 PL501.2 PQ500.2 PQ500.3 PQ500.4 PQ500.10 PQ601.2 PQ601.3 PQ601.4 PQ601.10
BASE_DDI_AUX_DEV_DN: JPOGO.17 MD4.4 MD4.7 R119.2
BASE_DDI_AUX_DEV_DN_L: R119.1 R127.1 U23.27
BASE_DDI_AUX_DEV_DP: JPOGO.15 MD4.5 MD4.6 R120.2
BASE_DDI_AUX_DEV_DP_L: R120.1 R137.1 U23.26
BASE_DDI_LANE0_DEV_DN: C206.2 JPOGO.5
BASE_DDI_LANE0_DEV_DN_L: C206.1 U23.49
BASE_DDI_LANE0_DEV_DP: C258.2 JPOGO.3
BASE_DDI_LANE0_DEV_DP_L: C258.1 U23.50
BASE_DDI_LANE1_DEV_DN: C260.2 JPOGO.6
BASE_DDI_LANE1_DEV_DN_L: C260.1 U23.46
BASE_DDI_LANE1_DEV_DP: C259.2 JPOGO.4
BASE_DDI_LANE1_DEV_DP_L: C259.1 U23.47
BASE_DDI_LANE2_DEV_DN: C264.2 JPOGO.11
BASE_DDI_LANE2_DEV_DN_L: C264.1 U23.44
BASE_DDI_LANE2_DEV_DP: C262.2 JPOGO.9
BASE_DDI_LANE2_DEV_DP_L: C262.1 U23.45
BASE_DDI_LANE3_DEV_DN: C266.2 JPOGO.12
BASE_DDI_LANE3_DEV_DN_L: C266.1 U23.41
BASE_DDI_LANE3_DEV_DP: C265.2 JPOGO.10
BASE_DDI_LANE3_DEV_DP_L: C265.1 U23.42
BASE_DDSP_HPD: R138.1 U23.48 U27.K13
BASE_DDSP_HPD_L: JPOGO.65 MD4.1 MD4.9 R138.2
BASE_DET#: PR226.2 PU201.2 Q347.5 R170.1 U27.K10
BASE_I2C_ALERT#: Q347.1 R1053.1 R5750.1 U27.B5
BASE_KEYSSA_STATE: QT20.2 R142.2
BASE_KEYSSA_STATE_L: JPOGO.64 R142.1
BASE_SMB_EN: Q347.2 Q347.3 Q348.2 Q348.5 R5746.2
BASE_SMBCLK: Q348.4 R168.1 R5751.1 U27.A9
BASE_SMBDAT: Q348.1 R169.1 R5752.1 U27.D8
BAT_B+: PC424.1 PC425.1 PC426.1 PQ401.1 PQ401.2 PQ401.3 PR410.4 PR703.2
BATDRV#: PQ401.4 PR420.2
BATLOW#: RH117.2 UC1.BD16
BATT_PRS#: JBAT100.6 PD101.2 PR123.1 PR161.2
BEEP: RA18.1 U27.M8
BIA_PWM_EC: D3.2 U27.M10
BOARD_ID: C189.1 R155.2 U27.G1
BOARD_TYPE: R5738.2 U27.N7
BOOT4: PR500.2 PU500.K2
BOOT5: PR510.2 PU500.A9
BOOT6: PR516.2 PU500.J13
BOOT7: PR501.1 PU500.F14
BOOT8: PR511.1 PU500.C5
BOOT9: PR601.2 PU500.C11
BOOT10: PR605.2 PU500.F2
BOOT11: PR609.2 PU500.N7
BOOT12: PR600.1 PU500.M9
BQ2477_CSIP: PR400.2 PR401.1
BQ24777_CSIN: PR400.3 PR402.1
BQ24777_CSON: PC430.2 PC431.1 PR410.3 PU400.19
BQ24777_CSOP: PC429.2 PC430.1 PR410.2 PU400.20
BQ24777_REGN: PC418.1 PR409.1 PR418.2 PR421.1 PU400.24
BT_OFF#_R: D4.1 JNGFF3.46 R42.1
BT_ON/OFF#: D4.3 UC1.AA10
BT_RADIO_DIS#: D4.2 U27.L11
BT_UART_MUX_SEL: TC27.1(TP-1) UC1.AG10
CAM_PD: C1430.1 J3.11 R92.1
CD_WAKE#: RR1.1 UR1.32
CEXT: C57.1 U23.17
CFD_PWRBTN#_XDP: CC162.2 JXDP2.41 RC66.2
CFG0: JXDP2.9 RC42.1 UC1.G52
CFG0_R: JXDP2.45 RC42.2
CFG1: JXDP2.11 UC1.F53
CFG2: JXDP2.15 UC1.J52
CFG3: JXDP2.17 RC31.1 UC1.H53
CFG4: JXDP2.27 RC152.2 UC1.H55
CFG5: JXDP2.29 UC1.D55
CFG6: JXDP2.33 UC1.C56
CFG7: JXDP2.35 UC1.F55
CFG8: JXDP2.10 UC1.D61
CFG9: JXDP2.12 UC1.G58
CFG10: JXDP2.16 UC1.D57
CFG11: JXDP2.18 UC1.F61
CFG12: JXDP2.28 UC1.J60
CFG13: JXDP2.30 UC1.J58
CFG14: JXDP2.34 UC1.H61
CFG15: JXDP2.36 UC1.H59
CFG16: JXDP2.6 UC1.J54
CFG17: JXDP2.4 UC1.G54
CFG18: JXDP2.24 UC1.G56
CFG19: JXDP2.22 UC1.J56
CFG_RCOMP: RC151.1 UC1.A54
CHG_BTS: PR406.1 PU400.25
CHG_BTS_C: PC423.1 PR406.2
CHG_LED#: Q341.2 R19.2 U27.E3
CHG_LED#_R: C1427.1 JPB1.5 R1104.2
CHG_LGATE: PQ400.8 PU400.23
CHG_PMIC_SMBCLK: PR408.1 PR712.1 U27.B8
CHG_PMIC_SMBDAT: PR407.1 PR713.1 U27.C8
CHG_SW: PC423.2 PL401.1 PQ400.9 PR413.2 PU400.27
CHG_UGATE: PQ400.1 PU400.26
CHRGR_VIN: C1340.1 C1341.1 PC122.1 PC124.1 PC233.1 PD401.2 PQ101.1 PQ101.2 PQ101.3 PQ103.3 PQ108.1 PQ108.2 PQ108.3 PQ203.5 PR106.1 PR139.1 PR141.1 PR400.1 PR404.1 PR427.1 R1427.1 R1428.1
CK_XDP: RC70.1 UC1.G34
CK_XDP#: RC69.1 UC1.J34
CL_CLK: JNGFF3.34 UC1.F12
CL_DATA: JNGFF3.32 UC1.D12
CL_RST#: JNGFF3.30 UC1.B12
CLK_LPC_DEBUG: CH41.1 JLPDE1.10 RH12.2
CLK_PCI_MEC: CH42.1 R180.1 RH11.2 U27.N6
CLK_PCIE2: C251.1 LR1.1 RR16.1 UC1.G36
CLK_PCIE2#: C228.1 LR1.4 RR17.1 UC1.J36
CLK_PCIE2#_R: LR1.3 RR17.2 UR1.6
CLK_PCIE2_R: LR1.2 RR16.2 UR1.5
CLK_PCIE3: C269.1 L25.4 R1095.1 UC1.G38
CLK_PCIE3#: C268.1 L25.1 R1096.1 UC1.J38
CLK_PCIE3#_R: JNGFF2.53 L25.2 R1096.2
CLK_PCIE3_R: JNGFF2.55 L25.3 R1095.2
CLK_PCIE4: L26.1 R1098.1 UC1.F37
CLK_PCIE4#: L26.4 R1097.1 UC1.H37
CLK_PCIE4#_R: JNGFF3.41 L26.3 R1097.2
CLK_PCIE4_R: JNGFF3.39 L26.2 R1098.2
CLK_PCIE5: L27.1 R1100.1 UC1.F39
CLK_PCIE5#: L27.4 R1099.1 UC1.H39
CLK_PCIE5#_R: JNGFF1.45 L27.3 R1099.2
CLK_PCIE5_R: JNGFF1.47 L27.2 R1100.2
CLK_REQ2#: RH30.2 UC1.BD10 UR1.2
CLK_REQ3#: JNGFF2.52 RH33.2 UC1.AV5
CLK_REQ4#: JNGFF3.45 RH35.2 UC1.AV7
CLK_REQ5#: JNGFF1.44 RH37.2 UC1.BC5
CLK_SMB: JBAT100.4 PD100.2 PR121.1
CLK_XDP#_L: JXDP2.42 RC69.2
CLK_XDP_L: JXDP2.40 RC70.2
CLKOUT_LPC0: RH11.1 UC1.BJ10
CLKOUT_LPC1: RH12.1 UC1.BF5
CLKRUN#: RH13.1 U27.J3 UC1.BH11
CMSRC: PR427.2 PU400.3
CODEC_MUTE#: DA7.1 RA17.1 RA25.2 RA72.1 UA1.52 UA2.11
CORE_FB: L17.2 R81.1 U16.H6
CORE_SW: L17.1 U16.G7
CPU_B+: PC817.1 PC818.1 PC820.1 PC821.1 PC822.1 PC823.1 PC824.1 PC910.1 PC911.1 PC1013.1 PC1014.1 PC1017.1 PC1018.1 PC1245.1 PQ800.2 PQ800.3 PQ800.4 PQ800.10 PQ900.2 PQ900.3 PQ900.4 PQ900.10 PQ1000.2 PQ1000.3 PQ1000.4 PQ1000.10 PR839.2 PR840.2 PR841.2 PU800.A5 PU800.B5 PU800.C6
CPU_POPIRCOMP: RC14.1 UC1.BN17
CPU_XDP_TCK: RC23.1 RC27.1 UC1.D53
CPU_XDP_TDI: RC25.1 RC43.1 UC1.C54
CPU_XDP_TDO: RC5.1 RC18.1 UC1.G48
CPU_XDP_TMS: RC20.1 RC44.1 UC1.C59
CPU_XDP_TRST#: RC12.1 RC24.1 UC1.F47
CPUBST1: PR805.1 PU801.1
CPUDRVH1: PQ800.1 PU801.8
CPUDRVL1: PR806.1 PU801.5
CPUDRVL1_1: PQ800.8 PR806.2
CPUSW1: PC804.2 PL802.1 PQ800.9 PR807.1 PR808.1 PU801.7
CSI2_COMP: RC64.2 UC1.A11
DAT_SMB: JBAT100.5 PD100.3 PR122.1
DCPDSW_1P0: CC42.1 UC1.AL2 UC1.AM1
DD: JPOGO.66 MD6.5 MD6.6 PR218.2 PR219.1 PR254.2 PU208.1
DDR_0_DQ_VREF: C2.1 R6.2 R8.2 R10.1 U3.H17 U3.U8
DDR_1_DQ_VREF: C4.1 R14.2 R15.2 R16.1 U4.H17 U4.U8
DDR_CHA_EN: RH140.1 RH142.1 UC1.AC6
DDR_CHB_EN: RH141.1 RH143.1 UC1.AB5
DDR_RCOMP_0: RC45.1 UC1.BF64
DDR_RCOMP_1: RC46.1 UC1.BJ64
DDR_RCOMP_2: RC47.1 UC1.BC64
DDR_VREF_CA: C3.1 C5.1 R7.2 R9.2 R11.1 U3.A10 U3.J1 U4.A10 U4.J1
DEBUG_UART_TX: JDEG1.9 UC1.AC4
DEVSLP0: JNGFF2.38 R1378.1 T18.1(TP-1) UC1.F10
DISPOFF#: D2.1 JLVDS1.19 R31.1
DMIC_CLK1: C280.1 CA35.1 JDMIC1.1 RA53.1
DMIC_CLK1_R: RA53.2 UA1.53
DMIC_CLK2: C284.1 CA39.1 JDMIC1.11 RA54.1
DMIC_CLK2_R: RA54.2 UA1.2
DMIC_DATA1: C279.1 CA36.1 JDMIC1.3 RA52.1
DMIC_DATA1_R: RA52.2 UA1.54
DMIC_DATA2: C283.1 CA40.1 JDMIC1.9 RA55.1
DMIC_DATA2_R: RA55.2 UA1.4
DP_CFG0: R183.2 U23.59
DP_MUX_SEL: U23.18 U27.N10
DPRC_RBIAS: RT3.1 UT1.N6
DPSNK1_AUX_N: C1270.1 UT1.W12
DPSNK1_AUX_P: C1269.1 UT1.Y12
DPSNK1_ML0_N: C1262.1 UT1.AC15
DPSNK1_ML0_P: C1261.1 UT1.AB15
DPSNK1_ML1_N: C1264.1 UT1.AC17
DPSNK1_ML1_P: C1263.1 UT1.AB17
DPSNK1_ML2_N: C1266.1 UT1.AC19
DPSNK1_ML2_P: C1265.1 UT1.AB19
DPSNK1_ML3_N: C1268.1 UT1.AC21
DPSNK1_ML3_P: C1267.1 UT1.AB21
DPSNK_RBIAS: RT13.1 UT1.Y18
DPWROK: PR232.1 PU500.K5
EC_ALWON: R184.1 U27.E1
EC_IN_VOLUMEDOWN#: C1244.1 R1057.1 R1072.1 U27.E12
EC_IN_VOLUMEUP#: C1245.1 R1060.1 R1071.1 U27.E11
EC_PROCHOT#: Q25.2 U27.K8
EC_REST#: C56.1 D22.1 U715.5
EC_SLP_S0IX#: R165.2 R166.2 U27.J12
EC_WAKE#_L: RH77.2 RH82.2 UC1.BE15
EDP_AUXN: C45.1 UC1.J42
EDP_AUXN_CONN: JLVDS1.35 L61.4
EDP_AUXN_R: C45.2 L61.1
EDP_AUXP: C44.1 UC1.G42
EDP_AUXP_CONN: JLVDS1.36 L61.3
EDP_AUXP_R: C44.2 L61.2
EDP_DISP: RC2.2 TC17.1(TP-1) UC1.A40
EDP_HPD: JLVDS1.24 RC3.2 UC1.A7
EDP_I2C_CLK: JLVDS1.17 Q346.4 RC241.1
EDP_I2C_DAT: JLVDS1.16 Q346.1 RC240.1
EDP_I2C_DELAY: Q346.2 Q346.5 R1056.1 R5743.1 R5743.2 U27.M7
EDP_TXN_P0: C42.1 UC1.H45
EDP_TXN_P0_CONN: JLVDS1.39 L58.3
EDP_TXN_P0_R: C42.2 L58.2
EDP_TXN_P1: C39.1 UC1.J44
EDP_TXN_P1_CONN: JLVDS1.42 L57.3
EDP_TXN_P1_R: C39.2 L57.2
EDP_TXN_P2: C412.1 UC1.J46
EDP_TXN_P2_CONN: JLVDS1.45 L60.3
EDP_TXN_P2_R: C412.2 L60.2
EDP_TXN_P3: C410.1 UC1.H43
EDP_TXN_P3_CONN: JLVDS1.48 L59.3
EDP_TXN_P3_R: C410.2 L59.2
EDP_TXP_P0: C43.1 UC1.F45
EDP_TXP_P0_CONN: JLVDS1.38 L58.4
EDP_TXP_P0_R: C43.2 L58.1
EDP_TXP_P1: C40.1 UC1.G44
EDP_TXP_P1_CONN: JLVDS1.41 L57.4
EDP_TXP_P1_R: C40.2 L57.1
EDP_TXP_P2: C413.1 UC1.G46
EDP_TXP_P2_CONN: JLVDS1.44 L60.4
EDP_TXP_P2_R: C413.2 L60.1
EDP_TXP_P3: C411.1 UC1.F43
EDP_TXP_P3_CONN: JLVDS1.47 L59.4
EDP_TXP_P3_R: C411.2 L59.1
EMMC_RCOMP: RC61.2 UC1.BC1
EMMC_RST_N: TC23.1(TP-1) UC1.AH11
EN_CAM: R207.2 U30.5 UC1.BB16
EN_INVPWR: R29.1 R161.2 U27.J10 U711.2
EN_PD_HV_1: PD402.2 PR103.1 PR159.2 PR235.1 PU101.1 R160.2 R1432.2
EN_PD_HV_1_R: R160.1 U27.A11
EN_PD_HV_2: PD403.2 PR135.1 PR160.2 PR236.1 PU101.2 R179.1 R1436.2
EN_PD_HV_2_R: R179.2 U27.H11
ENBKL: D2.2 UC1.D4
ENVDD: D1.1 R25.1 U7.3 U27.G3
EXT_PWR_GATE#: R1043.1 UC1.BC7
EXT_PWR_GATE#_R: R1043.2 R1225.2 U40.5
G_S1: PQ204.5 PU201.4 PU204.1
G_S3: PQ205.5 PQ210.1 PR251.2 PU205.1
GNSS_CTS_RESET_N: TC26.1(TP-1) UC1.AH9
GNSS_IRQ: R58.2 RH118.1 UC1.AL8
GNSS_IRQ_L: JNGFF1.36 R58.1
GNSS_OFF#: Q89.3 RH24.1 UC1.AL12
GNSS_OFF#_R: JNGFF1.18 Q89.4 R52.2
GNSS_SCL: R55.2 RH71.1 UC1.AT9
GNSS_SCL_L: JNGFF1.32 R55.1
GNSS_SDA: R57.2 RH70.1 UC1.AM7
GNSS_SDA_L: JNGFF1.34 R57.1
GNSS_SYSCLK: JNGFF1.38 T22.1(TP-1)
GPD11: RH116.2 UC1.BC15
GPIO170: JDEG1.6 R5676.2 U27.C11
GPIO171: JDEG1.7 R5671.2 R5677.2 U27.E10
GPP_B5: TC62.1(TP-1) UC1.BB10
GPP_B18: RC84.2 TC70.1(TP-1) UC1.BB4
GPP_B22: RC85.2 TC95.1(TP-1) UC1.AW8
GPP_D16: RC86.2 TC88.1(TP-1) UC1.V9
GPP_F0: TC31.1(TP-1) UC1.AT11
GPP_F1: TC30.1(TP-1) UC1.AT13
GPP_F2: TC32.1(TP-1) UC1.AP11
GPP_F3: TC33.1(TP-1) UC1.AT5
GPP_F23: TC163.1(TP-1) UC1.AJ8
GTBST1: PR900.1 PU901.1
GTDRVH1: PQ900.1 PU901.8
GTDRVL1: PR901.1 PU901.5
GTDRVL1_1: PQ900.8 PR901.2
GTSW1: PC901.2 PL902.1 PQ900.9 PR902.1 PR903.1 PU901.7
GYRO_DRDY: R112.1 U20.13
GYRO_I2C_ADD_SEL: R103.2 R109.1 U20.5
GYRO_INT: DH6.1 U20.10
H_CATERR: TC5.1(TP-1) UC1.H49
H_CPUPWRGD_R: RH54.2 UC1.A62
H_PECI: R172.2 UC1.F49
H_PROCHOT#: PR416.1 PR715.2 PR800.2 PR837.2 R1217.2 RC8.1 RC13.2
H_PROCHOT#_R: RC8.2 UC1.J48
H_THERMTRIP#: R90.2 UC1.H47
H_VCCST_PWRGD: RC79.2 T23.1(TP-1) UC1.B61
H_VCCST_PWRGD_R: PU500.K6 RC79.1 RH66.2
HDA_BIT_CLK: RH109.2 UC1.BK18
HDA_BIT_CLK_L: CH40.1 RH109.1 UA1.13
HDA_RST#: RH110.2 UC1.BL19
HDA_RST#_L: CH39.1 RA77.1 RH110.1
HDA_RST#_L_R: RA77.2 UA1.15
HDA_SDI0: RA14.1 UC1.BL15
HDA_SDIN0_AUDIO: RA14.2 UA1.16
HDA_SDOUT: RH26.2 RH112.2 UC1.BK16
HDA_SDOUT_L: CH49.1 RH112.1 UA1.17
HDA_SYNC: RH111.2 UC1.BJ19
HDA_SYNC_L: CH50.1 RH111.1 UA1.14
HG4: PQ500.1 PU500.J1
HG5: PQ501.1 PU500.A8
HG6: PQ502.1 PU500.J14
HG10: PQ600.1 PU500.F1
HG11: PQ601.1 PU500.P7
HOME_KEY#: D423.2 JLVDS1.3 R1059.1 U27.H12
HOST_DEBUG_TX: JDEG1.8 R195.2 U27.C9
HOST_SD_WP#: QR1.2 RH134.1 UC1.AA12
HP2_D_L: RA1.1 RA30.2 UA1.32
HP2_D_L_C: CA11.1 DA8.1 JHP1.8 L1.2 RA4.1
HP2_D_L_R: L1.1 RA1.2 RA32.2
HP2_D_R: RA2.1 RA31.2 UA1.33
HP2_D_R_C: CA10.1 DA1.1 JHP1.7 L2.2 RA3.1
HP2_D_R_R: L2.1 RA2.2 RA33.2
HP_PLUG#: JHP1.10 RA24.1
HW_ACAV_IN: PR411.1 PR737.1 U27.C1
I2C0_SCL_AMP: RA66.1 UA1.12
I2C0_SCL_AMP_R: Q349.1 RA66.2 RA71.1 RA79.1 UA2.4
I2C0_SCL_AUD: RA79.2 RH75.1 UC1.AB3
I2C0_SDA_AMP: RA65.1 UA1.11
I2C0_SDA_AMP_R: Q349.4 RA65.2 RA70.1 RA78.1 UA2.3
I2C0_SDA_AUD: RA78.2 RH74.1 UC1.AD11
I2S_DATA_OUT: RA60.1 UA2.10
I2S_DATA_OUT_R: RA60.2 UA1.5
I2S_LRCK: CA46.1 RA56.1 UA2.7
I2S_LRCK_R: RA56.2 UA1.1
I2S_OUT: CA47.1 RA57.1 UA2.8
I2S_OUT_R: RA57.2 UA1.3
I_ADP: C205.1 PR412.1 U27.M2
I_BATT: C203.1 PR415.1 U27.M4
ILEDA: R5712.1 U16.B2
ILEDB: R66.1 U16.B3
ILIM4: PC518.1 PR506.1 PU500.J2
ILIM5: PC539.1 PR515.1 PU500.B8
ILIM6: PC549.1 PR520.1 PU500.L13
INV_PWM_R: D3.1 JLVDS1.18 MC2.1 R32.1
IRQ_SERIRQ: RH15.1 U27.L5 UC1.BN8
ISH_I2C0_SCL: JSER.1 RH130.1 U20.2 UC1.P5
ISH_I2C0_SDA: JSER.2 RH131.1 U20.4 UC1.P7
ISH_I2C1_SCL: RH93.1 UC1.T3
ISH_I2C1_SDA: RH92.1 UC1.T9
JACK_PLUG#: CA32.1 RA23.2 RA24.2 UA1.9
JTAG_CLK: JDEG1.4 R1067.2 U27.D9
JTAG_RST#: C197.1 R178.2 R181.1 U27.B10
JTAG_TDI: JDEG1.2 R1065.2 U27.D10
JTAG_TDO: JDEG1.5 R1068.2 U27.C10
JTAG_TMS: JDEG1.3 R1066.2 U27.A10
JUSBC1_GND: CT3.1 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 LT1.1
JUSBC2_GND: CT4.1 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 LT2.1
KEYSSA_DP_PWR_EN: R5728.2 U27.L8 U721.3
KEYSSA_LDBE_CTRL: QT21.2 R5702.1
KEYSSA_LDBE_CTRL_R: R5702.2 U27.K11
KEYSSA_LDBE_EN: QT21.3 R143.2 R5704.2
KEYSSA_STABLE: QT20.3 R1041.2 U27.H10
