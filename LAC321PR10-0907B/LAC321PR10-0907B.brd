# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19758591: length 10.9
  TOP w0.254: PR240.2 v2(71.23,129.07) ; PU208.5 66.5,121.93 v2(66.27,122.16)
  IN2 w0.254: v2(66.27,122.16) 66.27,122.54 69.5,125.76 69.5,126.53 71.23,128.25 v2(71.23,129.07)
N19795095: length 12.2
  TOP w0.254: PR227.2 73.41,124.42 73.41,122.82 73.04,122.45 72.16,122.45 71.91,122.21 71.91,121.7 72.29,121.32 PU209.2 ; PR227.2 72.16,124.23 PU206.1 ; PR227.2 72.85,124.98 PC231.1 ; v2(71.39,127.49) 71.39,127.68 PR230.2
  IN2 w0.254: v2(72.89,125.01) 72.76,125.14 71.79,125.14 71.39,125.53 v2(71.39,127.49)
N19796536: length 12.8
  TOP w0.254: PC230.1 68.46,123.55 67.58,123.55 67.25,123.22 PR229.2 ; PC230.1 69.45,123.48 69.45,124.34 69.62,124.51 70.38,124.51 71.66,123.22 PR225.2 71.56,122.87 71.56,121.27 72.16,120.67 PU209.1 ; PC230.1 68.99,124.14 68.25,124.88 PU206.7
N19805641: length 2.7
  TOP w0.254: PU203.5 61.3,143.28 PR238.2 61.55,143.23 61.77,143.44 61.77,144.18 62.02,144.43 PC207.2
N19813199: length 1.6
  TOP w0.254: PQ111.6 44.66,123.71 44.46,123.5 44.46,123.33 44.72,123.06 PQ111.5
N19813289: length 2.1
  TOP w0.254: PQ111.2 42.92,123.06 42.3,122.44 PR118.2 PR129.1
N19818897: length 1.5
  TOP w0.508: PR413.1 59.64,109.86 PC432.1
N19824530: length 5.2
  TOP w0.254: PR245.2 73.46,119.95 72.21,119.95 70.59,121.56 PU209.4 70.59,122.81 PR226.1
N19868559: length 1.3
  TOP w0.254: PR1026.1 72.78,104.61 PR1017.2
N19902287: length 7.3
  IN2 w0.06: v2(166.79,124.4) 166.62,124.4 166.43,124.6 165.72,124.6
  IN2 w0.084: 165.72,124.6 164.8,124.6 164.75,124.54 164.19,124.54 163.79,124.95 162.13,124.95 161.36,125.73 v2(161.36,127.03)
N19912057: length 5.6
  TOP w0.119: v1(172.83,124.58) PR740.2
  IN1 w0.06: v1(168.39,123.6) 168.59,123.8 169.69,123.8 170.03,124.14 170.44,124.14 170.77,124.47 171.06,124.47 171.28,124.68 171.81,124.68
  IN1 w0.089: v1(172.83,124.58) 172.73,124.68 171.81,124.68
N19918206: length 10.3
  TOP w0.119: PR739.2 175.15,124.75 PC712.2 175.46,125.12 v2(175.42,125.16)
  IN2 w0.06: 170.03,125.51 169.81,125.28 169.81,124.79 169.51,124.49 169.51,124.39 168.82,123.71 168.51,123.71 168.22,124 v2(167.99,124)
  IN2 w0.084: v2(175.42,125.16) 175.27,125.16 175.08,125.35 171.54,125.35 171.15,125.74 170.26,125.74 170.03,125.51
N20063017: length 1.2
  TOP w0.119: R1217.1 227.64,116.61 Q25.1
N20124874: length 3.3
  TOP w0.381: U713.1 v7(87.07,128.26) 86.66,128.67 R118.1
  BOTTOM w0.119: v13(86.53,128.56) 86.83,128.26 v7(87.07,128.26)
N20566621: length 1.8
  TOP w0.119: QT20.5 130.21,80.77 R1074.2 130.08,81.12 QT20.6
N20604762: length 5.4
  TOP w0.119: UH2.1 99.5,98.75 99.31,98.56 v7(99.31,97.54) 99.83,97.02 100.67,97.02 101.12,96.57 R1038.2
  BOTTOM w0.119: v7(99.31,97.54) v13(99.31,98.12)
N20604774: length 4.7
  TOP w0.119: R1039.2 101.96,96.66 101.39,97.23 101.39,97.84 101.12,98.1 v10(100.51,98.1)
  GND1 w0.119: v4(100.76,98.61) 100.74,98.6 100.74,98.34 v10(100.51,98.1)
  IN3 w0.084: v4(100.76,98.61) 101.15,98.22 v6(101.29,98.22)
  GND4 w0.119: v15(100.5,99.14) 100.76,98.89 v4(100.76,98.61)
N20978000: length 1.4
  TOP w0.119: R398.1 R1048.2 231.39,106.09 QT18.1
N21033082: length 6.1
  TOP w0.102: 122.79,81.69 122.03,81.69 121.7,82.02 JPOGO.72
  TOP w0.119: 122.79,81.69 125.54,81.69 125.88,82.04 R143.1
N21063245: length 4.5
  TOP w0.119: U15.27 200.13,136.17 200.35,136.38 202.23,136.38 202.66,136.81 R60.1
N21063249: length 1.7
  TOP w0.254: U15.1 196.07,134.87 195.84,135.1 R5717.1
N21063326: length 13.7
  TOP w0.254: U15.14 200.16,130.54 v7(200.16,128.74) ; U15.22 203.09,133.87 203.43,134.21 203.82,134.21 R5718.1 203.3,134.59 v7(203.24,134.65)
  BOTTOM w0.508: v7(203.24,134.65) 203.24,134.77 202.98,135.03 202.37,135.03 201.94,134.6 201.94,131.1 200.16,129.32 v7(200.16,128.74)
N21077234: length 1.5
  TOP w0.203: U37.12 196.78,124.75 C225.1
N21078167: length 1.5
  TOP w0.203: C273.1 196.45,124.33 195.98,124.8 U37.10
N21436900: length 10
  TOP w0.119: v10(196.33,105.14) 196.26,105.22 196.26,105.58 R59.1
  GND1 w0.119: v10(196.33,105.14) 196.14,104.95 v4(195.95,104.95)
  IN3 w0.084: v4(195.95,104.95) 195.95,102.51 198.28,100.19 v6(198.43,100.19)
  BOTTOM w0.119: v6(198.43,100.19) 201.05,100.19 JNGFF2.68
N21793938: length 6.8
  TOP w0.119: PR718.1 163.51,126.68 v1(163.51,126.45)
  IN1 w0.06: v1(168.39,124.4) 168.13,124.65 167.77,124.65 167.72,124.6 166.6,124.6 166.28,124.92 165.99,124.92 165.99,124.92 165.89,124.92 165.38,125.43 165.38,125.58 165.14,125.82 165.14,126.04 165.1,126.08 165.1,126.17 164.83,126.45 164.06,126.45
  IN1 w0.089: v1(163.51,126.45) 164.06,126.45
N22206076: length 7.8
  TOP w0.254: v1(52.11,147.76) PR224.1 54.8,145.96 PQ209.2
  IN1 w0.254: v1(52.11,147.76) 55,147.76 v1(55.92,148.69)
N22206124: length 11.1
  TOP w0.254: PQ206.2 57.17,145.38 56.8,145.74 56.26,145.74 ; PQ211.2 54.69,141.13 55.01,141.45 55.01,142.72 55.85,143.56 55.85,145.34 56.26,145.74 ; PR202.2 54.81,147.76 PR231.2 54.81,147.43 55.7,146.55 55.7,146.3 56.26,145.74
N22206126: length 5.5
  TOP w0.254: PQ206.3 57.82,145.59 57.23,146.17 56.33,146.17 56.05,146.45 56.05,146.69 55.38,147.37 55.38,148.11 PR231.1
N22206285: length 3.6
  TOP w0.254: PU200.4 51.02,136.42 51.3,136.14 PR200.1 50.77,135.28 49.82,135.28 49.54,135.56 PR204.1
N22206891: length 1.1
  TOP w0.254: PQ206.5 57.17,147.42 PR232.2
N22207134: length 1.2
  TOP w0.254: PR223.2 56.52,147.18 PQ206.6
N22211458: length 15.3
  TOP w0.254: PR107.2 41.89,119.62 42.39,119.12 v1(43.75,119.12) ; PQ110.3 45.81,128.34 46.6,129.13 v1(46.72,129.13)
  IN1 w0.254: v1(43.75,119.12) 43.75,121.52 43.91,121.69 43.91,125.57 46.72,128.38 v1(46.72,129.13)
N22219567: length 19.2
  TOP w0.254: PR119.2 50.36,108.69 50.01,108.34 50.01,107.87 49.84,107.7 PQ107.4 ; PR119.2 50.68,108.71 v2(50.68,109.52) ; PR119.2 PC123.2
  IN2 w0.254: v2(50.68,109.52) 50.68,112.57 48.72,114.52 44.71,114.52 43.32,115.91 v2(43.32,119.58)
N22223021: length 1.7
  TOP w0.254: PQ112.6 44.65,120.88 44.47,120.7 44.47,120.34 44.58,120.23 PQ112.5
N22231891: length 13.3
  IN1 w0.089: v1(31.71,44.47) 31.71,45.51 32.21,46.01 32.21,50.03 31.76,50.48 31.59,50.48 31.3,50.77 29.15,50.77 28.16,51.76 26.8,51.76 26.02,50.98 v1(25.75,50.98)
N22231917: length 15.1
  IN1 w0.089: v1(23.25,51.48) 22.98,51.48 22.76,51.27 21.34,51.27 20.71,51.9 20.71,52.05 20.54,52.22 18.97,52.22 18.5,51.76 18.5,47.44 17.96,46.91 17.96,46.22 18.23,45.96 18.55,45.96 18.97,46.38 v1(21.52,46.38)
N22235149: length 4.1
  TOP w0.119: v1(14.94,52.26) 15.91,52.26 C1343.1
  IN1 w0.089: v1(14.94,52.26) 14.79,52.26 14.52,51.99 13.75,51.99 12.99,51.23 v1(12.42,51.23)
N22235165: length 2.7
  TOP w0.081: v7(13.38,52.28) 13.43,52.23 U717.F10
  BOTTOM w0.119: v7(13.38,52.28) 13.44,52.34 R5684.1 12.86,53.08 R5759.1 12.82,53.73 R5685.1
N22235177: length 2.8
  IN1 w0.089: v1(9.92,51.73) 9.68,51.97 9.68,52.05 8.77,52.96 8.25,52.96 7.88,52.59 v1(7.83,52.59)
N22260243: length 7.9
  TOP w0.254: v1(66.66,138.79) 66.58,138.87 PQ204.2 ; v7(64.34,134.2) 64.52,134.2 64.73,133.99 PU204.4
  IN1 w0.254: v1(66.66,138.79) 66.66,138.29 v8(65.69,137.32)
  GND1 w0.254: v8(65.69,137.32) 65.65,137.32 v4(65.39,137.05)
  GND4 w0.254: v9(64.95,137.07) 64.97,137.05 v4(65.39,137.05)
  BOTTOM w0.254: v9(64.95,137.07) 64.95,134.81 v7(64.34,134.2)
N22283370: length 1.9
  TOP w0.254: RA33.1 34.91,10.5 D8.3
N22283372: length 1.8
  TOP w0.254: RA32.1 34.65,12.43 D8.2
N22292307: length 14.1
  TOP w0.254: PC220.1 50.01,148.61 PD202.1 50.01,146.43 PD201.1 52.11,146.43 v1(52.12,146.44)
  IN1 w0.254: v1(60.13,147.22) 59.59,147.22 59.19,146.82 58.77,146.82 58.29,147.3 57.16,147.3 55.05,145.19 53.37,145.19 v1(52.12,146.44)
N22316260: length 0.9
  TOP w0.254: PR821.2 77.01,116.59 PR822.1
N22316276: length 0.9
  TOP w0.254: PC810.1 78.01,113.89 PR824.2
N22383371: length 7.6
  TOP w0.119: R1434.1 18.62,52.01 18.34,52.29 17.73,52.29 17.53,52.48 v1(17.53,52.98)
  IN1 w0.089: v1(12.42,53.23) 12.43,53.25 13.52,53.25 13.75,53.47 14.05,53.47 14.29,53.23 15.17,53.23 15.66,52.74 17.3,52.74 v1(17.53,52.98)
N22383378: length 5.9
  TOP w0.119: R1435.1 11.23,46.6 11.23,48.81 11.79,49.37 v1(12.08,49.37)
  IN1 w0.089: v1(12.08,49.37) 12.17,49.46 12.17,50.98 v1(11.92,51.23)
N22383733: length 2.3
  IN1 w0.089: v1(27.25,53.48) 28.99,53.48 v1(29.41,53.9)
N22383735: length 4.2
  IN1 w0.089: v1(29.41,52.12) 28.31,53.22 27.11,53.22 27.07,53.26 26.47,53.26 26.19,52.98 v1(25.75,52.98)
N22383737: length 3.3
  IN1 w0.089: v1(25.25,50.98) 25.63,50.6 25.63,48.52 v1(25.13,48.01)
N22391071: length 1.7
  TOP w0.254: PR233.2 PR235.2 51.65,143.92 51.65,144.31 PD201.2
N22391100: length 1.5
  TOP w0.254: PR236.2 PR234.2 49.74,144.47 PD202.2
N22401321: length 4.3
  TOP w0.254: PQ110.5 46.46,126.67 47.71,127.91 47.71,129.42 PR143.1
N22407862: length 2.9
  TOP w0.254: PQ109.5 43.41,129.83 43.24,130.01 43.24,131.25 43.53,131.54 PR147.1
N22417276: length 4.8
  TOP w0.254: PU100.2 44.64,139.95 PR134.1 44.05,140.55 PC116.1 45.49,141.07 46.25,141.07 PR133.2
N22417312: length 8
  TOP w0.254: 43.67,138.06 42.87,138.06 PR136.2 42.18,138.77 PC117.2 PR117.2 ; 43.67,138.06 44.41,137.32 PR128.1 ; 43.67,138.06 43.99,138.38 PU100.3
N22422788: length 3.2
  TOP w0.254: PR138.2 PC126.1 PR137.1 43.99,133.43 PU100.6
N22435782: length 27.3
  TOP w0.254: v2(43.26,128.99) 43.41,128.99 43.96,128.44 PR112.1 44.13,128.47 44.13,129.04 PQ109.6 ; PR116.2 v2(50.08,110.43)
  IN2 w0.254: v2(50.08,110.43) 50.08,110.48 49.32,111.24 49.32,112.35 48.21,113.46 44.21,113.46 42.21,115.46 42.21,120.17 42.79,120.75 42.79,127.61 43.26,128.07 v2(43.26,128.99)
N22435889: length 27.6
  TOP w0.254: PR108.2 v2(50.2,111.58) ; PQ109.3 46.21,130.48 46.31,130.38 v1(46.31,130.13)
  IN1 w0.254: v3(43.54,126.09) 43.93,126.09 46.31,128.48 v1(46.31,130.13)
  IN2 w0.254: v2(50.2,111.58) 50.2,112.53 48.56,114.17 44.54,114.17 42.93,115.78 42.93,119.88 43.54,120.49 v3(43.54,126.09)
N22440956: length 4.7
  TOP w0.254: PR135.2 v1(42.91,128.18) ; PQ109.2 45.12,129.83 v1(44.74,129.45)
  IN1 w0.254: v1(44.74,129.45) 44.74,129.19 43.52,127.97 43.19,127.97 42.98,128.18 v1(42.91,128.18)
N22441712: length 3.1
  TOP w0.254: PR127.1 PR106.2 47.28,124.02 PQ103.2
N22492141: length 4.2
  TOP w0.203: PQ110.2 46.46,128.46 46.74,128.74 47,128.74 47.22,128.96 47.22,129.29
  TOP w0.254: PR144.2 46.87,131.61 47.22,131.25 47.22,129.29
N22492313: length 1.2
  TOP w0.254: PQ110.6 47.11,126.06 46.78,125.73 46.78,125.73 PR127.2
N22493133: length 6.9
  IN1 w0.089: v1(9.09,46.12) 9.21,46.12 10.6,47.51 10.6,47.94 11.26,48.6 11.26,49.51 11.16,49.61 11.16,50.4 11.39,50.63 11.39,50.86 11.16,51.09 11.16,51.49 v1(10.92,51.73)
N22493136: length 7.3
  IN1 w0.089: v1(10.92,52.23) 10.6,51.91 10.6,51.34 10.5,51.24 10.5,50.99 10.55,50.94 10.55,49.33 10.67,49.21 10.67,48.98 10.36,48.66 10.1,48.66 8.67,47.23 v1(8.67,46.12)
N22493152: length 6.6
  TOP w0.119: v1(19.72,50.53) 19.49,50.3 TC29.1
  IN1 w0.089: v1(24.25,51.48) 24.25,51.44 24.03,51.22 23.1,51.22 22.89,51.01 21.33,51.01 20.82,51.52 19.89,51.52 19.72,51.34 v1(19.72,50.53)
N22493166: length 6.2
  TOP w0.119: v1(23.55,55.51) 23.36,55.7 23.36,57.31 23.13,57.54 TC25.1
  IN1 w0.089: v1(24.25,51.98) 23.5,52.73 23.5,55.46 v1(23.55,55.51)
N22493234: length 5.1
  IN1 w0.089: v1(31.67,51.37) 31.41,51.63 29.48,51.63 28.13,52.98 v1(27.25,52.98)
N22493298: length 4.4
  IN1 w0.089: v1(27.25,51.48) 27.62,51.11 28.24,51.11 29.13,50.23 v1(31.1,50.23)
N22493300: length 5.1
  IN1 w0.089: v1(27.25,52.48) 28.35,52.48 29.49,51.34 31.19,51.34 v1(31.67,50.85)
N22493318: length 4.3
  IN1 w0.089: v1(27.75,51.48) 28.17,51.48 29.07,50.58 31.22,50.58 v1(31.57,50.22)
N22493409: length 8.1
  TOP w0.119: v1(17.99,52.95) 18.37,52.95 18.6,52.71 19.21,52.71 19.79,52.12 19.79,51.09 19.56,50.86 TC39.1
  IN1 w0.089: v1(17.99,52.95) 17.88,52.95 17.49,52.55 15.58,52.55 15.09,53.04 14.11,53.04 v1(13.92,53.23)
N22493425: length 6.8
  TOP w0.119: TC41.1 19.48,52.13 19.11,52.49 18.5,52.49 18.4,52.59 v1(18.01,52.59)
  IN1 w0.089: v1(13.92,52.73) 15.14,52.73 15.5,52.36 17.57,52.36 17.8,52.59 v1(18.01,52.59)
N22493427: length 4.6
  IN1 w0.089: v1(13.92,51.73) 14.22,51.43 14.52,51.43 14.88,51.79 17.63,51.79 v1(18.1,51.32)
N22493429: length 3.8
  IN1 w0.089: v1(14.42,51.73) 14.57,51.73 14.82,51.98 18.07,51.98 v1(18.1,51.96)
N22494332: length 2.3
  TOP w0.254: PQ104.5 43.93,127.3 43.54,126.91 42.53,126.91 PR103.2
N22511338: length 24.2
  TOP w0.119: PQ104.6 v2(43.29,127.53)
  TOP w0.254: v2(50.1,110.97) 51.39,110.97 51.57,110.79 PR145.2
  IN2 w0.254: v2(43.29,127.53) 43.15,127.39 43.15,120.61 42.58,120.03 42.58,115.63 44.39,113.81 48.41,113.81 49.68,112.55 49.68,111.39 v2(50.1,110.97)
N22511366: length 4.2
  TOP w0.254: PQ104.2 43.93,125.09 43.63,124.79 42.82,124.79 42.63,124.6 PC130.1 42.18,124.61 PR146.2 42.18,126.34 PR148.2
N22631833: length 7.2
  TOP w0.119: v2(243.11,121.55) 242.91,121.55 242.83,121.47 R40.1
  IN2 w0.084: JNGFF3.42 246.96,120.62 246.03,121.55 v2(243.11,121.55)
N22902923: length 4.2
  TOP w0.254: PQ214.2 75.97,123.79 75.79,123.97 75.54,123.97 75.32,123.76 PQ214.3 74.9,123.6 74.82,123.68 PR241.2 73.77,123.12 73.77,122.03 PR248.1
N22903845: length 2.4
  IN1 w0.089: v1(9.92,54.23) 9.68,54 9.29,54 9.23,53.93 8.21,53.93 v1(7.83,54.31)
N22903866: length 6
  IN1 w0.089: v1(9.92,53.73) 10.17,53.98 10.17,54.68 9.28,55.56 9.28,55.89 8.27,56.9 8.27,58.21 v1(7.83,58.66)
N23173944: length 1.7
  TOP w0.119: R1463.2 5.86,57.55 5.86,56.57 6.08,56.36 QT19.2
N23173956: length 2.2
  TOP w0.119: v1(7.56,56.27) 7.47,56.36 QT19.5
  IN1 w0.089: v1(7.83,57.78) 7.93,57.68 7.93,56.65 v1(7.56,56.27)
N23173999: length 2.8
  TOP w0.119: QT19.3 6.4,56.01 6.66,56.27 6.66,56.49 6.88,56.71 QT19.6 7.95,56.71 R1440.1
N23260134: length 6.8
  TOP w0.254: PU101.4 42.48,131.21 42.12,130.85 v10(42.12,130.51)
  GND1 w0.254: v4(41.74,125.51) 41.7,125.47 v10(41.27,125.47) ; v10(42.12,130.51) v4(42.12,130.08)
  IN3 w0.254: v4(42.12,130.08) 42.09,130.08 41.87,129.85 41.87,125.64 v4(41.74,125.51)
N23265666: length 14.6
  TOP w0.254: PR205.2 66.16,141.85 v2(66.27,141.97)
  IN1 w0.254: v1(75.9,138.5) 73.76,138.5 72.93,139.33 72.62,139.33 v2(72.4,139.56)
  IN2 w0.254: v2(66.27,141.97) 65.46,141.16 65.46,139.79 65.82,139.43 72.17,139.43 72.29,139.56 v2(72.4,139.56)
N23266057: length 1.1
  TOP w0.381: PR201.1 65.93,140.63 PQ204.3
N23267237: length 29.3
  TOP w0.119: v1(66.2,137.07) PC224.2 ; PR206.2 PR249.1 75.32,120.68 74.94,121.06 v10(74.94,122.21)
  IN1 w0.089: v1(66.2,137.07) 66.5,137.07 68.03,138.59 70.81,138.59 v2(70.9,138.5)
  GND1 w0.119: v4(74.68,122.69) 74.68,122.49 74.94,122.23 v10(74.94,122.21)
  IN2 w0.084: v4(73.36,127.57) 73.36,128.2 73.04,128.52 73.04,130.63 74.53,132.12 74.53,136.06 72.09,138.5 v2(70.9,138.5)
  GND4 w0.119: v9(74.33,122.97) 74.35,122.97 74.63,122.69 v4(74.68,122.69) ; v4(73.36,127.57) 73.43,127.63 v9(73.78,127.63)
  BOTTOM w0.119: v9(74.33,122.97) 74.33,127.08 v9(73.78,127.63)
N23269982: length 17.7
  TOP w0.254: PR207.1 61.58,139.48 v1(61.58,138.79) 62.13,138.23 62.13,137.49 61.66,137.02 PC225.2
  IN1 w0.254: v1(73.92,136.67) 71.75,136.67 70.27,138.16 68.12,138.16 66.57,136.61 65.47,136.61 63.94,138.15 62.22,138.15 v1(61.58,138.79)
N23270361: length 2.5
  TOP w0.254: PR208.2 59.79,138.92 59.52,139.19 58.79,139.19 58.26,139.72 PQ205.6
N23270518: length 14
  TOP w0.254: PR208.1 60.64,138.53 60.64,138.03 v1(60.62,138.02) 60.62,137.16 PR216.2 ; PC226.2 66.38,133.31 v1(65.81,133.88)
  IN1 w0.254: v1(68.41,136.67) 68.25,136.67 66.25,134.67 66.25,134.11 66.02,133.88 v1(65.81,133.88) 65.26,134.42 65.26,135.33 63.49,137.09 61.55,137.09 v1(60.62,138.02)
N23286560: length 5.4
  IN1 w0.06: 164.06,123.42 164.16,123.42 164.32,123.58 165.28,123.58 165.46,123.4 166.99,123.4 v1(167.19,123.2)
  IN1 w0.089: 164.06,123.42 163.43,123.42 162.49,124.37 v1(162.36,124.37)
N23294129: length 1.1
  TOP w0.119: PQ214.6 76.62,120.92 PR249.2
N23314109: length 3.4
  TOP w0.119: PQ214.5 75.97,121.95 76.41,122.39 77.68,122.39 PC209.1 77.7,123.53 PR228.1
N23341117: length 1.7
  TOP w0.119: Q340.1 227.03,138.2 R5669.2
N23346401: length 2.4
  TOP w0.119: U34.5 192.02,100.46 R136.2 R135.2
N23354249: length 2.1
  TOP w0.119: Q341.5 246.4,137.08 246.68,136.8 R18.2 246.75,136.81 Q341.6
N23354257: length 1.1
  TOP w0.119: R1104.1 246.05,139.56 Q341.3
N23354742: length 1.2
  TOP w0.119: R1107.1 217.16,139.23 216.74,138.81 Q342.3
N23355623: length 2.7
  TOP w0.203: Q342.5 214.84,138.46 214.71,138.34 214.43,138.34 R21.2 214.15,137.96 215.17,137.96 215.33,138.11 Q342.6
N23551801: length 1.4
  TOP w0.254: PR251.1 59.2,143.03 PU203.4
N23646933: length 2.3
  TOP w0.254: PR252.1 PR253.1 91.07,93.57 91.32,93.32 PU202.4
N23704108: length 24.2
  TOP w0.254: PR158.1 43.88,92.86 45.98,94.95 PQ105.3 45.66,95.74 v7(45.66,97.62) ; PD102.1 45.95,110.98 46.64,110.29 46.64,107.88 45.77,107.02 v10(44.94,107.02)
  GND1 w0.254: v10(44.94,107.02) 44.95,107.03 v4(44.95,107.42)
  GND4 w0.254: v4(44.95,107.42) 44.39,107.42 v9(44.33,107.35)
  BOTTOM w0.254: v7(45.66,97.62) 45.47,97.62 44.84,98.26 44.84,102.53 44.11,103.25 44.11,107.14 v9(44.33,107.35)
N23704163: length 4.4
  TOP w0.254: PR157.1 43.07,91.96 PR158.2 44.23,91.94 45.78,93.49 PQ105.2
N23705603: length 1.1
  TOP w0.254: PQ120.6 41.72,93.35 42.2,92.87
N23707230: length 1.1
  TOP w0.254: PQ120.2 PR159.1
N23733930: length 2.3
  TOP w0.119: R5683.2 21.19,52.03 21.19,52.36 21.44,52.61 21.95,52.61 22.59,51.98 U719.F1
N23735438: length 5.8
  TOP w0.119: v7(26.78,52.61) 26.78,52.23 27.03,51.98 U719.F10
  BOTTOM w0.119: R5760.1 26.05,52.61 v7(26.78,52.61) 26.78,53.26 26.4,53.64 26.4,54.3 R5686.1 25.85,54.84 25.07,54.84 R5687.1
N23738255: length 3.8
  TOP w0.254: PD205.2 95.57,94.46 PR257.1 93.85,94.46 93.2,93.8 PU202.5
N23741494: length 44.3
  TOP w0.254: v10(38.65,97.91) 40.42,96.15 PQ120.3 ; PR113.1 46.63,130.97 44.97,130.97 44.48,130.48 PQ109.4 43.99,130.5 v2(43.59,130.89)
  GND1 w0.254: v10(38.65,97.91) v4(38.65,98.4)
  IN2 w0.254: v2(43.59,130.89) 43.59,129.93 42.63,128.96 v4(42.63,128.74)
  IN3 w0.254: v4(42.63,128.74) 42.22,128.33 42.22,125.3 v6(41.21,124.29)
  GND4 w0.254: v9(38.23,98.84) 38.23,98.81 v4(38.65,98.4)
  BOTTOM w0.254: v6(41.21,124.29) 41.21,111.94 39.64,110.37 37.49,110.37 37.19,110.08 37.19,107.83 37.4,107.62 37.4,101.62 38.64,100.39 38.64,99.25 v9(38.23,98.84)
N23741962: length 1.9
  TOP w0.254: PR160.1 PR162.1 41.31,93.14 41.07,93.38 PQ120.5
N23762904: length 2.7
  TOP w0.254: PQ300.1 171,108.54 PR302.2 170.3,106.9 PU300.3
N23762935: length 3.7
  TOP w0.254: PU300.1 168.99,105.9 168.48,106.41 168.48,107.2 169.44,108.15 PR307.2
N23762943: length 14.8
  TOP w0.254: 166.74,102.31 PD302.1 ; 166.74,102.31 166.72,102.28 165.79,102.28 165.35,101.84 PD301.1 ; 166.74,102.31 166.74,102.75 165.97,103.53 165.97,104.53 166.17,104.73 166.17,105.65 166.43,105.9 PU300.8 167.55,105.9 167.98,105.47 169.09,105.47 PR304.1 170.24,104.94 170.57,105.27 170.57,105.72 171.05,106.21 171.46,106.21 171.91,106.66 PR303.1 PR302.1
N23762945: length 5
  TOP w0.254: PR304.2 v1(167.85,104.94) ; v1(165.82,106.61) 166.03,106.4 PU300.7
  IN1 w0.254: v1(167.85,104.94) 167.85,105.38 167.54,105.68 166.74,105.68 v1(165.82,106.61)
N23762996: length 1.4
  TOP w0.254: PU300.2 170.69,106.4 PR303.2
N23763035: length 4.2
  TOP w0.254: PQ300.2 171.51,110.32 170.69,109.51 169.35,109.51 PR300.2 168.74,108.9 PR301.1
N23764093: length 1.9
  TOP w0.254: PU300.5 166.91,107.85 166.94,107.88 166.94,108.56 166.63,108.86 PR305.1
N23795786: length 1.8
  TOP w0.119: QT21.5 127.64,82.26 R5703.2 127.99,82.41 QT21.6
N23810550: length 17.8
  TOP w0.119: v2(160.97,129.64) 160.93,129.67 159.14,129.67 158.96,129.85 PC716.1 PR742.2
  GND1 w0.084: v10(169.19,122.4) 169.19,122.18 v4(169.02,122)
  IN2 w0.084: v2(160.97,129.64) 160.99,129.66 165.3,129.66 v4(165.32,129.68)
  IN3 w0.079: v4(165.32,129.68) 165.32,129.03 165.59,128.76 165.59,125.97 166.33,125.23 166.68,125.23 169.02,122.89 v4(169.02,122)
N23831252: length 8.8
  TOP w0.203: PU400.6 54.17,131.39 53.83,131.73 52.61,131.73 PC422.1 51.86,132.48 v1(51.86,133.31) PR404.2
  IN1 w0.254: v1(53.64,135.77) 53.14,135.77 52.34,134.97 52.34,134.06 51.86,133.58 v1(51.86,133.31)
N23832036: length 2.7
  TOP w0.254: PQ402.5 52.99,138.33 52.66,138.67 52.2,138.67 PR428.2 52.34,138.4 PQ402.6
N23832206: length 4
  TOP w0.254: PQ402.2 52.99,136.4 53.29,136.69 54.08,136.69 PD402.1 PD403.1
N23913209: length 19.6
  TOP w0.119: v1(37.42,92.13) 37.49,92.07 37.49,90.11 PQ115.5 ; v1(32.41,86.9) 31.37,87.94 29.57,87.94 27.32,90.19 PR150.2
  IN1 w0.089: v1(37.42,92.13) 37.2,92.13 35.38,90.31 34.75,90.31 34.49,90.05 34.49,89.78 34.2,89.49 33.62,89.49 32.92,88.79 32.92,88.1 32.41,87.6 v1(32.41,86.9)
N23913329: length 10.3
  TOP w0.254: PQ113.2 41.55,90.05 43.12,88.48 44.34,88.48 45.27,87.55 45.27,86.72 PR149.1 PC131.1 43.06,85.42 42.35,85.42 PR151.1
N23913347: length 26.3
  TOP w0.254: v1(36.26,94.86) 36.84,94.86 37.65,94.05 38.45,94.05 38.87,93.63 38.87,92.35 38.47,91.96 PR153.2 38.47,91.18 38.84,90.81 PQ115.2 ; PR152.2 24.47,86.67 24,87.14 PQ114.2 24,89.7 v1(24.01,89.71)
  IN1 w0.254: v1(36.26,94.86) 31.96,94.86 31.87,94.95 30.65,94.95 29.84,94.15 29.84,92.37 28.89,91.42 27.69,91.42 25.98,89.71 v1(24.01,89.71)
N23913349: length 17.7
  TOP w0.119: PR152.1 31.71,86.67 v1(32.26,86.12) ; v1(37.47,92.57) 37.71,92.33 37.71,91.14 PQ115.3
  IN1 w0.089: v1(37.47,92.57) 37.37,92.57 35.3,90.5 34.56,90.5 34.21,90.15 34.21,89.77 34.12,89.68 33.54,89.68 32.67,88.81 32.67,88.12 32.16,87.61 32.16,86.23 v1(32.26,86.12)
N23913377: length 3.1
  TOP w0.254: PR151.2 41.79,86.99 40.02,88.76 PQ115.6
N23913442: length 3.5
  TOP w0.254: PU102.4 32.47,70.74 33.29,71.56 PR155.1 34.18,70.69 PC135.1
N24067725: length 7.3
  IN1 w0.089: v1(24.77,56.02) 24.31,56.02 24.01,56.32 21.93,56.32 21.62,56.02 21.62,55.56 21.98,55.2 21.98,54.77 21.72,54.52 21.72,54.24 22.08,53.88 22.89,53.88 23.25,53.52 v1(23.25,53.48)
N24067748: length 5.3
  TOP w0.119: v1(22.05,55.89) 22.15,55.99 22.15,57.43 22.79,58.07 TC35.1
  IN1 w0.089: v1(23.25,53.98) 23.25,54.39 22.89,54.76 22.7,54.76 22.05,55.41 v1(22.05,55.89)
N24108706: length 3.9
  TOP w0.119: U717.F1 9.42,52.24 8.57,53.09 6.56,53.09 R5682.2
N24437701: length 1.3
  TOP w0.119: U721.6 91.65,98.48 C1389.1
N24597122: length 7
  TOP w0.119: R5739.2 201.87,140.67 201.87,142.48 201.62,142.73 198.77,142.73 198.58,142.92 Q344.2
N24921198: length 74.6
  TOP w0.119: v2(228.38,141.89) 228.85,142.36 R716.1 228.56,142.83 R5758.2 ; D406.1 175.41,116.22 v1(175.62,116.44)
  IN1 w0.089: v1(175.62,116.44) 175.62,117.06 175.43,117.25 175.43,117.57 175.99,118.13 176.23,118.13 177.42,119.32 177.8,119.7 183.29,119.7 183.46,119.88 184.52,119.88 185.92,121.27 185.92,123.01 188.18,125.28 188.84,125.28 192.51,128.95 193.78,128.95 194.02,129.19 198.24,129.19 198.93,129.88 200.63,129.88 200.81,129.69 202.81,129.69 202.93,129.82 203.97,129.82 205.71,131.56 206.27,131.56 208.75,134.04 208.75,136.09 210.85,138.19 212.69,138.19 213.17,137.71 221.5,137.71 221.83,138.04 222.85,138.04 223.12,137.77 229.23,137.77 v3(229.38,137.61)
  IN2 w0.084: v3(229.38,137.61) 229.38,139.09 229.52,139.23 229.52,139.84 228.91,140.45 228.91,141.36 v2(228.38,141.89)
N25304790: length 3.1
  TOP w0.508: PR254.1 65.67,117.64 66.14,118.11 PD204.1 67.2,118.91 PR259.2
N25431332: length 16.9
  TOP w0.254: RC140.1 128.49,95.69 127.13,95.69 v10(126.98,95.84)
  TOP w0.381: v1(128.49,103.24) v10(128.49,103.8)
  IN1 w0.381: v10(128.49,103.8) v1(128.49,103.24)
  GND1 w0.203: v4(128.49,103.25) v10(128.49,103.8)
  GND1 w0.254: v10(126.98,95.84) 126.77,95.63 v4(126.41,95.63)
  GND2 w0.076: 126.71,101.41 126.53,101.59 126.53,101.79 126.26,102.06 126.26,102.31 126.46,102.5 126.79,102.5 126.97,102.32 127.36,102.32
  GND2 w0.203: 127.36,102.32 126.71,101.67 126.71,101.41
  GND2 w0.254: 126.71,101.41 126.71,101.19 127.26,100.64 127.74,100.64 128.2,100.19 128.2,98.79 126.88,97.47 126.88,96.1 v4(126.41,95.63) ; v4(128.49,103.25) 128.16,103.25 127.54,102.62 127.54,102.5 127.36,102.32
N26458468: length 8
  IN1 w0.06: v1(132.87,99.57) 132.87,99.32 132.92,99.27 132.95,99.27 133.07,99.16 133.07,98.99 132.99,98.91 132.99,98.75 133.11,98.63 133.18,98.63 133.55,98.26 133.55,97.89 134.8,96.64 134.97,96.64 135.81,95.79 136.12,95.79
  IN1 w0.089: v1(138.09,94.56) 137.67,94.56 136.44,95.79 136.12,95.79
N26494340: length 9.9
  TOP w0.119: v1(174.73,117.42) 174.66,117.34 173.9,117.34 PR719.1
  IN1 w0.06: v1(169.99,122.8) 170.19,122.6 170.84,122.6 170.95,122.7 171.67,122.7 171.81,122.56 171.81,121.48 171.83,121.46
  IN1 w0.089: v1(174.73,117.42) 174.73,118.21 173.16,119.78 173.16,119.91 172.21,120.86 172.21,121.08 171.83,121.46
N44370994: length 1.9
  TOP w0.089: U34.12 191.22,105.73 C236.1
N44535135: length 1.3
  TOP w0.119: U30.10 237.71,134.96 C214.1
N45346942: length 1.5
  TOP w0.119: C227.1 100.39,84.35 U33.10
N47519532: length 0.6
  BOTTOM w0.119: v7(170.94,99.5) v13(171.51,99.5)
N51581718: length 1.4
  TOP w0.119: U31.6 194.27,132.48 C217.1
N51600744: length 1.9
  TOP w0.119: U36.12 28,66.11 C244.1
N51600766: length 1.9
  TOP w0.119: U36.10 28.09,65.31 C245.1
N53869491: length 0.9
  TOP w0.119: R180.2 C198.1
N54227584: length 3.9
  TOP w0.119: v2(127.88,117.29) 127.91,117.26 R5.1
  IN2 w0.076: v2(128.24,120.42) 128.24,120.4 127.66,119.82 127.66,119.25 127.77,119.15 127.77,118.59 127.93,118.43 127.93,117.55 127.88,117.5 v2(127.88,117.29)
N54227586: length 3.9
  TOP w0.119: U4.B11 126.73,124.92 126.49,124.67 124.23,124.67 R4.1
N54714782: length 6.4
  TOP w0.076: U3.B11 105.89,113.71 105.89,113.01
  TOP w0.119: R3.1 102.85,109.74 103.18,110.07 104.37,110.07 104.55,110.24 104.55,111.68 105.89,113.01
N54714783: length 4.2
  TOP w0.119: R2.1 113.79,116.33 v2(113.73,116.27)
  IN2 w0.076: v2(113.73,116.27) 113.48,116.27 113.26,116.05 112.79,116.05 112.2,115.45 111.89,115.45 111.6,115.74 110.79,115.74 110.64,115.59 v2(110.64,115.45)
N55958256: length 4.4
  TOP w0.203: UA1.43 33.32,16.23 33.66,15.88 33.66,15.27 34.42,14.51 34.75,14.51 CA26.1
  TOP w0.254: CA27.1 35.74,14.42 CA26.1
N55958521: length 3.1
  TOP w0.203: UA1.21 25.02,19.03 24.47,18.47 CA30.1
  TOP w0.254: CA30.1 23.34,18.47 CA31.1
N55958533: length 4
  TOP w0.203: CA33.1 35.82,15.04 34.63,15.04 34.07,15.6 34.07,16.42 33.85,16.63 UA1.44
N55958539: length 3
  TOP w0.203: UA1.41 31.71,14.89 32.07,14.52 32.07,13.28 31.65,12.86 CA34.1
N55958618: length 5.9
  TOP w0.203: UA1.46 33.56,17.43 34.54,18.41 CA15.1
  TOP w0.254: CA15.1 35.07,18.41 35.41,18.75 LA3.2
N55958653: length 5.1
  TOP w0.203: CA9.1 34.51,20.26 33.68,19.43 UA1.51
  TOP w0.254: CA9.1 34.84,22.45 LA2.2
N55960562: length 5.2
  TOP w0.119: RA15.2 16.57,15.11 16.57,14.13 16.8,13.9 QA1.5 17.59,13.9 17.74,13.76 17.74,13.4 17.59,13.25 ; Q68.2 18.28,12.56 17.59,13.25 ; 17.59,13.25 QA1.6
N55960594: length 3.7
  TOP w0.119: QA1.2 19.31,13.9 19.59,14.18 19.59,14.77 19.23,15.12 18.93,15.12 18.74,15.31 RA19.1 18.23,15.5 RA13.2 RA17.2
N55967094: length 1.3
  TOP w0.305: R69.2 196.87,138.29 197.25,137.9 C116.1
N55977579: length 1.9
  TOP w0.152: R87.1 117.86,125.33 ML3.1 117.86,124.46 117.62,124.23 117.62,123.92 C132.2
N55977609: length 1.9
  TOP w0.152: C131.2 117.29,123.92 117.29,124.23 117.06,124.46 ML3.4 117.06,125.33 R86.1
N56067860: length 4
  TOP w0.203: UA1.18 25.06,20.23 24.33,20.96 24.33,21.81 24.16,21.98 CA23.1
  TOP w0.254: CA22.1 23.22,21.98 CA23.1
N56068412: length 2.1
  TOP w0.203: CA25.1 26.75,13.6 26.75,13.95 26.37,14.33 26.37,14.61 26.91,15.15 UA1.29
N56068450: length 2
  TOP w0.203: CA24.1 27.36,13.88 27.36,14.36 27.71,14.71 UA1.31
N56068743: length 3.6
  TOP w0.119: UA1.25 25.62,17.43 24.89,16.69 24.89,14.86 CA18.1
N56068745: length 4.2
  TOP w0.119: UA1.26 25.54,17.03 25.11,16.6 25.11,14.16 CA18.2
N56068751: length 3.9
  TOP w0.119: UA1.28 25.96,14.38 26.34,14 26.34,13.11 CA19.2
N56068753: length 3.8
  TOP w0.119: UA1.27 25.56,16.63 25.33,16.4 25.33,15.91 25.74,15.5 25.74,14.28 25.89,14.13 CA19.1
N56194338: length 0.8
  TOP w0.305: R13.1 C7.2
N56194376: length 1
  TOP w0.119: R17.1 120.59,127.73 120.33,127.47 C8.2
N56194392: length 0.8
  TOP w0.381: C6.2 105.56,124.42 R12.1
N57436928: length 1.3
  TOP w0.119: C224.1 237.62,135.76 U30.12
N57439320: length 1.5
  TOP w0.119: C1230.1 152.31,94.17 U40.12
N57439346: length 1.5
  TOP w0.119: U40.10 152.4,94.97 C1231.1
N57439824: length 1.4
  TOP w0.119: U40.3 156.59,94.17 R1025.2
N57468042: length 1.2
  TOP w0.119: U709.4 100.01,93.09 R1028.2
N57468960: length 4
  TOP w0.119: R1030.2 137.55,84.52 137.92,84.15 139.17,84.15 v1(139.37,84.35)
  IN1 w0.089: v1(139.37,84.35) 140.55,84.35 140.77,84.57 v1(140.77,84.95)
N57645414: length 7
  TOP w0.119: C263.1 145.69,126.42 145.52,126.59 v1(143.49,126.59) ; U41.12 v1(140.93,124.76)
  IN1 w0.089: v1(143.49,126.59) 143.49,125.81 142.79,125.12 141.29,125.12 v1(140.93,124.76)
N125071922: length 6.5
  IN1 w0.06: v1(134.41,100.28) 134.61,100.28 134.82,100.08 135.27,100.08 136.47,98.88 137.19,98.88 137.51,98.56 138.28,98.56 138.54,98.31 139.07,98.31 139.62,97.76
  IN1 w0.089: 139.62,97.76 139.69,97.68 v1(139.69,97.52)
N125164302: length 10.1
  TOP w0.119: v1(142.84,111.04) 142.6,110.79 TC63.1
  IN1 w0.06: v1(133.91,110.59) 134.24,110.91 134.86,110.91 135.14,110.63 135.64,110.63 135.7,110.58 137.55,110.58 137.67,110.69 140.16,110.69 140.32,110.54 140.68,110.54
  IN1 w0.089: 140.68,110.54 141.22,110.54 141.5,110.82 141.98,110.82 142.2,111.04 v1(142.84,111.04)
N125184377: length 1.6
  TOP w0.229: v10(130.94,108.69) 130.94,108.3 v10(130.96,108.27)
  IN1 w0.254: v10(130.94,108.69) v10(130.96,108.27)
  GND4 w0.254: v9(131.68,107.88) 131.65,107.86 130.99,107.86 v4(130.93,107.92)
N125185663: length 6
  TOP w0.089: TC129.1 139,95.03 138.65,95.38 138.19,95.38 137.47,96.1 136.61,96.1 136.28,96.42 136.28,96.73 135.32,97.7 134.86,97.7 UC1.B4
N125185665: length 6.1
  TOP w0.06: UC1.B3 135.11,97.87 135.44,97.87 136.03,97.28
  TOP w0.119: TC131.1 139.37,95.34 139.04,95.34 138.8,95.58 138.28,95.58 137.56,96.3 136.69,96.3 136.49,96.5 136.49,96.82 136.03,97.28
N125185667: length 1.1
  IN2 w0.06: v2(134.99,98.86) 135.13,99 135.13,99.28 135.23,99.38 v4(135.23,99.38)
  GND4 w0.119: v9(135.41,99.8) 135.24,99.63 135.24,99.38 v4(135.23,99.38)
N125185669: length 5.2
  TOP w0.119: UC1.F1 136.26,98.09 136.26,97.87 137.56,96.56 137.64,96.56 138.4,95.8 139.03,95.8 TC135.1
N125185671: length 1.3
  GND1 w0.119: v2(125.14,100.06) 125.29,100.21 125.29,100.22 v4(125.56,100.49)
  GND4 w0.06: v9(124.95,100.24) 125.23,100.24 125.48,100.49 v4(125.56,100.49)
N125185842: length 8.2
  IN1 w0.06: v5(116.8,96.22) 117.06,95.96 118.83,95.96 119.68,96.81 119.68,96.92 119.87,97.11 120.21,97.11 120.84,97.73 120.84,98.22 v1(120.95,98.34)
  GND1 w0.119: v5(116.8,96.22) 117,96.02 v4(117.13,96.02)
  GND4 w0.119: v9(117.25,95.64) 117.13,95.77 v4(117.13,96.02)
  BOTTOM w0.119: TC148.1 118.34,94.55 v9(117.25,95.64)
N125185844: length 0.8
  GND1 w0.06: v4(129.67,100.57) 129.93,100.31 v10(129.97,100.31)
  GND4 w0.06: v4(129.67,100.57) 129.72,100.57 v6(129.98,100.31)
N125185848: length 1.5
  IN2 w0.06: v2(130.62,100.31) 130.68,100.31 v4(130.92,100.54)
  GND4 w0.119: v9(130.63,100.99) 130.94,100.67 130.94,100.52 v4(130.92,100.54)
  BOTTOM w0.119: v9(130.63,100.99) 130.79,100.82 TC153.1
N125185850: length 5.1
  TOP w0.06: 126.71,96.43 v1(126.71,97.28)
  TOP w0.119: 126.71,96.43 126.71,96.08 126.6,95.97 TC155.1
  IN1 w0.06: v1(126.71,97.28) 126.92,97.48 126.92,97.81 127.48,98.37 127.48,98.62 127.63,98.78 127.71,98.78 128.05,99.12 128.12,99.12 128.24,99.24 128.24,99.4 128.16,99.49 128.16,99.65 128.36,99.85 v1(128.36,100.06)
N125185953: length 2.7
  TOP w0.119: TC111.1 114.23,111.74 UC1.BL64
N125186153: length 4.4
  IN2 w0.06: v4(135.26,100.87) 135.19,100.8 134.71,100.8 134.53,100.97 134.53,101.2 134.2,101.53 133.69,101.53 133.52,101.37 133.17,101.37 133.05,101.25 v2(132.68,101.25)
  GND4 w0.119: v9(135.34,100.49) 135.34,100.8 v4(135.26,100.87)
  BOTTOM w0.119: TC119.1 v9(135.34,100.49)
N125186155: length 8.1
  IN2 w0.06: v2(132.44,100.93) 132.65,100.93 132.84,101.13 133.1,101.13 133.22,101.25 133.57,101.25 133.74,101.41 134.15,101.41 134.41,101.15 134.41,100.86 134.7,100.57 135.39,100.57 135.64,100.82 136.34,100.82 136.85,100.31 137.4,100.31 137.78,99.94 137.78,99.55 138.13,99.2 v4(138.13,99.17)
  GND4 w0.119: v9(138.51,98.64) 138.51,98.79 v4(138.13,99.17)
N125186157: length 8.3
  IN2 w0.06: v4(136.12,97.85) 135.62,98.36 135.02,98.36 134.46,98.92 134.42,98.92 133.85,99.48 133.19,99.48 132.78,99.89 132.78,99.97 132.4,100.35 131.95,100.35 v2(131.9,100.31)
  GND4 w0.119: v4(136.12,97.85) 136.33,97.85 v9(136.48,97.7)
  BOTTOM w0.119: 136.46,96.78 136.05,96.38 TC121.1 ; 136.48,97.39 v9(136.48,97.7)
  BOTTOM w0.127: 136.46,96.78 136.48,96.81 136.48,97.39
N125186159: length 6.2
  IN2 w0.06: v4(136.03,97.34) 135.82,97.55 135.82,97.82 135.41,98.23 134.97,98.23 134.41,98.8 134.37,98.8 133.8,99.37 133.14,99.37 132.44,100.06 v2(131.58,100.06)
  GND4 w0.119: v4(136.03,97.34) 135.95,97.26 v9(135.95,96.86)
N125186161: length 6
  IN2 w0.06: v4(135.46,97.72) 135.38,97.81 135.22,97.81 134.4,98.64 134.35,98.64 133.79,99.2 133.13,99.2 132.5,99.83 131.48,99.83 131.25,100.06 v2(130.94,100.06)
  GND4 w0.119: v4(135.46,97.72) 135.36,97.82 v9(135.36,98.23)
N125186163: length 4.3
  IN2 w0.06: v4(134.52,99.25) 134.47,99.25 134.02,99.7 133.14,99.7 132.95,99.89 132.95,99.98 132.42,100.51 131.82,100.51 131.62,100.31 v2(131.26,100.31)
  GND4 w0.119: v4(134.52,99.25) 134.5,99.22 v9(134.14,99.22)
N125186165: length 8.3
  IN1 w0.06: 134.65,95.03 134.13,95.54 134.13,96.09 132.81,97.41 132.76,97.41 132.31,97.86 132.31,97.95 132.11,98.15 132.11,98.52 132.19,98.6 132.19,99.28 132.55,99.64 v1(132.55,99.81)
  IN1 w0.089: v1(136.19,93.95) 135.97,94.17 135.01,94.17 134.65,94.53 134.65,95.03
N125186167: length 9.6
  IN1 w0.06: 135.05,95.03 134.25,95.82 134.25,96.14 132.86,97.53 132.81,97.53 132.43,97.91 132.43,98 132.23,98.2 132.23,98.47 132.25,98.49 132.25,98.49 132.31,98.55 132.31,99.08 v1(132.55,99.32)
  IN1 w0.089: 135.05,95.03 135.17,94.9 136.11,94.9 137.92,93.1 v1(137.92,92.82)
N125186171: length 4.7
  TOP w0.119: v1(139.05,112.6) 139.05,112.18 TC130.1
  IN1 w0.06: v1(139.05,112.6) 139.01,112.65 138.44,112.65 138.15,112.36 136.04,112.36 135.87,112.19 135.02,112.19 v1(134.99,112.22)
N125186173: length 3.9
  TOP w0.089: TC132.1 138.33,112.5 136.69,112.5 136.28,112.92 135.23,112.92 UC1.BP3
N125186177: length 9.5
  GND1 w0.119: v4(129.06,100.57) 129.32,100.31 v2(129.33,100.31)
  IN2 w0.254: v2(129.33,100.31) 129.07,100.57 v4(129.06,100.57)
  GND2 w0.406: v4(130.3,93.8) 130.31,93.8 130.37,93.86 130.37,94.61 130.83,95.07 130.83,95.86 129.62,97.06 129.62,99.83 129.06,100.39 v4(129.06,100.57)
  GND4 w0.254: v9(130.41,94.24) 130.41,93.91 v4(130.3,93.8)
  BOTTOM w0.508: TC136.1 130.66,94.24 v9(130.41,94.24)
N125186179: length 0.8
  GND1 w0.119: v4(130.01,108.97) 130.07,108.97 130.27,109.18 v2(130.29,109.18)
  GND4 w0.06: v9(130.36,109) 130.33,109.02 130.06,109.02 v4(130.01,108.97)
N125186183: length 3.3
  TOP w0.06: UC1.BN1 135.77,112.2 135.79,112.23 138.16,112.23
  TOP w0.119: TC138.1 138.54,111.84 138.16,112.23
N125186366: length 13.8
  TOP w0.119: v2(142.7,113.71) 142.9,113.71 143.65,114.46 RC153.1
  IN2 w0.06: v2(132.23,109.67) 132.57,110.01 132.57,110.24 132.65,110.33 133.01,110.33 133.81,111.13 134.54,111.13 135.7,112.3 136.29,112.3 136.71,112.72 137.19,112.72 137.24,112.66 138.35,112.66 138.39,112.63 138.89,112.63
  IN2 w0.084: v2(142.7,113.71) 142.16,113.71 141.89,113.45 141,113.45 140.8,113.65 139.9,113.65 138.89,112.63
N125186425: length 5.1
  TOP w0.119: v1(126.45,97.01) 126.35,96.91 126.35,96.27 126.17,96.1 TC150.1
  IN1 w0.06: v1(126.45,97.01) 126.45,97.59 127.3,98.45 127.3,98.64 127.2,98.75 127.2,98.91 127.27,98.99 127.35,99.07 127.43,99.07 127.59,99.23 127.59,99.23 127.6,99.24 127.6,99.4 127.52,99.48 127.52,99.65 127.72,99.85 v1(127.72,100.06)
N125186427: length 1
  GND1 w0.06: v4(128.45,100.52) 128.23,100.52 128.04,100.33 v2(128.04,100.31)
  GND4 w0.06: v6(128.05,100.36) 128.17,100.49 128.43,100.49 v4(128.45,100.52)
N126479310: length 6.5
  IN1 w0.06: v1(134.65,99.96) 134.65,99.96 135.22,99.96 136.44,98.74 137.16,98.74 137.49,98.41 138.26,98.41 138.59,98.08 139.13,98.08 139.41,97.79 139.41,97.58 139.43,97.57
  IN1 w0.089: 139.43,97.57 139.43,97.42 139.69,97.16 v1(139.69,97.06)
N126490868: length 1.8
  TOP w0.119: Q10.3 143.83,123.28 R1.1 144.09,123.78 Q10.2
N126490934: length 0.9
  TOP w0.152: Q10.1 144.22,124.28 143.95,124.01 RH26.1
N126538537: length 1.5
  BOTTOM w0.119: TC67.1 115.58,97.72 115.58,97.29 115.84,97.02 RH54.1
N1782815210: length 2.8
  TOP w0.203: U21.11 67.81,147.52 67.46,147.87 67.46,148.38
  TOP w0.254: 67.46,148.38 67.46,148.88 66.91,149.42 R34.2
N1782815211: length 2.7
  TOP w0.119: U21.12 67.74,147.12 67.15,147.71 67.15,148.57 66.87,148.85 R36.2

## Copper pours and planes (outline as drawn)
+0.85V_PRIM on TOP: 163.94,111.03 164.57,111.03 164.78,110.83 164.78,110.45 164.8,110.42 165.32,110.42 165.33,110.41 165.33,110.24 165.31,110.22 164.8,110.22 164.78,110.19 164.78,109.79 164.62,109.63 164.06,109.63 163.94,109.76 163.94,110.24 163.83,110.35 163.83,110.92
+0.85V_PRIM on VCC: 151.24,99.73 151.24,109.33 151.44,109.53 151.44,111.54 163.83,111.54 164.57,110.8 164.57,103.79 158.71,103.79 158.2,104.3 153.67,104.3 153.14,103.77 153.14,100.09 152.78,99.73
+1.0V_MPHYGT on TOP (solid shape): 136.84,102.23 137.48,102.23 137.53,102.23 137.63,102.23 137.73,102.14 137.73,101.76 137.67,101.71 137.12,101.71 137.02,101.62 135.89,101.62 135.65,101.38 135.36,101.38 135.12,101.62 135.12,101.63 135.08,101.71 135,101.77 134.98,101.78 134.98,102 135.03,102.03 135.06,102.05 135.12,102.08 135.39,101.92 135.62,102.01 135.87,102.26 136.82,102.26
+1.0V_MPHYGT on TOP: 140.19,95.92 142.86,95.92 142.98,95.79 142.98,94.65 142.86,94.52 142.2,94.52 142.12,94.45 140.26,94.45 140.06,94.65 140.06,95.79
+1.0V_MPHYGT on BOTTOM: 142.35,94.65 141.33,93.63 138.79,93.63 137.52,92.36 135.11,92.36 134.22,93.25 134.22,93.26 133.94,93.54 133.94,100.4 134.22,100.68 134.22,102.52 134.47,102.78 135.74,102.78 135.87,102.65 135.87,94.46 136.52,93.81 137.12,93.81 137.41,94.1 137.41,94.46 137.89,94.94 139.3,94.94 139.52,95.16 142.23,95.16 142.35,95.04
+1.0V_MPHYGT on VCC: 133.38,94.39 128.94,98.84 128.94,99.78 128.87,99.84 128.87,103.67 128.25,104.29 128.25,106.41 130.38,106.41 130.38,105.22 130.08,104.91 130.08,104.2 130.41,103.87 130.41,103.46 129.75,102.8 129.75,102.42 130.46,101.71 130.46,100.51 130.87,100.11 132.75,100.11 133.08,100.44 133.08,101.2 133.51,101.63 133.91,101.63 134.17,101.38 134.42,101.38 135.69,100.11 137.72,100.11 142.09,95.74 142.09,94.45 142.04,94.39
+1.0V_MPHYPLL on BOTTOM (solid shape): 132.06,102.14 132.06,100.49 131.93,100.36 131.43,100.36 131.3,100.49 131.3,102.14 131.43,102.27 131.93,102.27
+1.0V_MPHYPLL on TOP: 139.55,93.51 141.46,93.51 141.59,93.38 141.59,92.11 141.33,91.85 139.68,91.85 139.43,92.11 139.43,93.38
+1.0V_MPHYPLL on VCC: 139.83,91.73 139.83,94.14 142.15,94.14 142.35,94.34 142.35,95.84 137.83,100.36 135.8,100.36 134.53,101.63 134.27,101.63 134.02,101.89 133.41,101.89 132.82,101.31 132.82,100.54 132.64,100.36 130.97,100.36 130.71,100.62 130.71,101.63 131.1,101.63 131.68,102.22 132.14,102.22 132.82,102.9 136.71,102.9 141.91,97.7 143.31,97.7 144.13,96.88 144.13,94.24 142.35,92.47 142.35,91.73
+1.0V_PRIM on TOP: 155.11,93.89 156.13,93.89 156.53,93.48 156.98,93.48 157.03,93.43 157.03,92.85 156.93,92.74 155.14,92.74 155.06,92.82 155.06,93.84
+1.0V_PRIM on TOP: 100.46,94.24 100.31,94.39 100.31,95.35 100.34,95.37 103.07,95.37 103.16,95.28 103.16,92.9 103.1,92.85 101.58,92.85 101.53,92.9 101.53,94.01 101.3,94.24
+1.0V_PRIM on TOP: 156.62,95.51 157.19,95.51 157.31,95.62 157.31,96.11 157.34,96.14 157.96,96.14 158.21,96.39 158.21,96.81 158.03,96.99 157.56,96.99 156.99,96.42 155.4,96.42 155.34,96.48 155.34,97.18 155.29,97.23 154.86,97.23 154.82,97.19 154.82,96.19 155.06,95.95 155.06,95.33 155.12,95.27 156.38,95.27
+1.0V_PRIM on TOP: 156.83,103.41 156.83,102.27 156.7,102.14 152.25,102.14 151.87,102.52 151.75,102.52 151.49,102.78 151.49,103.67 153.65,103.67 153.7,103.62 154.26,103.62 154.26,104.17 155.32,104.17 155.32,103.62 156.62,103.62
+1.0V_PRIM on VCC: 152.93,89.71 151.93,90.71 145.96,90.71 145.4,91.27 145.4,91.55 146.16,92.31 146.16,93.45 148.57,95.87 148.57,99.35 150.88,99.35 151.01,99.22 152.99,99.22 153.65,99.88 153.65,103.56 153.88,103.79 157.99,103.79 158.35,103.43 158.35,95.13
+1.0V_VCCST on TOP: 153.73,93.9 152.86,93.9 152.24,93.28 151.3,93.28 151.16,93.14 149.99,93.14 149.93,93.07 149.93,92.29 150.05,92.17 153.38,92.17 153.8,92.59 153.8,93.82
+1.0V_VCCST on TOP: 136.96,89.22 136.84,89.1 136.84,88.74 137.15,88.44 138.12,88.44 138.26,88.58 138.26,89.14 138.17,89.22
+1.0V_VCCST on TOP: 143.77,90.5 145.06,90.5 145.24,90.32 145.24,89.81 145.01,89.58 143.9,89.58 143.7,89.79 143.7,90.42
+1.0V_VCCST on BOTTOM: 135.17,89.11 133.93,89.11 133.23,89.81 133.23,90.41 132.24,91.4 129.41,91.4 128.41,92.39 128.41,94.29 127.7,94.99 127.7,96.15 127.82,96.26 129.33,96.26 130.3,97.23 130.3,99.7 130.12,99.88 130.12,100.21 130.19,100.29 131.2,100.29 132.56,98.93 132.56,92.85 134.98,90.42 136.73,90.42 136.97,90.18 136.97,89.65 136.43,89.11 135.17,89.11
+1.0V_VCCST on IN1: 145.97,89.47 144.56,89.47 144.5,89.53 144.5,90.11 144.63,90.24 145.88,90.24 145.97,90.15
+1.0V_VCCST on IN1: 149.27,89.71 147.91,89.71 147.89,89.68 147.89,88.98 148,88.87 148.49,88.87 148.63,89.01 149.21,89.01 149.36,89.16 149.36,89.62
+1.0V_VCCST on IN3: 128.24,102.65 129.9,102.65 131.18,101.37 131.18,100.24 130.84,99.89 129.03,99.89 128.09,100.83 128.09,102.5
+1.0V_VCCST on IN3: 136.85,89.7 135.84,89.7 135.75,89.61 135.75,89 135.91,88.84 136.89,88.84 137.04,88.99 137.04,89.51
+1.0VA_GATE on TOP: 151.82,97.44 153.27,97.44 153.38,97.34 153.38,96.41 153.39,96.39 153.79,96 153.79,95.33 153.73,95.27 152.58,95.27 152.43,95.42 152.43,95.69 152.36,95.77 151.81,95.77 151.7,95.88 151.7,97.32
+1.0VA_S on TOP (solid shape): 156.19,109.89 156.19,104.55 155.81,104.17 155.81,103.77 155.42,103.77 155.42,104.27 154.97,104.27 154.97,103.77 154.62,103.77 154.62,104.27 154.17,104.27 154.17,103.77 153.72,103.77 153.57,103.92 151.62,103.92 151.49,104.05 151.49,110.02 151.62,110.14 155.94,110.14
+1.0VS_VCCIO on TOP (solid shape): 118.68,117 118.68,116.37 118.32,116.01 118.32,115.6 118.12,115.4 117.76,115.4 116.64,116.52 116.64,117.03 116.67,117.05 118.62,117.05
+1.0VS_VCCIO on GND1 (solid shape): 128.66,106.09 128.66,105.46 129.3,104.82 129.33,104.77 129.38,104.74 129.64,104.48 129.64,103.76 129.54,103.66 128.92,103.66 128.72,103.86 128.72,104.01 128.63,104.1 128.63,104.27 128.64,104.34 128.63,104.41 128.63,104.66 128.18,105.1 128.18,105.41 128.19,105.48 128.18,105.55 128.18,106.06 128.32,106.2 128.55,106.2
+1.0VS_VCCIO on GND1 (solid shape): 123.26,108.98 123.81,108.98 123.85,108.97 123.9,108.98 124.01,108.98 124.07,109.05 124.24,109.05 124.27,109.02 124.33,108.97 124.61,108.97 124.62,108.98 124.76,108.98 124.82,109.05 125.23,109.05 125.42,108.86 125.8,108.86 126.01,109.08 127.2,109.08 127.44,108.84 128.26,108.84 128.39,108.97 128.66,108.97 128.74,108.89 128.74,108.63 128.62,108.51 127.16,108.51 127.07,108.6 126.69,108.6 126.62,108.52 125.25,108.52 125.18,108.59 124.73,108.59 124.65,108.52 123.09,108.52 123.08,108.51 122.29,108.51 122.21,108.6 121.82,108.6 121.73,108.51 121.16,108.51 121.12,108.53 121.02,108.63 120.68,108.63 120.66,108.61 120.41,108.61 120.31,108.7 120.31,108.96 120.42,109.07 121,109.07 121.25,108.82 121.39,108.82 121.66,109.09 123.15,109.09
+1.0VS_VCCIO on GND4 (solid shape): 128.15,109.1 128.15,109.04 127.86,108.75 127.35,108.75 127.22,108.63 126.93,108.63 126.79,108.77 126.35,108.77 126.23,108.65 126.07,108.65 126.02,108.65 125.96,108.65 125.87,108.73 125.21,108.73 125.12,108.64 124.93,108.64 124.87,108.7 124.34,108.7 124.27,108.63 124.08,108.63 124.02,108.69 123.21,108.69 123.15,108.64 122.68,108.64 122.67,108.66 122.57,108.66 122.57,108.65 121.84,108.65 121.74,108.56 121.38,108.56 121.27,108.66 120.71,108.66 120.67,108.62 120.41,108.62 120.29,108.75 120.29,108.98 120.37,109.07 121.09,109.07 121.19,109.17 121.46,109.17 121.61,109.13 121.76,109.17 123.03,109.17 123.23,108.98 123.57,108.98 123.72,109.13 124.09,109.13 124.17,109.06 124.27,109.06 124.35,108.98 124.84,108.98 124.92,109.06 125.14,109.06 125.22,108.98 125.93,108.98 126.02,109.07 126.61,109.07 126.72,109.18 127.1,109.18 127.21,109.07 127.61,109.07 127.76,109.22 128.04,109.22
+1.0VS_VCCIO on TOP: 128.35,108.42 128.58,108.42 128.68,108.32 128.68,105.14 128.71,105.11 129.05,105.11 129.17,104.99 129.17,104.55 129.18,104.55 129.39,104.55 129.39,104.55 129.55,104.55 129.67,104.43 129.67,103.7 129.58,103.62 128.87,103.62 128.79,103.7 128.79,104.13 128.75,104.16 128.41,104.16 128.29,104.28 128.29,108.36
+1.0VS_VCCIO on TOP: 151.27,112.7 151.81,112.7 151.81,111.66 151.24,111.66 151.24,111.16 151.11,111.03 149.84,111.03 149.71,111.16 149.71,113.19 149.84,113.32 151.21,113.32 151.27,113.26
+1.0VS_VCCIO on TOP: 120.38,109 128.23,109 128.43,108.8 128.43,108.64 128.4,108.62 120.38,108.62 120.25,108.75 120.25,108.87
+1.0VS_VCCIO on BOTTOM: 129.65,109.25 130.13,108.77 130.13,104.4 129.9,104.17 129.65,104.17 129.39,104.43 129.39,108.57 126.9,108.57 126.68,108.8 118.7,108.8 118.55,108.95 118.55,109.18 118.62,109.25
+1.0VS_VCCIO on BOTTOM: 150.98,111.29 150.86,111.16 149.21,111.16 149.08,111.29 149.08,113.06 149.33,113.32 150.73,113.32 150.98,113.06
+1.0VS_VCCIO on IN1: 128.82,103.6 128.73,103.69 128.73,103.95 128.58,104.1 128.44,104.1 128.24,104.3 128.24,108.26 128.25,108.28 128.25,108.36 128.12,108.49 128.14,108.51 127.96,108.51 127.93,108.54 120.38,108.54 120.13,108.79 120.13,109.02 120.17,109.07 128.1,109.07 128.11,109.06 128.21,109.06 128.45,108.82 128.5,108.87 128.76,108.62 128.76,108.49 128.75,108.48 128.75,108.35 128.78,108.31 128.78,105.34 129.2,104.92 129.2,104.76 129.3,104.66 129.61,104.66 129.7,104.57 129.7,103.64 129.66,103.6
+1.0VS_VCCIO on IN2: 128.94,104.54 127.82,105.65 127.82,107.65 126.91,108.56 121.84,108.56 121.79,108.52 121.41,108.52 121.37,108.56 121.37,108.56 121.15,108.56 121.1,108.61 120.38,108.61 120.17,108.82 120.17,109.05 120.28,109.15 120.25,109.18 120.25,109.51 120.5,109.76 123.3,109.76 123.42,109.63 128.91,109.63 129.37,109.18 129.37,108.36 129.61,108.12 129.6,108.12 130.12,107.6 130.12,106.18 129.71,105.77 129.71,105.41 129.5,105.2 129.5,104.77 129.26,104.54
+1.0VS_VCCIO on IN2: 117.07,116.37 117.58,116.37 118.22,115.73 118.22,114.84 117.96,114.59 117.71,114.59 116.95,115.35 116.95,116.24
+1.0VS_VCCIO on IN3: 121.87,108.62 121.78,108.54 121.29,108.54 121.2,108.62 119.99,108.62 119.91,108.71 119.91,110.02 117.2,112.72 117.2,116.49 117.71,117 119.61,117 122.15,114.46 127.11,114.46 128.76,112.81 128.76,105.57 129.27,105.06 129.27,104.68 129.08,104.49 128.74,104.49 128.55,104.68 128.55,104.93 128.24,105.25 128.24,108.24 127.86,108.62 127.36,108.62 127.36,108.7 127.28,108.62
+1.0VS_VCCIO on VCC: 128.25,106.66 128.25,107.98 128.28,108.01 128.28,108.39 128,108.67 127.8,108.67 127.67,108.8 127.33,108.8 127.21,108.67 126.25,108.67 126.04,108.87 125.33,108.87 125.12,108.67 123.12,108.67 123.02,108.77 122.69,108.77 122.58,108.67 120.51,108.67 120.25,108.93 120.25,109.15 120.38,109.28 120.38,109.87 117.18,113.06 148.04,113.06 148.3,113.32 150.62,113.32 150.93,113.01 150.93,109.74 150.88,109.69 131.73,109.69 130.38,108.34 130.38,106.66
+1.0VS_VCCIO_S on TOP (solid shape): 155.81,118.35 155.81,114.65 154.29,113.12 154.29,110.78 153.9,110.4 151.62,110.4 151.42,110.6 151.42,111.49 151.43,111.5 151.97,111.5 151.97,111.51 151.97,112.05 151.97,112.05 151.44,112.05 151.42,112.07 151.42,112.28 151.44,112.3 151.95,112.3 151.97,112.33 151.97,112.84 151.97,112.85 151.43,112.85 151.42,112.86 151.42,117.94 151.61,118.14 154.26,118.14 154.69,118.58 155.58,118.58
+1.0VS_VCCSTG on TOP: 105.75,93.1 104.55,93.1 104.02,92.57 99.6,92.57 99.49,92.45 99.49,91.93 99.54,91.88 105.19,91.88 105.86,92.55 105.86,92.98
+1.0VS_VCCSTG on TOP: 126.78,91.96 127.56,91.96 128.32,92.72 128.32,93.07 128.33,93.08 128.98,93.08 128.99,93.08 129.17,93.08 129.17,94.65 129.06,94.75 128.5,94.75 128.45,94.7 128.45,93.63 127.92,93.1 126.93,93.1 126.7,92.87 126.7,92.03
+1.2V_KEYSSA on TOP: 102.34,83.73 105.9,83.73 106.28,83.35 106.28,82.46 106.79,81.95 109.79,81.95 110.01,81.72 112.35,81.72 112.8,82.16 113.52,82.16 113.62,82.06 113.62,81.44 113.11,80.93 102.47,80.93 101.96,81.44 101.96,83.35
+1.2V_KEYSSA on IN3: 110.6,85.44 110.6,88.4 110.83,88.63 111.96,88.63 112.25,88.34 112.25,86.24 113.9,84.59 113.9,81.69 113.77,81.57 112.64,81.57 112.53,81.68 112.53,83.5
+1.2V_KEYSSA_DP on TOP: 111.66,83.41 112.15,83.41 112.21,83.35 112.21,82.48 112.33,82.37 112.33,81.95 112.2,81.82 111.4,81.82 111.3,81.92 111.3,82.15 111.6,82.46 111.6,83.35
+1.2V_KEYSSA_DP on TOP: 94.68,98.38 95.38,98.38 95.49,98.49 95.49,100 95.37,100.12 94.67,100.12 94.57,100.01 94.57,98.5
+1.2V_KEYSSA_DP on BOTTOM: 96.11,98.67 97,98.67 97.15,98.82 97.15,100.03 97.09,100.09 96.82,100.09 96.81,100.09 96.62,100.09 96.02,99.49 96.02,98.76
+1.2V_KEYSSA_DP on BOTTOM: 109.7,81.83 105.86,81.83 105.58,82.1 105.58,82.79 105.78,82.99 111.27,82.99 111.27,82.96 112.03,82.96 112.33,82.67 112.33,81.85 112.24,81.76 109.77,81.76
+1.2V_KEYSSA_DP on BOTTOM: 99.76,84.57 96.73,84.57 96.47,84.83 96.47,86.03 96.6,86.16 98.66,86.16 99.11,85.71 99.8,85.71 99.97,85.54 99.97,84.79
+1.2V_KEYSSA_DP on GND1: 94.8,100.04 95.92,100.04 96.02,99.94 96.02,99.37 96.02,99.37 96.02,99.28 95.9,99.16 95.03,99.16 94.74,99.45 94.74,99.98
+1.2V_KEYSSA_DP on IN3: 95.72,100.07 97.04,100.07 97.12,99.98 97.12,99.12 97.01,99.01 95.78,99.01 95.57,99.21 95.57,99.92
+1.2V_VCCSFR_OC on TOP: 136.92,87.77 137.05,87.64 137.05,87.11 136.96,87.02 135.33,87.02 135.23,87.11 134.22,87.11 134.22,87.11 133.75,87.11 133.52,87.34 133.52,87.65 133.64,87.77
+1.2V_VCCSFR_OC on IN2: 127.81,105.13 127.81,104.12 128.2,103.74 128.49,103.74 128.6,103.85 128.6,104.45 128.41,104.65 128.41,104.88 128.1,105.19 127.87,105.19
+1.2V_VCCSFR_OC on IN3: 127.81,105.01 127.81,104.12 128.2,103.74 128.49,103.74 128.6,103.85 128.6,104.45 128.41,104.65 128.41,104.88 128.1,105.19 128,105.19
