# Allegro board LAC321PR10-0907B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1: 128.72,107.55 128.72,105.15 129.02,105.15 129.2,104.97 129.2,104.58 129.52,104.58 129.7,104.4 129.7,103.47 129.72,103.45 130.55,103.45 130.61,103.51 131.7,103.51 131.74,103.55 131.74,104.06 131.7,104.1 130.36,104.1 130.25,104.2 130.25,104.3 130.25,104.3 130.25,104.96 130.42,105.13 130.42,105.25 130.36,105.32 129.84,105.32 129.78,105.37 129.78,105.79 129.71,105.86 129.34,105.86 129.23,105.98 129.23,107.55
GND on IN1: 123.89,104.78 124.2,104.78 124.23,104.82 124.23,107.8 124.2,107.84 123.89,107.84 123.85,107.8 123.85,104.82
GND on IN1: 118.34,137.07 117.33,137.07 117.2,136.94 117.2,135.8 117.33,135.67 123.16,135.67 125.1,133.73 129.74,133.73 130.65,134.64 130.65,136.83 130.03,137.45 124.25,137.45 123.74,136.94 118.47,136.94
GND on IN1: outline of 98 points within 144.49,119.74 149.21,130.69 ; 1 cut-out
GND on IN1: 171.5,120.64 173.82,118.31 173.82,117.63 175.44,116.01 175.94,116.01 176.02,115.94 176.02,113.02 176.66,112.37 176.66,110.75 176.39,110.48 176,110.48 175.79,110.7 175.79,111.21 175.06,111.94 173.71,111.94 172.96,112.69 172.96,116.01 173.14,116.18 173.14,117.45 172.04,118.56 171.52,118.56 170.63,119.45 169.69,119.45 168.8,120.34 168.8,120.44 168.78,120.52 168.72,120.57 168.7,120.58 168.7,120.64 168.75,120.71 168.83,120.69 168.92,120.61 168.91,120.58 168.89,120.45 168.96,120.33 169.72,119.57 170.66,119.57 171.55,118.68 171.81,118.68 172.04,118.91 171.81,119.13 171.73,119.13 170.85,120.02 169.91,120.02 169.84,120.1 169.82,120.15 169.84,120.2 169.91,120.37 169.82,120.52 169.82,120.85 170.19,120.85 170.39,120.65 171.09,120.65 171.12,120.64 171.15,120.64
GND on IN1: 58.59,125.59 56.47,127.71 56.47,129.91 58.76,132.2 58.76,134.19 58.44,134.5 58.39,134.5 58.39,134.58 58.42,134.58 58.49,135.23 58.21,134.64 58.24,134.55 58.16,134.5 57.88,134.5 57.8,134.55 57.83,134.64 57.64,135.24 57.45,134.64 57.47,134.55 57.4,134.5 57.17,134.5 56.94,134.27 56.09,134.27 55.23,135.14 53.07,135.14 53.06,135.16 52.75,135.38 52.44,135.16 52.43,135.14 51.37,135.14 51.09,134.85 51.01,134.84 50.96,134.91 50.96,136.53 52.39,137.96 55.52,137.96 56.75,136.73 57.27,136.73 57.47,136.94 57.87,136.94 59.7,135.11 62.41,135.11 62.78,134.74 62.78,134.25 64.73,132.3 64.73,132.04 59.71,127.02 59.63,127.01 59.58,127.07 59.19,127.2 59.32,126.81 59.38,126.76 59.36,126.68 59.22,126.54 59.22,125.92 58.9,125.59
GND on IN1: outline of 102 points within 147.49,120.82 163.24,129.02
GND on IN1: 115.5,86.98 115.4,87.17 115.45,87.38 115.38,87.53 115.35,87.58 115.37,87.64 115.62,87.89 116.85,87.89 116.92,87.84 116.91,87.76 117.15,87.21 117.4,87.76 117.38,87.84 117.45,87.89 118.74,87.89 118.8,87.86 118.82,87.8 118.98,87.53 119.26,87.67 119.31,87.71 119.38,87.69 119.83,87.24 121.03,87.24 121.44,87.64 121.44,88.05 121.53,88.14 121.61,88.14 121.64,88.12 121.63,88.08 121.58,87.85 121.75,87.69 121.81,87.64 121.79,87.57 121.41,87.19 121.41,87.03 121.09,86.7 116.11,86.7 116.05,86.74 116.04,86.81 115.83,87.13 115.62,86.81 115.61,86.74 115.55,86.7 115.52,86.7 115.46,86.75 115.46,86.82 ; 2 cut-outs
GND on IN1: 142.33,132.38 142.26,132.43 142.27,132.51 142.48,132.71 142.48,134.97 142.81,135.3 143.93,135.3 144.18,135.56 146.15,135.56 146.64,135.07 149.02,135.07 149.46,134.62 149.46,134.48 149.47,134.44 149.44,134.42 149.42,134.42 148.07,133.07 144.96,133.07 144.28,132.38
GND on IN1: 92.95,90.88 89.96,87.89 63.74,87.89 63.15,87.3 62.75,87.3 62.68,87.35 62.69,87.43 64.43,89.17 75.86,89.17 76.62,89.93 91.84,89.93 92.84,90.93 92.91,90.92
GND on IN1: 38.35,84.94 38.26,84.93 38.22,85 38.22,87.98 41.23,90.98 41.4,91.16 42.84,91.16 44.25,92.57 44.99,92.57 45.29,92.26 45.29,88.07 43.4,86.17 39.58,86.17
GND on IN1: outline of 112 points within 13.92,95.08 31.18,103.94
GND on IN1: 62.08,94.01 57.77,94.01 56.62,92.87 51.16,92.87 50.78,92.49 50.78,88.93 51.16,88.55 59.67,88.55 60.43,89.31 63.1,89.31 64.24,90.46 64.24,91.85
GND on IN1: 133.97,86.28 133.53,86.72 133.53,88.46 134.58,89.5 137.23,89.5 137.35,89.39 137.35,88.23 135.39,86.28
GND on IN1: outline of 220 points within 59.99,93.35 94.81,114.45
GND on IN1: 42.52,126.33 42.43,126.32 42.39,126.39 42.39,128.42 42.4,128.43 42.4,129.65 42.96,130.21 42.96,130.97 43.91,131.93 43.91,134.23 42.43,135.71 41.93,135.71 41.93,135.2 43.2,133.93 43.2,132.22 42.28,131.31 42.28,129.7 42.24,129.63 42.15,129.65 41.42,130.38 41.42,138.04 42.23,138.86 42.23,140.44 42.99,141.19 44.16,141.19 44.18,141.21 44.28,141.21 46.72,141.21 47.69,140.24 47.69,139.91 47.73,139.87 47.73,138.67 46.79,137.73 46.79,136.41 46.41,136.03 46.41,133.03 46.18,132.8 46.18,131.02 45.27,130.11 45.27,129.75 43.54,128.02 43.54,127.36
GND on IN1: 18.15,46.44 18.11,46.51 18.11,46.85 18.66,47.39 18.66,49.44 18.78,49.56 19.41,49.56 20.24,50.4 23.58,50.4 23.87,50.69 24.3,50.69 25.05,51.44 25.88,51.44 25.94,51.38 26.02,51.36 26.08,51.3 26.06,51.23 25.96,51.12 25.91,51.12 25.9,51.13 25.67,51.17 25.54,50.99 25.54,50.97 25.5,50.93 25.47,50.97 25.47,50.99 25.1,51.13 25.24,50.76 25.26,50.76 25.49,50.53 25.49,47.56 24.83,46.9 21.67,46.9 21.61,46.93 21.6,47 21.38,47.3 21.16,47 21.15,46.93 21.09,46.9 18.79,46.9 18.37,46.48 18.35,46.48 18.29,46.47 18.23,46.44
GND on IN1: 44.38,93.96 44.49,93.94 44.5,93.94 44.52,93.92 46.63,93.92 46.81,94.1 46.89,94.12 46.94,94.06 47.19,93.87 47.39,94.1 47.39,94.12 47.88,94.6 49.9,94.6 50.2,94.3 52.09,94.3 53.85,96.05 62.65,96.05 64.73,93.97 75.96,93.97 77.08,92.85 80.01,92.85 80.39,93.23 86.89,93.23 88.9,95.24 88.9,97.53 90.71,99.34 90.8,99.36 90.84,99.28 90.84,95.67 87.65,92.48 76.52,92.48 75.8,91.76 66.29,91.76 62.13,95.91 54,95.91 52.09,94.01 49.81,94.01 49.37,93.58 45.9,93.58 45.66,93.82 44.85,93.82 43.26,92.22 42.75,92.22 42.41,91.88 40.84,91.88 37.15,88.2 37.15,87.47 37.12,87.44 37.12,86 36.6,85.48 36.6,84.55 34.12,82.06 34.12,77.22 33.03,76.14 33.03,74.65 32.35,73.96 32.35,72.85 32.98,72.22 32.98,65.16 32.89,65.07 32.67,65.07 32.16,65.58 32.16,74.32 32.86,75.02 32.86,76.35 33.84,77.34 33.84,82.25 35.41,83.82 35.41,86.12 36.69,87.4 36.69,88.33 41.19,92.83 41.79,92.83 43.02,94.06 43.83,94.06 43.85,94.04 44.18,94.04 44.24,94.07 44.29,94.03 ; 3 cut-outs
GND on IN1: outline of 711 points within 6.75,0.25 256.25,150.65 ; 6 cut-outs
GND on IN1: 128.82,103.52 129.42,103.52 129.44,103.5 129.44,103.09 129.42,103.07 129.42,101.95 129.45,101.91 129.81,101.91 129.94,102.04 131.05,102.04 131.28,101.81 131.28,100.86 131.32,100.82 131.32,100.4 131.28,100.36 128.24,100.36 128.15,100.45 128.15,100.67 128.22,100.74 128.69,100.74 128.77,100.82 128.77,103.47
GND on IN1: outline of 121 points within 66.95,100.9 83.97,108.09 ; 1 cut-out
GND on IN1: 125.83,104.78 126.14,104.78 126.18,104.82 126.18,107.8 126.14,107.84 125.83,107.84 125.8,107.8 125.8,104.82
GND on IN1: 146.64,100.03 146.66,99.9 146.74,99.8 146.77,99.74 146.75,99.67 146.61,99.54 146.61,97.4 146.61,97.39 143.12,97.39 142.72,97.79 142.72,98.89 141.99,99.61 141.99,100.13 141.87,100.25 141.85,100.34 141.92,100.38 142.07,100.38 142.18,100.32 142.32,100.34 142.32,100.34 145.14,100.34 145.14,100.34 146.19,100.34 146.19,100.34 146.44,100.09 146.58,100.09
GND on IN1: 144.14,119.65 144.2,119.36 144.5,119.38 144.52,119.39 144.54,119.39 145,119.85 145.46,119.85 145.5,119.81 145.52,119.74 145.47,119.69 145.3,119.43 145.52,119.24 145.55,119.24 145.68,119.1 147.53,119.1 147.75,118.88 147.75,118.65 144.04,118.65 143.26,117.87 143.26,117.58 143.38,117.46 143.83,117.46 143.98,117.31 143.98,116.88 143.98,116.83 143.95,116.78 143.93,116.75 141.64,116.75 141.53,116.64 141.41,116.64 141.41,116.72 141.43,116.73 141.52,116.84 141.53,116.97 141.55,117.03 141.61,117.06 141.75,117.06 142.09,117.4 142.09,119.58 142.69,120.19 142.76,120.21 142.81,120.17 142.9,120.09 143.01,120.06 143.29,119.78 144.01,119.78
GND on IN1: 88.75,126.72 88.68,126.77 88.7,126.85 90.04,128.2 92.02,128.2 93.15,127.07 94.1,127.07 94.17,127.02 94.15,126.93 93.59,126.37 89.88,126.37 89.53,126.72
GND on IN1: 165.33,96.8 165.33,97.57 165.74,97.97 176.03,97.97 176.27,97.73 179.46,97.73 179.88,97.31 180.64,97.31 181.06,97.73 185.83,97.73 186.36,98.27 189.04,98.27 189.1,98.21 189.1,97.72 189.03,97.66 187.98,97.66 186.94,96.62 186.22,96.62 185.73,96.13 178.23,96.13 177.08,94.98 177.08,93.64 176.61,93.16 168.97,93.16
GND on IN1: 123.31,90.07 123.22,90.05 123.18,90.12 123.18,90.55 124.26,91.63 124.26,93.48 124.17,93.56 124.15,93.63 124.19,93.68 124.25,94.05 123.88,93.99 123.83,93.95 123.76,93.97 123.7,94.03 123.7,94.07 123.73,94.13 123.79,94.14 123.99,94.2 124.06,94.39 124.06,95.15 124.76,95.85 125.14,95.85 126.19,96.9 126.25,96.92 126.3,96.89 126.33,96.87 126.36,96.81 126.33,96.75 124.94,95.36 124.94,95.15 124.92,95.13 124.88,95.06 124.88,95.03 124.88,94.3 124.41,93.83 124.41,92.86 124.7,92.57 124.81,92.57 124.82,92.55 125.15,92.45 125.2,92.79 125.19,92.82 125.2,92.85 125.23,93.1 125,93.23 124.94,93.24 124.92,93.3 124.92,93.62 125.39,94.09 125.39,95.03 125.37,95.1 125.32,95.15 125.32,95.2 125.51,95.39 125.59,95.4 125.64,95.33 125.64,95.15 125.62,95.13 125.58,95.06 125.57,95.03 125.57,92.43 125.54,92.36 125.48,92.35 125.19,92.2 125.33,91.92 125.38,91.86 125.36,91.79 123.78,90.21 123.45,90.21
GND on IN1: outline of 409 points within 1.55,39.53 37.89,111.65 ; 2 cut-outs
GND on IN1: 7.07,28.15 8.56,28.15 9.56,27.14 12.14,27.14 12.86,26.42 12.86,21.73 12.25,21.12 7.78,21.12 6.81,22.08 6.81,27.9
GND on IN1: 167.93,105.2 168.01,105.18 169.49,103.69 169.51,103.61 169.44,103.56 168.56,103.56 167.96,104.17 165.15,104.17 164.98,104 164.21,104 164.14,104.04 164.14,104.11 164.01,104.41 163.71,104.29 163.66,104.24 163.59,104.26 163.41,104.43 162.54,104.43 162.11,104 158.3,104 156.73,105.56 154.09,105.56 153.92,105.73 153.92,108.79 152.07,110.65 152.05,110.74 152.12,110.78 152.18,110.78 153.01,109.95 161.59,109.95 162.84,108.7 162.84,107.61 164.03,106.41 165.35,106.41 166.06,105.7 167.48,105.7 167.51,105.68 167.53,105.6 167.48,105.55 167.32,104.99 167.88,105.15
GND on IN1: outline of 95 points within 189.53,136.97 206.16,146.39
GND on IN1: 110.06,86.79 109,87.85 105.79,87.85 104.95,88.69 103.73,88.69 103.31,89.12 102.02,89.12 99.17,91.97 99.17,93.08 99.19,93.09 99.28,93.17 99.31,93.29 99.36,93.36 99.44,93.34 102.56,90.22 102.85,90.22 103,90.07 103.02,89.99 102.96,89.94 102.74,89.49 103.22,89.34 103.26,89.34 103.28,89.31 103.28,89.28 103.77,88.8 105.23,88.8 106.07,87.95 109.76,87.95 110.22,87.49 112.28,87.49 112.82,88.03 113.89,88.03 114.28,87.64 114.3,87.58 114.28,87.53 114.27,87.52 114.24,87.51 114.22,87.52 114.03,87.59 113.8,87.45 113.74,87.47 113.45,87.76 112.78,87.76 111.82,86.79
GND on IN1: 190.07,91.35 189.14,91.35 188.81,91.01 188.7,90.73 188.89,90.41 188.87,90.35 187.22,88.7 178.54,88.7 178.45,88.79 178.45,89.01 181.45,92.02 181.64,92.02 181.81,91.96 181.96,92.03 182.79,92.03 182.9,91.91 183.01,92.01 187.06,92.01 191.1,96.06 191.1,94.56 191.5,94.17 191.5,92.78
GND on IN1: 95.87,134.53 99.2,134.53 99.71,134.02 101.48,134.02 101.5,133.99 101.5,133.24 100.32,132.06 100.2,132.06 100.14,131.99 99.69,131.99 99.26,131.56 95.12,131.56 94.76,131.92 94.76,133.42
GND on IN1: 143.37,120.24 143.28,120.22 143.24,120.29 143.22,120.37 143.19,120.43 143.17,120.5 143.2,120.57 144.32,121.7 144.32,124.13 144.38,124.19 144.38,127.66 144.44,127.66 144.5,127.63 144.52,127.57 144.52,127.47 144.55,127.39 144.56,127.38 144.56,127.07 145,127.07 145,121 144.38,120.38 144.16,120.59 143.92,120.59 143.59,120.27 143.59,120.24 ; 1 cut-out
GND on IN1: outline of 345 points within 98.4,105.31 144.1,130.54 ; 2 cut-outs
GND on IN1: 188.89,141.21 188.84,141.14 188.76,141.16 188.27,141.65 188.27,143.1 188.31,143.16 188.39,143.16 188.75,143.34 188.39,143.52 188.31,143.52 188.27,143.58 188.27,146.58 188.48,146.8 189.14,146.8 189.21,146.75 189.19,146.67 188.89,146.36
GND on IN1: 83.93,137.09 92.59,137.09 92.73,136.95 92.73,136.67 92.22,136.16 89.49,136.16 89.48,136.15 84.23,136.15 83.75,136.63 83.75,136.91
GND on IN1: outline of 148 points within 76.97,113.87 97.8,127.7
GND on IN1: 101.32,126.77 99.47,124.93 99.39,124.91 99.34,124.98 99.34,126.13 100.33,127.13 101.25,127.13 101.25,127.13 101.69,127.13 103.16,128.6 103.16,129.78 103.28,129.9 107.38,129.9 108.05,130.58 108.05,130.95 108.08,130.97 108.1,131 108.15,131.03 108.22,131.01 109.13,130.1 109.15,130.01 109.08,129.97 108.86,129.65 109.24,129.58 109.32,129.6 109.37,129.53 109.37,129.4 110.08,128.69 110.08,127.56 109.87,127.35 108.95,127.35 108.37,126.77
GND on IN1: 189.35,138.92 189.31,138.94 189.32,138.99 189.37,139.04 189.37,145.75 189.41,145.81 189.48,145.81 189.51,145.8 189.56,145.79 192.99,142.35 193.65,142.35 193.68,142.33 193.7,142.3 193.68,142.27 193.57,142.13 193.63,141.96 193.65,141.91 193.62,141.85 193.57,141.77 193.56,141.67 193.54,141.61 193.48,141.59 191.19,141.59 190.84,141.23 191.19,140.88 191.6,140.88 191.66,140.85 191.68,140.79 191.7,140.65 191.79,140.55 191.81,140.54 191.81,139.92 191.77,139.89 191.7,139.87 191.64,139.92 191.09,140.09 191.25,139.54 191.31,139.48 191.29,139.41 191.09,139.21 190.89,139.21 190.63,139.25 190.53,139.01 190.51,138.95 190.45,138.92
GND on IN1: 96.62,86.36 95.81,85.56 95.74,85.54 95.69,85.6 95.67,85.66 95.65,85.71 95.41,85.88 95.13,85.8 95.08,85.78 94.8,85.89 94.52,85.78 94.24,85.89 93.96,85.78 93.91,85.8 93.35,85.56 93.91,85.31 93.96,85.34 94.24,85.22 94.52,85.34 94.8,85.22 95.08,85.34 95.13,85.31 95.2,85.27 95.27,85.24 95.31,85.23 95.37,85.18 95.36,85.1 95.14,84.89 82.8,84.89 80.88,86.81 65.21,86.81 64.77,86.36 61.76,86.36 61.61,86.51 56.68,86.51 56.21,86.98 51.34,86.98 51.29,87.03 51.27,87.11 51.34,87.16 56.44,87.16 56.79,86.81 63.33,86.81 63.51,86.98 63.94,87.41 90.16,87.41 93.75,91 94.21,91.45 94.21,93.58 93.75,94.03 93.75,96.8 94.42,97.47 94.5,97.48 94.55,97.42 94.55,92.44 94.98,92 94.98,87.85 93,85.87 92.98,85.87 92.66,85.32 93.21,85.64 93.21,85.66 95.28,87.73 95.28,89.51 95.32,89.57 95.4,89.56 98.54,86.42 98.56,86.36 98.52,86.31 98.49,86.28 98.46,86.24 98.4,86.21 98.34,86.23 98.21,86.36
GND on IN1: 125.83,100.87 126.14,100.87 126.18,100.91 126.18,103.89 126.14,103.93 125.83,103.93 125.8,103.89 125.8,100.91
GND on GND1: outline of 273 points within 0.25,0.25 256.25,150.65 ; 16 cut-outs
GND on IN2: 170.71,113.36 173.78,116.44 173.78,116.47 173.83,116.54 173.91,116.53 173.95,116.49 174,116.47 174.05,116.41 174.02,116.34 173.89,116.2 173.8,116.2 170.78,113.19 166.68,113.19 165.46,114.4 162.1,114.4 161.49,113.79 158.89,113.79 158.54,114.15 154.73,114.15 151.58,117.29 151.07,117.29 148.91,119.46 147.23,119.46 147.16,119.49 147.15,119.56 147.17,119.67 147.15,119.78 147.16,119.85 147.23,119.88 147.56,119.88 148.25,120.57 149.25,120.57 151.2,118.61 161.03,118.61 161.99,119.57 162.04,119.57 162.07,119.55 162.07,119.52 162.22,119.03 162.67,119.27 162.73,119.32 162.8,119.3 162.98,119.12 163.35,119.12 164.78,117.69 164.78,116.43 164.89,116.33 164.89,116.13 166.27,114.75 166.27,113.85 166.75,113.36 ; 1 cut-out
GND on IN2: 65.19,90.38 74.67,90.38 75.14,89.91 76.27,89.91 76.52,89.66 76.52,89.25 76.23,88.96 66.2,88.96 65.05,90.1 65.05,90.24
GND on IN2: 7,0.25 6.83,0.33 6.75,0.5 6.75,3.85 6.81,4 6.95,4.09 8.94,6.2 7.53,8.73 9.29,10.48 9.29,10.48 12.82,14.02 12.81,14.02 14.68,15.88 14.68,21.24 15.09,21.66 16.02,21.66 17.26,20.42 17.26,19.91 17.79,19.38 18.85,19.38 19.08,19.62 19.1,19.62 19.21,19.64 19.29,19.71 19.52,19.71 19.52,19.71 19.87,19.36 19.87,19.35 19.9,19.23 19.98,19.14 20.01,19.09 19.99,19.02 18.5,17.53 18.5,15.95 18.5,15.91 16.39,15.91 16.24,15.76 16.24,13.75 16.03,13.54 16.03,10.6 16.09,10.41 16.24,10.28 16.24,0.25 11.54,0.25
GND on IN2: 50.68,118.03 49.36,119.35 49.36,130.25 48.34,131.27 48.34,134.23 50.34,136.23 55.83,136.23 56.22,136.62 56.22,137.41 58.95,140.14 61.28,140.14 62.39,139.02 62.77,139.02 62.8,139.02 62.84,139.03 64.95,139.03 65.46,138.51 69.61,138.51 70.57,137.56 71.88,137.56 73.24,136.19 73.24,136.02 72.55,135.33 71.96,135.33 71.27,136.03 67.12,136.03 66.93,135.84 66.93,135 66.93,134.99 66.91,134.87 66.93,134.75 66.93,134.74 66.93,134.34 66.9,134.23 66.9,134.12 66.91,134.1 61.17,128.36 61.17,127.66 56.58,123.07 53.88,123.07 51.89,121.08 51.89,118.22 51.7,118.03
GND on IN2: outline of 252 points within 70.77,98.11 107.41,126.32
GND on IN2: outline of 234 points within 140.65,113.65 230.75,138.16 ; 1 cut-out
GND on IN2: 194.3,143.09 191.69,143.09 189.76,141.16 189.76,139.21 190.07,138.9 190.62,138.9 191.62,139.9 192.25,139.9 194.53,142.18 194.53,142.86
GND on IN2: 82.13,127.01 84.02,128.91 86.24,128.91 86.25,128.83 86.19,128.79 85.99,128.27 86.51,128.47 86.55,128.54 86.64,128.52 86.93,128.23 91.76,128.23 93.4,126.58 93.4,126.49 93.04,126.12 90.3,126.12 89.64,126.78 82.13,126.78
GND on IN2: 163.75,106.22 163.04,105.51 162.42,105.51 161.76,104.85 159.21,104.85 158.84,105.23 158.82,105.31 158.89,105.36 159.35,105.36 159.56,105.56 159.56,106.39 159.64,106.47 163.75,106.47 163.87,106.35 163.88,106.27 163.81,106.22
GND on IN2: 195.1,118.36 195.1,119.7 196.81,121.41 196.81,121.59 196.84,121.66 196.91,121.67 196.98,121.65 197.05,121.65 197.3,121.87 197.21,122.18 197.1,122.24 196.98,122.26 196.91,122.3 196.92,122.39 200.16,125.62 206.84,125.62 208.5,123.97 208.51,123.99 211.94,123.99 212.45,123.48 213.47,123.48 213.86,123.09 213.86,122.95 213.88,122.9 213.86,122.85 213.84,122.83 212.7,122.83 209.76,119.9 208.8,119.9 208.25,119.35 202.49,119.35 201.82,118.68 198.98,118.68 195.84,115.55 195.84,115.19 194.16,113.5 192.12,113.5 191.73,113.89 191.73,115 ; 2 cut-outs
GND on IN2: outline of 604 points within 17.37,31.09 102.2,129.38 ; 1 cut-out
GND on IN2: 109.47,88.88 109.25,89.1 108.17,89.1 107.42,89.85 106.04,89.85 105.34,89.15 102.6,89.15 102.3,89.44 88.35,89.44 87.14,90.65 75.4,90.65 74.96,91.09 65.72,91.09 60.72,96.09 51.82,96.09 50.82,97.09 46.68,97.09 46.68,97.65 47.58,97.65 47.72,97.42 47.98,97.47 48,97.48 48.03,97.47 48.32,97.44 48.41,97.72 48.41,97.79 48.48,97.83 51.14,97.83 51.52,97.45 60.25,97.45 65.08,92.62 74.6,92.62 75.9,91.32 88.14,91.32 89.35,90.11 101.64,90.11 102.02,90.48 107.88,90.48 108.71,89.65 112.55,89.65 112.84,89.37 114,89.37 114.41,89.78 116.07,89.78 116.65,90.36 116.71,90.38 116.77,90.34 116.96,90.17 117.27,90.21 117.32,90.16 117.34,90.12 117.35,90.1 117.34,90.07 117.31,90.06 116.83,90.06 116.25,89.48 114.64,89.48 114.29,89.14 112.75,89.14 112.56,89.32 110.76,89.32 110.33,88.88
GND on IN2: 127.65,81.81 127.45,81.9 127.27,81.77 126.78,81.77 126.47,81.47 126.13,81.47 125.64,80.97 109.76,80.97 109.5,80.71 109.3,80.71 109.23,80.75 109.24,80.83 109,81.33 108.76,80.83 108.76,80.75 108.7,80.71 51.45,80.71 50.87,81.29 50.85,81.38 50.92,81.42 51.17,81.42 51.5,81.09 104.7,81.09 105.3,81.69 110.32,81.69 110.62,81.39 120.8,81.39 121.64,82.23 126.14,82.23 130.81,86.89 132.65,86.89 136.83,91.07 136.83,91.4 137.07,91.64 137.07,93.26 137.11,93.32 137.19,93.31 137.26,93.27 137.35,93.25 137.41,93.25 137.47,93.27 137.54,93.26 137.57,93.2 137.57,91.02 138,90.58 138,90.36 137.7,90.05 137.7,87.84 135.6,85.75 133.48,85.75 129.55,81.81
GND on IN2: outline of 195 points within 147.19,120.81 162.35,128.24
GND on IN2: 168.85,109.82 167.46,111.22 167.46,111.74 167.51,111.8 171.36,111.8 173.02,113.46 173.02,113.46 173.6,114.04 174.17,114.04 174.19,114.04 175.07,114.04 176.98,115.95 176.98,116.2 179.6,118.81 183.18,118.81 184.17,117.82 190.01,117.82 191.49,119.3 191.49,119.65 191.53,119.72 191.61,119.71 192.06,119.79 191.92,120.23 191.88,120.28 191.9,120.35 192.01,120.47 192.1,120.49 192.14,120.42 192.19,120.27 192.31,120.16 192.31,119.9 187.1,114.7 187.1,111.26 187.05,111.21 185.96,110.12 173.54,110.12 173.33,109.9 171.91,109.9 171.83,109.82
GND on IN2: 22.57,87.05 22.12,87.05 20.12,85.06 20.12,80.27 20.5,79.89 20.85,79.89 22.71,81.76 22.71,86.91
GND on IN2: outline of 1075 points within 1.55,16.41 256.25,150.65 ; 8 cut-outs
GND on IN2: outline of 235 points within 21.99,36.22 134.54,96.05 ; 1 cut-out
GND on IN2: outline of 112 points within 73.55,96.97 99.01,115.64
GND on IN2: 190.16,144 190.09,143.98 190.03,144.03 189.93,144.18 189.76,144.25 189.7,144.3 189.71,144.38 190.63,145.3 191.21,145.3 192.75,146.83 196.95,146.83 197.06,146.72 199.96,146.72 201.46,148.23 203.52,148.23 204.1,148.81 214.46,148.81 214.53,148.76 214.51,148.68 210.59,144.75 209.9,144.75 209.84,144.79 209.83,144.86 209.83,144.93 209.68,145.08 205.49,145.08 204.73,145.84 200.62,145.84 200.5,145.73 196.5,145.73 196.12,146.11 196,146.1 195.9,146.04 192.2,146.04
GND on IN2: 14.76,80.33 14.8,80.4 14.89,80.38 16.82,78.45 16.82,72.31 7.37,62.86 7.37,61.1 7.35,61.07 7.31,61.07 7.29,61.08 7.29,67.11 13.26,73.08 13.26,77.89 14.76,79.38
GND on GND2: outline of 260 points within 0.25,0.25 256.25,150.65 ; 8 cut-outs
GND on GND3: outline of 253 points within 0.25,0.25 256.25,150.65 ; 150 cut-outs
GND on IN3: 39.4,107.23 40.18,107.23 40.75,106.66 40.75,104.21 40.66,104.12 40.34,104.12 39.47,104.99 39.03,104.99 38.9,105.12 38.9,106.73
GND on IN3: outline of 307 points within 20.81,16.44 256.25,150.65 ; 10 cut-outs
GND on IN3: 7.09,32.93 6.97,33.05 6.97,34.96 5.57,36.36 5.57,37.85 6.6,37.85 9.05,40.3 6.6,42.75 4.25,42.75 4.08,42.83 4,43 4,58.19 3.78,58.72 3.25,58.94 3.18,58.94 3.01,59.02 2.93,59.19 2.93,59.55 2.71,60.08 2.18,60.3 1.8,60.3 1.63,60.38 1.55,60.55 1.55,61.25 1.55,99.71 1.63,99.88 1.8,99.96 2.1,99.96 2.63,100.18 2.86,100.71 2.86,111.4 2.93,111.57 3.1,111.65 12.4,111.65 12.57,111.57 12.64,111.4 12.64,107.08 12.61,106.95 12.52,106.86 12.36,105.68 13.55,105.83 13.59,105.88 13.63,105.92 13.63,102.9 8.97,98.24 8.97,92.65 8.2,91.88 4.51,91.88 3.64,91 3.64,84.88 7.97,80.55 13.86,80.55 18.99,75.42 18.99,67.95 18.41,67.37 15.18,67.37 10.74,62.92 6.43,62.92 5.49,61.98 5.49,58.81 7.12,57.18 7.12,53.7 4.81,51.39 4.81,48.17 5.31,47.67 5.31,46.51 10.01,41.81 10.01,34.45 8.49,32.93
GND on IN3: 27.64,97.07 36.33,97.07 36.7,97.45 37.35,97.45 37.47,97.32 37.47,92.85 36.73,92.11 31.09,92.11 27.35,95.86 27.35,96.78
GND on IN3: 7,0.25 6.83,0.33 6.75,0.5 6.75,3.85 6.81,4 6.95,4.09 8.2,4.73 8.89,5.96 8.75,7.48 7.73,8.63 7.73,12.35 6.97,13.11 6.97,13.75 7.22,14 10.15,14 10.37,14.22 13.41,14.22 14.73,15.54 14.73,21.06 15.11,21.45 18.18,21.45 19.58,20.05 19.58,16.65 18.94,16.01 16.97,16.01 16.44,15.48 16.44,0.25
GND on IN3: 95.36,134.91 99.77,134.91 99.95,134.72 99.95,133.49 99.5,133.04 96.94,133.04 95.36,134.63
GND on IN3: 75.55,88.91 65.22,88.91 64.42,89.71 64.42,90.24 64.54,90.35 74.8,90.35 75.73,89.42 75.73,89.1
GND on IN3: 22.63,100.96 21.62,100.96 21.04,100.38 21.04,99.91 17.93,96.79 17.93,96.02 18.61,95.33 19.74,95.33 22.43,98.03 22.43,100.05 22.69,100.3 22.69,100.9
GND on IN3: 195.05,123.86 199.88,123.86 201.15,122.59 201.15,121.06 200.64,120.56 197.97,120.56 197.34,121.19 195.43,121.19 194.8,121.83 194.8,123.6
GND on IN3: 116.38,130.86 119.83,130.86 120.57,130.11 120.57,128.78 120.44,128.64 117.09,128.64 116.25,129.48 116.25,130.73
GND on IN3: 111.18,136.45 107.51,136.45 107.35,136.28 107.35,135.94 107.91,135.38 110.99,135.38 111.29,135.67 111.29,136.35
GND on GND4: outline of 260 points within 0.25,0.25 256.25,150.65 ; 8 cut-outs
GND on VCC: 120,106.4 119.95,106.45 118.4,106.45 118.28,106.56 118.28,106.71 118.37,106.8 122.97,106.8 123.08,106.69 123.08,106.45 120.17,106.45 120.12,106.4
GND on VCC: 7,0.25 6.83,0.33 6.75,0.5 6.75,3.85 6.81,4 6.95,4.09 8.94,6.73 6.5,8.95 0.5,8.95 0.33,9.03 0.25,9.2 0.25,11.53 0.33,11.7 0.5,11.78 4.79,11.78 5.63,11.29 6.25,12.03 6.25,14.74 6.26,14.74 6.26,20.98 5.63,21.72 4.79,21.24 1.5,21.24 1.33,21.31 1.26,21.48 1.26,25.53 1.33,25.7 1.5,25.78 4.79,25.78 5.63,25.29 6.26,26.03 6.26,34.98 6.18,35.32 5.96,35.58 6.21,35.84 9.86,35.84 12.83,38.81 12.83,43.87 8.24,48.47 8.24,51.47 11.81,51.47 12.45,50.83 21.97,50.83 23.62,49.18 31.84,49.18 32.49,49.84 32.49,55.05 32.73,55.28 40.24,55.28 40.24,55.04 40.27,55.01 41,55.01 41,19.97 35.5,19.97 35.1,19.57 35.1,17.79 34.8,17.5 32.26,17.5 31.92,17.16 31.92,16.52 31.82,16.42 27.01,16.42 26.9,16.52 26.9,19.57 26.57,19.91 22.16,19.91 21.44,19.19 21.44,16.78 20.58,15.91 16.24,15.91 16.24,0.26 11.36,0.26 11.36,0.25 ; 3 cut-outs
GND on VCC: 119.01,100.83 118.92,100.92 118.92,101.02 119.03,101.14 122.92,101.14 123.07,101.29 123.14,101.29 123.23,101.2 123.23,101.08 122.99,100.83
GND on VCC: 118.35,105.2 118.28,105.27 118.28,105.49 118.32,105.53 123.09,105.53 123.11,105.52 123.11,105.22 123.09,105.2
GND on VCC: 10.98,104.42 10.98,104.44 11.39,104.44 11.39,109.75 9.67,111.46 3.99,111.46 3.99,104.63 4.21,104.42
GND on VCC: 118.37,103.96 118.31,104.02 118.31,104.25 118.37,104.31 123.09,104.31 123.11,104.3 123.11,103.96
GND on VCC: 125.85,99.97 125.85,104.33 125.8,104.38 125.8,108.62 125.94,108.62 126.14,108.42 127.1,108.42 127.1,107.8 127.23,107.67 127.44,107.67 127.48,107.63 127.48,107.55 127.3,107.37 127.3,107 127.37,106.93 127.37,106.33 127.27,106.23 127.27,105.93 127.37,105.82 127.37,105.52 127.22,105.37 127.22,104.4 127.37,104.25 127.37,104.1 127.25,103.97 127.25,103.61 127.4,103.46 127.4,102.93 127.27,102.8 127.27,102.5 127.43,102.34 127.43,101.76 127.35,101.69 127.35,100.25 127.01,100.25 126.97,100.29 126.97,104.4 126.92,104.45 126.92,104.55 126.99,104.63 126.99,106.56 126.92,106.64 126.92,106.76 126.99,106.84 126.99,107.53 126.83,107.69 126.4,107.69 126.21,107.5 126.21,100.19 125.99,99.97
GND on VCC: 124.11,100.68 123.89,100.9 123.89,101.05 123.92,101.07 123.92,101.76 123.84,101.84 123.84,101.94 123.89,101.99 123.89,102.17 123.77,102.29 123.77,102.37 123.92,102.52 123.92,102.93 123.84,103.01 123.84,103.05 123.89,103.11 123.89,103.29 123.82,103.36 123.82,103.49 123.89,103.56 123.89,104.38 123.82,104.45 123.82,104.53 123.92,104.63 123.92,105.17 123.84,105.24 123.84,105.39 123.89,105.44 123.89,106.18 123.77,106.31 123.77,106.43 123.82,106.48 123.82,106.86 123.89,106.94 123.89,107.22 123.74,107.37 123.74,107.51 124.12,107.89 124.12,108.42 124.38,108.42 124.38,107.58 124.25,107.45 124.25,107.22 124.35,107.12 124.35,105.95 124.33,105.93 124.33,105.01 124.28,104.96 124.28,104.48 124.43,104.32 124.43,104.23 124.35,104.15 124.35,101.4 124.45,101.3 124.45,100.68
GND on VCC: 118.4,107.62 118.31,107.71 118.31,107.88 118.4,107.97 123.04,107.97 123.11,107.91 123.11,107.62
GND on VCC: 118.4,102.1 118.33,102.17 118.33,102.34 118.4,102.41 123.14,102.41 123.16,102.39 123.16,102.12 123.14,102.1
GNDA_CHG on TOP: 54.34,122.97 54.08,122.72 53.32,122.72 53.07,122.97 53.07,124.05 53.17,124.15 54.26,124.15 54.34,124.07
GNDA_CHG on IN1: 55.16,135.03 51.42,135.03 49.89,133.51 49.89,124.13 52.58,124.13 52.94,123.77 57.93,123.77 58.65,124.49 58.65,125.38 56.37,127.67 56.37,129.95 58.65,132.24 58.65,134.15 58.4,134.4 57.26,134.4 57,134.15 56.05,134.15
VCC0V9_CIO on TOP (solid shape): 26.73,35.35 26.73,34.64 26.85,34.51 26.85,34.07 27.02,33.91 27.04,33.88 27.11,33.82 27.11,33.6 27.1,33.59 27.02,33.53 26.98,33.44 26.98,33.42 26.93,33.38 26.91,33.38 26.78,33.37 26.67,33.3 26.6,33.28 26.53,33.31 26.47,33.37 26.47,33.51 26.55,33.71 26.48,33.91 26.47,33.92 26.47,33.94 26.03,34.39 26.03,34.5 26.13,34.69 26.03,34.88 26.03,35.15 26.1,35.21 26.13,35.3 26.13,35.32 26.28,35.46 26.62,35.46
VCC0V9_DP on TOP (solid shape): 28,36.04 28,35.94 27.85,35.8 27.85,35.55 28,35.4 28,35.28 27.86,35.01 28,34.75 28,34.63 27.94,34.58 27.9,34.51 27.11,34.51 26.98,34.64 26.98,35.46 27.3,35.78 27.31,35.79 27.37,35.83 27.41,35.89 27.41,35.89 27.45,35.93 27.62,35.93 27.79,36.1 27.93,36.1
VCC0V9_DP on TOP (solid shape): 25.4,33.5 25.58,33.5 25.67,33.41 25.67,33.39 25.72,33.26 25.82,33.18 25.84,33.17 25.84,33.11 25.69,32.96 25.63,32.87 25.6,32.77 25.6,32.75 25.4,32.56 25.23,32.56 24.97,32.74 24.68,32.63 24.6,32.6 24.53,32.63 24.47,32.69 24.39,32.72 24.38,32.73 24.28,32.83 24.25,32.83 24.23,32.86 24.21,32.91 24.17,32.96 24.06,33.07 24.06,33.14 24.21,33.3 24.26,33.3 24.51,33.55 25.35,33.55
VCC0V9_DP on IN3: 29.09,36.11 29.01,36.02 27.18,36.02 26.8,35.64 25.16,35.64 24.66,35.14 24.66,34.55 23.95,33.84 23.95,33.04 24.3,32.69 29.96,32.69 30.2,32.92 30.2,34.99 29.93,35.26 29.93,35.96 29.78,36.11 ; 1 cut-out
VCC0V9_LVR_OUT on IN1 (solid shape): 23.93,37.9 24,37.87 24,37.79 23.95,37.55 24.08,37.35 24.11,37.29 23.95,36.96 24.11,36.64 24.08,36.58 24.05,36.55 24.01,36.51 23.95,36.48 23.89,36.51 23.4,36.55 23.43,36.05 23.46,35.99 23.43,35.93 23.4,35.43 23.89,35.47 23.95,35.5 24.01,35.47 24.21,35.34 24.43,35.37 24.51,35.37 24.54,35.3 24.54,34.91 24.47,34.83 23,34.83 22.69,35.14 22.69,37.79 22.8,37.9
VCC0V9_LVR_OUT on TOP: 23.11,45.65 24.53,45.65 24.6,45.59 24.6,44.47 24.5,44.38 23.5,44.38 22.98,44.89 22.98,45.52
VCC0V9_LVR_OUT on BOTTOM: 20.71,42.21 21.93,43.42 21.93,44.71 22.6,45.39 24.14,45.39 24.55,44.97 24.55,43.75 24.35,43.55 24.35,42.92 22.19,40.76 22.19,38.73 23.09,37.83 23.78,37.83 23.86,37.74 23.86,37.46 23.81,37.4 22.96,37.4 22.86,37.31 21.38,37.31 20.71,37.98
VCC0V9_PCIE on TOP (solid shape): 24.93,38.51 25,38.51 25.16,38.35 25.35,38.35 25.5,38.49 25.55,38.49 25.81,38.75 25.94,38.75 25.99,38.68 26.06,38.63 26.06,37.9 25.98,37.83 25.92,37.73 25.92,37.72 25.88,37.69 25.84,37.69 25.46,37.31 25.46,36.62 25.43,36.61 25.25,36.32 25.41,36.03 25.42,35.97 25.39,35.91 25.33,35.85 24.93,35.85 24.86,35.88 24.83,35.95 24.82,36.06 24.76,36.16 24.76,36.47 24.83,36.64 24.76,36.81 24.76,36.86 24.69,36.93 24.66,37.01 24.71,37.08 24.82,37.23 24.8,37.41 24.74,37.48 24.65,37.51 24.64,37.52 24.6,37.55 24.61,37.58 24.58,37.75 24.46,37.89 24.46,37.99 24.61,38.27 24.46,38.54 24.43,38.56 24.43,38.62 24.46,38.64 24.52,38.69 24.57,38.75 24.69,38.75
VCC0V9_PCIE on BOTTOM: 24.73,36.06 24.6,36.2 24.6,36.22 24.61,36.31 24.6,36.41 24.6,36.87 24.61,36.96 24.6,37.06 24.6,37.52 24.61,37.61 24.6,37.71 24.6,38.14 24.62,38.26 24.6,38.38 24.6,38.82 24.61,38.91 24.6,39.01 24.6,39.28 24.67,39.35 24.67,40.84 24.72,40.89 25.96,40.89 25.99,40.86 25.99,39.9 25.83,39.74 25.83,37.8 25.21,37.18 25.21,36.14 25.14,36.06
VCC0V9_SVR on TOP (solid shape): 24.4,34.55 24.4,34.54 24.53,34.41 24.74,34.41 24.9,34.58 25.05,34.58 25.15,34.49 25.28,34.46 25.31,34.47 25.39,34.39 25.39,33.94 25.33,33.88 23.87,33.88 23.81,33.94 23.81,34.39 23.89,34.47 23.91,34.46 23.97,34.46 24.04,34.48 24.23,34.48 24.35,34.6
VCC0V9_SVR on TOP: 22.1,36.89 22.24,36.75 22.24,36.54 22.08,36.37 21.94,36.37 21.84,36.27 21.84,35.95 22.01,35.66 21.84,35.37 21.84,35.09 22,34.92 22.02,34.92 22.07,34.91 22.12,34.89 22.19,34.83 22.23,34.74 22.23,34.72 22.27,34.69 22.29,34.69 22.47,34.66 22.61,34.54 22.7,34.54 22.75,34.61 22.83,34.66 22.85,34.67 22.85,36.86 22.66,37.06 22.64,37.06 22.54,37.09 22.47,37.16 22.45,37.18 22.21,37.18 22.18,37.14 22.15,37.11 22.1,37.08
VCC0V9_SVR on TOP: 15.75,28.65 15.01,27.91 15.01,24.88 14.53,24.39 14.53,22.71 14.6,22.64 15.55,22.64 16.07,23.17 16.62,23.17 16.85,23.4 16.85,24.44 17.23,24.81 17.62,24.81 17.8,24.99 17.8,28.55 17.7,28.65
VCC0V9_SVR on BOTTOM: 23.23,35.57 22.9,35.23 22.9,34.87 22.69,34.67 22.45,34.67 22.44,34.67 22.33,34.7 22.21,34.67 22.21,34.67 21.8,34.67 21.79,34.67 21.55,34.67 21.37,34.49 21.37,34.48 21.35,34.46 21.35,34.35 21.29,34.29 21.22,34.29 21.21,34.28 19.62,34.28 19.52,34.38 19.52,35.85 19.6,35.93 21.16,35.93 21.21,35.88 21.21,35.46 21.34,35.32 21.86,35.32 21.86,35.33 21.92,35.33 22.07,35.48 22.07,37.05 22.21,37.19 22.57,37.19 22.75,37.01 22.75,36.2 22.82,36.13 23.2,36.13 23.23,36.1
VCC0V9_SVR on IN1: 15.36,27.61 16.36,27.61 17.69,26.27 17.69,24.23 17.46,23.99 15.75,23.99 15.06,24.68 15.06,27.31
VCC0V9_SVR on GND1: 16.32,26.37 17.9,26.37 18.67,25.59 18.67,24.81 18.55,24.68 18.16,24.68 18.07,24.59 17,24.59 16.18,25.41 16.18,26.23
VCC0V9_SVR on GND4: 19.09,26.64 18.93,26.81 17.6,26.81 17.13,26.33 17.13,24.99 17.53,24.59 18.23,24.59 19.09,25.44
VCC0V9_SVR on VCC: 18.16,30.5 18.85,31.19 19.72,31.19 20.11,31.58 20.11,32.67 20.62,32.67 20.82,32.88 20.82,37 20.99,37.17 22.62,37.17 22.63,37.17 24.25,37.17 24.25,36.36 24.81,36.36 24.81,37.17 26.46,37.17 26.83,36.79 26.83,35.94 27.44,35.34 28.31,35.34 28.56,35.1 28.56,31.29 23.36,26.09 19.16,26.09 18.79,25.72 17.9,25.72 17.58,26.03 17.58,27.44 18.16,28.02 ; 1 cut-out
VCC3V3_LC on TOP: 34,38.92 33.2,39.72 33.2,41.26 33.22,41.27 33.22,41.5 32.82,41.89 31.4,41.89 31.35,41.94 31.35,42.51 31.42,42.58 32.96,42.58 33.09,42.45 33.52,42.45 33.77,42.69 34.08,42.69 34.26,42.52 34.26,41.93 34.5,41.69 34.5,40.29 35.2,39.59 35.2,39.55 36.04,38.71 36.04,38.08 35.97,38 35.43,38 35.2,37.76 35.2,35.61 35.02,35.43 34.5,35.43 34.33,35.59 34.33,36.61 34,36.94
VCC3V3_SX_SYS_A on TOP: 9.21,51.11 8.52,50.42 8.42,50.35 8.35,50.25 8.27,50.17 8.27,50.11 8.11,49.94 7.46,49.94 7.33,50.07 7.33,50.9 7.51,51.07 8.53,51.07 8.86,51.41 9.56,51.41 9.61,51.35 9.61,51.24 9.48,51.11
VCC3V3_SX_SYS_B on TOP: 22.89,51.15 22.02,51.15 21.62,50.76 21.62,50.02 21.27,49.67 20.8,49.67 20.52,49.39 20.52,49.04 20.25,48.78 20.25,48.55 20.05,48.35 20.05,47.84 20.23,47.66 20.43,47.66 20.98,48.22 20.98,48.42 21.07,48.51 21.45,48.51 21.62,48.68 21.62,49.36 22.08,49.82 22.08,50.17 22.07,50.18 22.07,50.38 22.55,50.86 22.82,50.86 22.94,50.98 22.94,51.1
VCC3V3_TBTA_LDO on TOP (solid shape): 9.18,52.23 9.18,51.99 9.28,51.89 9.48,51.89 9.58,51.79 9.58,51.67 9.49,51.58 8.86,51.58 8.57,51.29 7.59,51.29 7.51,51.37 7.51,52.01 7.6,52.1 8.12,52.1 8.54,52.52 8.88,52.52
VCC3V3_TBTA_LDO on BOTTOM: 8.26,48.31 7.9,48.67 7.9,50.28 8.33,50.71 8.33,51.17 8.23,51.27 6.49,51.27 6.28,51.48 6.28,58.58 6.45,58.75 10.32,58.75 10.46,58.62 10.46,56.02 13.81,52.66 13.81,48.31
VCC3V3_TBTB_LDO on TOP: 22.83,51.33 22.92,51.42 22.92,51.64 22.86,51.7 22.55,51.7 22.44,51.81 22.44,52.1 22.18,52.36 21.7,52.36 21.57,52.23 21.57,51.6 21.44,51.47 20.94,51.47 20.81,51.34 20.81,50.07 20.94,49.94 21.32,49.94 21.44,50.07 21.44,50.83 21.95,51.34 22.08,51.34 22.09,51.33
VCC3V3_TBTB_LDO on IN3: 19.85,50.98 18.78,52.05 18.78,58.72 18.78,58.73 18.78,59.18 19.01,59.41 22.68,59.41 23.51,58.57 23.51,54.82 24,54.33 27.32,54.33 27.85,53.8 27.85,52.37 27.32,51.84 23.67,51.84 23.18,51.35 22.24,51.35 22.08,51.19 22.06,51.19 21.85,50.98
VCC5V0_SYS on TOP (solid shape): 34.5,57.63 34.5,56.63 34.04,56.17 31.29,56.17 30.98,55.86 30.98,55.16 30.18,54.36 29.15,54.36 28.85,54.07 28.85,53.33 28.34,52.82 27.68,52.82 27.6,52.89 27.6,55.12 28.29,55.81 28.96,55.81 29.65,56.49 29.65,57.5 30.02,57.88 34.25,57.88
VCC5V0_SYS on TOP (solid shape): 16.02,58.21 16.02,56.5 16.22,56.29 18.4,56.29 18.65,56.55 18.65,57.95 18.78,58.07 19.41,58.07 19.54,57.95 19.54,56.8 19.18,56.45 19.18,55.79 18.15,54.76 17.52,54.76 17.51,54.77 15.79,54.77 15.54,54.52 15.54,53.31 15.3,53.07 14.34,53.07 14.27,53.14 14.27,55.62 14.17,55.72 13.82,55.72 13.53,56.02 13.53,57.15 13.8,57.41 14.56,57.41 14.71,57.56 14.71,58.21 14.87,58.36 15.87,58.36
VCC5V0_SYS on IN1: 17.43,57.84 18.1,58.52 28.28,58.52 28.94,57.86 28.94,55.22 28.48,54.76 25.41,54.76 24.99,55.18 24.99,56.13 24.83,56.28 24.21,56.28 24,56.49 22.14,56.49 20.28,56.49 18.55,54.77 14.81,54.77 14.66,54.92 14.66,56.08 14.93,56.35 17.21,56.35 17.43,56.56
VCC5V0_SYS on IN2: 27.83,56.45 28.39,56.45 28.67,56.17 28.67,51.2 27.78,50.31 26.82,50.31 26.52,50.6 26.52,51.66 27.54,52.68 27.54,56.15
VCC5V0_SYS on IN3: 12.94,50.39 12.75,50.58 12.75,53.48 14.36,55.09 14.36,55.56 14.66,55.86 15.45,55.86 15.89,55.42 15.89,50.8 15.49,50.39
VIN12 on TOP: 168.38,117.51 167.75,116.87 166.73,116.87 166.6,117 166.6,117.76 166.73,117.89 167.11,117.89 167.49,118.27 167.49,119.79 167.62,119.92 168.13,119.92 168.26,119.79 168.26,118.91 168.51,118.65 169.27,118.65 169.4,118.52 169.4,117.76 169.14,117.51
VINTAB on TOP (solid shape): 117.81,83.35 117.81,81.19 115.5,78.88 92.79,78.88 91.85,79.81 91.85,82.89 92.03,83.07 96.15,83.07 98.41,80.81 113.26,80.81 114,81.54 114,83.37 114.02,83.39 117.76,83.39
VINTAB on TOP (solid shape): 76.59,142.17 76.59,139.66 76.38,139.45 73.54,139.45 72.97,140.03 72.97,140.34 72.39,140.92 72.39,140.93 72.03,140.93 71.94,141.02 71.94,142.01 72.21,142.27 76.49,142.27
VINTAB on TOP: 95.87,87.66 95.87,85.25 95.48,84.87 93.45,84.87 93.33,85 93.33,85.5 92.87,85.96 92.46,85.96 90.61,87.82 90.61,88.88 90.91,89.19 94.34,89.19
VINTAB on TOP: 116.08,87.03 117.57,87.03 117.8,86.8 117.8,85.82 117.74,85.76 114.05,85.76 114,85.81 114,86.74 113.9,86.84 113.9,87.66 114,87.77 115.79,87.77 115.86,87.7 115.86,87.26
VINTAB on BOTTOM: 91.42,85.25 88.5,88.17 88.5,94.14 91.8,97.44 91.8,101.13 93.58,102.9 93.58,122.46 92.82,123.22 85.45,123.22 83.42,125.26 80.5,125.26 75.86,129.89 75.86,133.07 72.38,136.55 72.38,138.39 72.12,138.65 72.12,142.53 72.5,142.91 74.53,142.91 75.04,142.4 75.04,140.11 75.93,139.23 75.93,137.45 79.36,134.02 79.36,131.86 82.91,128.3 92.44,128.3 97.39,123.35 97.39,101.04 95.94,99.58 95.94,96.37 91.42,91.85 91.42,90.33 93.83,87.92 94.85,87.92 95.74,87.03 95.74,85.63 95.36,85.25
VINTAB on GND1: 113.95,87.66 116.01,87.66 116.06,87.61 116.06,86.83 116.01,86.77 113.95,86.77 113.9,86.83 113.9,87.61
VINTAB on IN3: 115.93,81.69 114.28,81.69 114.03,81.95 114.03,82.84 114.87,83.68 114.87,86.19 114.71,86.34 114.26,86.34 114.14,86.46 114.14,86.53 113.9,86.77 113.9,87.54 113.94,87.57 113.94,87.7 114.26,88.02 115.93,88.02 116.39,87.56 116.39,82.15
VINTAB on IN3: 92.06,82.58 91.93,82.71 91.93,84.11 93.45,85.63 97.14,85.63 97.52,85.25 97.52,83.6 96.5,82.58
+BATT on TOP: 85.2,88.68 85.07,88.55 79.36,88.55 79.23,88.68 79.23,91.6 79.48,91.85 84.69,91.85 84.7,91.85 84.92,91.85 85.2,91.58
+BATT on TOP: 149.59,91.73 152.79,91.73 152.97,91.55 152.97,89.01 152.38,88.43 149.59,88.43 149.4,88.62 149.4,91.54
+BATT on VCC: 144,78.83 143.92,78.66 143.75,78.59 141.86,78.59 141.7,78.64 141.61,78.79 139.1,80.89 136.59,78.79 136.5,78.64 136.35,78.59 79.48,78.59 79.48,88.96 79.72,89.19 85.12,89.19 89.94,84.36 127.47,84.36 132.81,89.7 135.67,89.7 137.44,91.47 145.14,91.47 145.14,91.17 145.85,90.46 151.82,90.46 152.76,89.52 152.76,85.57 151.13,84.85 150.28,83.29 150.2,83.14 150.04,83.09 144.75,83.09 144.22,82.86 144,82.33
+DCIN on TOP (solid shape): 61.12,132.63 61.12,131.67 60.93,131.48 60.15,131.48 59.8,131.12 59.8,130.46 59.67,130.34 58.1,130.34 57.41,129.65 56.62,129.65 56.57,129.7 56.57,129.8 56.65,129.88 57,129.88 58.91,131.78 58.91,132.62 59.04,132.75 61,132.75
+INV_PWR_SRC on TOP: 183.17,101.57 182.99,101.75 182.99,102.7 183.22,102.93 184.36,102.93 184.83,102.46 184.83,101.75 184.65,101.57
+INV_PWR_SRC on TOP: 187.31,95.16 187.31,93.51 187.05,93.25 185.65,93.25 185.53,93.38 185.53,94.52 183.71,96.34 183.71,97.01 183.95,97.25 184.97,97.25 185.03,97.19 185.03,96.62 185.22,96.43 186.04,96.43
+INV_PWR_SRC on BOTTOM: 184.51,103.28 183.36,103.28 182.97,102.9 182.97,96.32 183.11,96.17 184.51,96.17 184.89,96.55 184.89,102.9
+LCDVDD on TOP: 178.29,94.39 178.29,93.25 178.16,93.12 176.76,93.12 176.51,93.38 176.51,95.03 176.64,95.16 176.64,95.92 176.76,96.05 176.76,97.32 177.02,97.57 179.05,97.57 179.3,97.32 179.3,95.41
+LCDVDD on TOP: 173.53,100.23 173.53,99.93 173.61,99.86 174.32,99.86 174.7,100.24 175.49,100.24 175.88,99.86 175.88,98.97 175.65,98.74 172.94,98.74 172.69,98.99 172.69,100.16 172.81,100.27 173.5,100.27
+LCDVDD on BOTTOM: 179.56,97.32 178.92,96.68 177.65,96.68 177.02,97.32 177.02,98.33 176.64,98.71 174.73,98.71 174.48,98.97 174.48,99.35 173.34,100.49 173.34,102.27 174.1,103.03 178.92,103.03 179.56,102.4
+ODR_PWR on TOP: 22.33,84.23 22.21,84.11 21.06,84.11 20.94,84.23 20.94,86.36 21.1,86.52 22.22,86.52 22.33,86.41
+ODR_PWR on TOP: 18.06,86.24 15.77,86.24 15.49,85.97 15.49,85.45 15.6,85.35 16.71,85.35 16.96,85.6 18.08,85.6 18.2,85.72 18.2,86.1
+ODR_PWR on IN1: 27.84,82.07 27.74,82.16 27.74,82.48 27.58,82.65 27.58,82.93 27.44,83.07 27.44,83.5 27.54,83.6 28.41,83.6 28.6,83.41 28.6,82.18 28.48,82.07
+ODR_PWR on IN1: 22.12,85.75 23.39,85.75 23.49,85.64 23.49,84.65 23.36,84.53 22.16,84.53 22.03,84.65 22.03,85.66
+ODR_PWR on IN3: 15.6,86.06 16.69,86.06 17.4,85.35 17.4,84.6 17.25,84.45 15.93,84.45 15.47,84.92 15.47,85.93
+ODR_PWR on IN3: 21.37,84.16 19.75,84.16 19.67,84.24 19.67,85.03 19.88,85.24 21.36,85.24 21.51,85.09 21.51,84.3
+PBATT on TOP: 75.42,88.17 77.45,88.17 78.21,87.41 78.97,87.41 79.23,87.66 79.23,88.26 79.27,88.3 84.13,88.3 84.18,88.25 84.18,85 83.8,84.62 75.29,84.62 75.04,84.87 75.04,87.79
+PD_VBUS_A on TOP: 11.93,56.67 13.23,56.67 13.35,56.55 13.35,54.94 12.52,54.11 12.35,54.11 11.79,54.67 11.79,56.53
+PD_VBUS_B on TOP: 25.63,53.86 25.84,53.86 25.94,53.96 25.94,54.1 26.1,54.26 26.34,54.26 26.54,54.45 26.54,54.53 27.2,55.2 27.2,56.4 27.13,56.46 26.25,56.46 26.25,56.46 26.18,56.46 26.09,56.37 26.09,55.65 26.08,55.64 25.52,55.64 25.08,55.2 25.08,54.41
+PD_VBUS_B on IN2: 25.6,55.16 26.09,55.16 26.61,55.68 26.61,58.16 25.55,59.23 25.55,61.97 25.22,62.3 24.64,62.3 24.4,62.06 24.4,58.77 24.43,58.75 24.44,58.75 25.08,58.11 25.08,57.68 25.51,57.25 25.51,55.25
+PWR_SRC_AC on TOP (solid shape): 70.83,135.4 70.83,133.08 70.66,132.9 68.05,132.9 68.05,132.91 67.14,132.91 66.97,133.08 66.97,134.36 67.61,135 67.61,135.44 67.79,135.62 70.62,135.62
+PWR_SRC_AC on TOP: 58.02,121.95 58.02,117.81 57.74,117.53 57.46,117.53 57.13,117.2 57.13,114.64 56.75,114.26 53.32,114.26 53.32,115.15 52.97,115.5 52.97,118.34 52.6,118.71 48.91,118.71 48.79,118.83 48.79,119.98 49.12,120.32 54.15,120.32 54.95,121.12 56.78,121.12 56.88,121.22 56.88,121.99 56.97,122.08 57.89,122.08
+PWR_SRC_AC on IN2: 67.04,135.8 67.04,134.09 61.27,128.32 61.27,127.62 56.9,123.25 54.87,123.25 52.3,120.68 52.3,116.4 54.46,114.24 56.75,114.24 57.18,114.67 57.18,117.22 57.72,117.76 62.72,117.76 66.02,121.06 66.02,122.59 68.99,125.56 68.99,128.46 69.17,128.63 70.24,128.63 71.86,130.26 71.86,135.29 71.23,135.92 67.16,135.92
+SD_VDD2 on TOP: 4.93,82.46 4.17,83.22 3.54,83.22 3.28,83.47 3.28,83.98 3.41,84.11 4.81,84.11 5.44,83.47 5.44,82.58 5.31,82.46
+SD_VDD2 on TOP: 27.4,82.93 27.54,82.79 27.54,82.49 27.68,82.35 27.68,81.22 27.63,81.17 27.53,81.17 27.48,81.22 27.48,82.09 26.96,82.61 26.96,82.86 27.02,82.93
+SD_VDD2 on TOP: 21.32,80.17 21.06,80.42 21.06,82.84 21.32,83.09 21.82,83.09 22.08,82.84 22.71,82.84 22.84,82.71 22.84,80.42 22.58,80.17
+SD_VDD2 on IN1: 22.66,82.53 23.45,81.74 23.45,80.81 21.67,80.81 21.07,81.4 21.07,82.2 21.41,82.53 21.76,82.53
+SD_VDD2 on IN1: 8.49,83.73 4.43,83.73 4.17,83.47 4.17,83.22 5.57,81.82 9.63,81.82 9.76,81.95 9.76,82.46
+SD_VDD2 on IN1: 27.26,82.92 26.42,82.92 26.15,82.65 26.15,81.89 26.36,81.68 27.48,81.68 27.65,81.84 27.65,82.39 27.49,82.55 27.49,82.68
+SD_VDD2 on IN3: 20.43,82.96 20.05,82.58 20.05,81.19 20.3,80.93 21.57,80.93 22.08,81.44 22.08,82.58 21.7,82.96
+SD_VDD2 on IN3: 8.56,82.9 10,82.9 10.04,82.86 11.14,82.86 11.41,82.58 11.41,82.08 11.03,81.69 8.49,81.69 8.36,81.82 8.36,81.87 8.38,81.89 8.38,82.71 8.56,82.89
B+ on TOP (solid shape): 160.89,128.57 160.89,127.28 160.74,127.14 159.79,127.14 159.62,127.3 159.62,128.57 159.75,128.7 160.76,128.7
B+ on TOP (solid shape): 181.08,114.54 181.08,111.92 180.7,111.54 178.92,111.54 178.8,111.67 178.8,113.06 179.43,113.7 180.19,113.7 180.57,114.08 180.57,114.56 180.68,114.66 180.96,114.66
B+ on TOP (solid shape): 60.18,108.03 60.18,103.23 60.15,103.21 59.46,103.21 59.34,103.33 52.54,103.33 52.5,103.37 52.5,104.93 52.95,105.38 52.95,107.57 53.21,107.83 58.53,107.83 58.89,108.19 60.02,108.19
B+ on TOP (solid shape): 76.21,135.44 76.21,133.08 76.03,132.9 71.65,132.9 71.62,132.92 71.35,132.92 70.99,133.28 70.99,134.72 71.14,134.87 72.85,134.87 73.58,135.59 76.05,135.59
B+ on BOTTOM (solid shape): 70.22,101.67 62.22,101.67 62.22,109.67 70.22,109.67
B+ on IN2 (solid shape): 181.13,114.64 181.13,111.77 180.12,110.75 174.76,110.75 173.97,111.54 173.97,112.17 174.61,112.81 177.4,112.81 179.46,114.87 180.91,114.87
B+ on TOP: 175.88,128.43 176.76,128.43 176.77,128.43 176.92,128.43 176.97,128.38 176.97,126.86 176.76,126.65 175.94,126.65 175.74,126.86 175.74,128.29
B+ on TOP: 187.31,102.14 188.07,102.14 188.19,102.27 188.19,103.38 188.03,103.54 188.03,104.75 188.32,105.04 189.62,105.04 189.85,104.81 189.85,104.55 190.1,104.3 190.1,101.13 189.97,101 187.31,101 187.18,101.13 187.18,102.01
B+ on TOP: 178.29,123.22 178.67,122.84 178.67,121.09 178.54,120.96 178.03,120.96 177.92,121.08 177.92,121.94 177.65,122.21 176.27,122.21 176.21,122.26 176.21,123.17 176.27,123.22
B+ on TOP: 156.06,113.95 157.08,113.95 157.21,113.83 157.21,111.43 157.05,111.27 155.94,111.27 155.81,111.4 155.81,113.7
B+ on TOP: 178.64,137.6 178.44,137.8 174.97,137.8 174.86,137.69 174.86,137.19 175.11,136.94 175.88,136.94 176.78,136.04 178.3,136.04 178.64,136.38
B+ on TOP: 71.99,98.34 71.81,98.17 70.12,98.17 69.48,98.81 69.48,100.17 69.48,100.17 69.48,100.34 70.1,100.96 70.1,102.13 71.09,103.12 71.9,103.12 71.99,103.03
B+ on TOP: 66.02,91.82 66.02,87.28 66.21,87.09 68.48,87.09 68.51,87.12 68.51,89.14 68.69,89.31 73.89,89.31 74.23,88.98 76.73,88.98 77.54,89.8 77.54,91.74 77.31,91.97 75.69,91.97 75.67,91.98 66.19,91.98
B+ on TOP: 166.86,130.59 165.59,130.59 165.21,130.97 165.21,132.37 165.46,132.62 168,132.62 168.13,132.49 168.13,131.49 168.04,131.39 167.41,131.39 167.11,131.1 167.11,130.84
B+ on TOP: 166.48,115.98 167.87,115.98 168,115.86 168,114.33 167.75,114.08 166.6,114.08 166.35,114.33 166.35,115.86
B+ on BOTTOM: 167.63,114.71 167.87,114.47 167.87,112.56 168.26,112.17 169.4,112.17 170.41,113.19 173.34,113.19 173.97,112.56 173.97,111.54 172.95,110.52 164.57,110.52 164.06,111.03 161.65,111.03 159.87,112.81 155.3,112.81 155.05,113.06 155.05,114.46 155.3,114.71 160.76,114.71 162.79,112.68 163.43,112.68 165.46,114.71
B+ on BOTTOM: 65.51,89.19 74.66,89.19 75.42,89.95 75.42,94.65 72.37,97.7 72.37,103.16 70.72,104.81 70.72,109.13 70.21,109.63 70.21,110.52 67.93,112.81 67.93,115.73 67.42,116.24 67.42,116.62 69.45,118.65 69.45,120.43 70.72,121.7 70.72,126.65 68.94,128.43 68.94,128.94 69.58,129.57 74.4,129.57 74.78,129.95 74.78,133.64 72.88,135.54 66.02,135.54 61.83,131.35 61.83,122.97 60.94,122.08 60.94,121.45 60.56,121.06 60.56,114.59 60.94,114.21 60.94,110.29 62.23,109 62.23,101.74 67.54,96.43 67.54,96.17 67.42,96.05 67.16,96.05 61.81,101.4 61.81,108.77 61.45,109.13 57.8,109.13 53.16,104.48 53.16,101.54 ; 1 cut-out
B+ on GND1: 156.07,112.83 155.99,112.91 155.99,113.62 156.19,113.83 157,113.83 157.23,113.6 157.23,112.91 157.15,112.83
B+ on GND1: 177.45,121.95 177.15,122.26 177.15,123.04 177.2,123.1 178.36,123.1 178.67,122.79 178.67,122.39 178.24,121.95
B+ on GND1: 176.2,128.27 176.94,128.27 177.61,127.61 177.61,127.41 177.5,127.3 177.3,127.3 177.18,127.43 176.55,127.43 176.15,127.83 176.15,128.22
B+ on IN3: 165.97,130.08 167.24,130.08 169.78,132.62 169.78,133.89 169.4,134.27 168.64,134.27 168.26,133.89 168.26,133 168,132.75 166.6,132.75 165.72,131.86 165.72,130.34
B+ on IN3: 179.43,113.95 180.96,113.95 181.21,113.7 181.21,111.92 182.48,110.65 189.85,110.65 191.24,109.25 191.24,105.7 189.34,103.79 188.32,103.79 187.31,104.81 187.31,107.35 186.29,108.36 179.05,108.36 178.54,108.87 178.54,112.17 179.18,112.81 179.18,113.7
B+ on GND4: 173.52,111.35 173.34,111.53 173.34,112.12 173.52,112.3 174.36,112.3 174.48,112.19 174.48,111.47 174.36,111.35
B+ on VCC: 177.51,113.06 177.02,113.55 177.02,126.38 174.46,128.94 163.71,128.94 161.93,127.16 159.6,127.16 155.66,131.1 147.83,131.1 145.16,128.43 124.04,128.43 120.86,131.61 72.1,131.61 71.48,132.22 71.48,140.37 80.37,140.37 80.37,139.9 80.59,139.37 81.12,139.15 131.84,139.15 132.09,138.9 132.09,133.84 132.53,133.4 139.31,133.4 139.75,133.84 139.75,138.9 140,139.15 178.16,139.15 178.16,137.09 178.88,136.37 179.97,136.37 181.59,134.74 181.59,113.55 181.1,113.06 ; 1 cut-out
B+_PMIC on TOP (solid shape): outline of 90 points within 157.59,107.98 163.56,115.98
BAT_B+ on TOP: 70.72,84.74 70.85,84.87 70.85,86.39 70.97,86.52 71.86,86.52 72.17,86.21 72.17,86.02 72.55,85.64 73.12,85.64 73.27,85.49 73.49,85.49 73.63,85.63 73.63,85.92 73.84,86.14 74.53,86.14 74.78,86.39 74.78,87.92 73.68,89.02 69.4,89.02 69.35,88.98 69.35,86.86 68.83,86.34 68.1,86.34 67.98,86.22 67.98,84.82 68.05,84.74
CHG_BTS on TOP (solid shape): 59.72,128.74 59.72,127.9 59.67,127.85 58.91,127.85 58.48,128.28 57.84,128.28 57.66,128.46 56.62,128.46 56.57,128.51 56.57,128.61 56.62,128.66 57.77,128.66 57.92,128.51 58.76,128.51 59.01,128.76 59.7,128.76
CHG_LGATE on TOP (solid shape): 57.66,127.72 58.2,127.72 58.4,127.52 58.4,126.7 58.27,126.58 57.97,126.58 57.79,126.75 57.79,127.29 57.44,127.64 56.65,127.64 56.57,127.72 56.57,127.8 56.65,127.87 57.51,127.87
CHG_LGATE on IN3 (solid shape): 59.16,127.67 59.16,125.13 58.91,124.87 57.77,124.87 57.51,125.13 57.51,127.67 57.77,127.92 58.91,127.92
CHG_LGATE on IN3: 59.16,117 59.42,116.75 61.19,116.75 61.45,117 61.45,117.76 61.07,118.14 59.42,118.14 59.16,117.89
CHG_SW on TOP (solid shape): 59.8,129.95 59.8,129.19 59.67,129.07 59.04,129.07 58.78,129.32 57.94,129.32 57.87,129.24 56.65,129.24 56.57,129.32 56.57,129.4 56.65,129.47 57.54,129.47 58.15,130.08 59.67,130.08
CHG_SW on TOP (solid shape): 58.53,117.33 58.53,114.14 59.04,113.64 60.98,113.64 61.07,113.55 61.07,112.58 60.99,112.49 59.35,112.49 59.16,112.3 59.16,111.16 58.6,110.59 53.81,110.59 53.07,111.34 53.07,113.44 53.32,113.7 56.62,113.7 57.41,114.49 57.41,117.28 57.51,117.38 58.48,117.38
CHG_SW on BOTTOM (solid shape): 59.42,111.79 59.42,110.9 59.16,110.65 58.15,110.65 57.89,110.9 57.89,112.68 58.53,112.68
CHG_SW on BOTTOM (solid shape): 60.05,130.34 60.05,129.7 59.8,129.45 58.02,129.45 57.89,129.57 57.89,130.34 58.15,130.59 59.8,130.59
CHG_UGATE on TOP (solid shape): 56.45,117.1 56.45,116.92 56.27,116.75 55.99,116.75 55.61,116.37 55.23,116.37 55.1,116.49 55.1,117.1 55.38,117.38 56.17,117.38
CHG_UGATE on TOP (solid shape): 58.86,129.01 58.86,128.76 58.73,128.63 57.99,128.63 57.79,128.84 56.62,128.84 56.57,128.89 56.57,129.01 56.62,129.07 57.92,129.07 57.99,129.14 58.73,129.14
CHG_UGATE on BOTTOM (solid shape): 56.11,116.59 55.9,116.38 55.28,116.38 55.1,116.57 55.1,118.91 55.23,119.03 56.11,119.03
CHG_UGATE on BOTTOM (solid shape): 59.54,128.68 59.54,126.91 58.53,126.91 58.53,127.67 57.77,128.43 57.77,128.94 58.02,129.19 59.04,129.19
CHRGR_VIN on TOP (solid shape): 71.84,142.07 71.84,140.11 71.23,139.5 68.41,139.5 68.05,139.86 68.05,141.24 67.75,141.55 67.27,141.55 67.14,141.68 67.14,142.21 67.23,142.3 71.61,142.3
CHRGR_VIN on TOP: 57.53,135.24 57.19,134.91 55.16,134.91 54.99,134.74 54.99,134.06 54.83,133.9 54.16,133.9 54.05,134.01 54.05,135.33 54.25,135.53 56.47,135.53 56.53,135.6 56.53,136.36 56.49,136.41 55.58,136.41 55.39,136.6 55.39,137.13 55.53,137.27 56.31,137.27 56.74,136.83 57.49,136.83 57.53,136.79
CHRGR_VIN on TOP: 47.98,116.03 50.32,116.03 50.45,115.91 50.45,115.38 51.12,114.71 51.65,114.71 51.82,114.54 51.82,113.91 51.78,113.88 50.49,113.88 49.76,114.6 47.94,114.6 47.78,114.75 47.78,115.84
