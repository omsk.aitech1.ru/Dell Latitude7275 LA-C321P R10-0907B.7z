# Allegro board LAC321PR10-0907B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_RST#_Q: length 13.4
  TOP w0.14: v2(243.16,129.45) 243.16,129.17 R41.1 242.74,128.75 U13.4
  IN2 w0.079: v2(243.16,129.45) 243.16,128.42 v4(243.26,128.32)
  IN3 w0.079: v4(243.26,128.32) 243.26,125.44 247.58,121.12 JNGFF3.44
  GND4 w0.084: v4(243.26,128.32) v15(243.83,128.32)
WLAN_WIGIG60GHZ_DIS#: length 10.7
  TOP w0.119: D5.2 223.31,126.22 v10(223.31,125.05)
  IN1 w0.089: v10(223.31,125.05) 223.59,125.05 224.09,124.55 224.09,123.33 224.97,122.45 226.54,122.45 227.63,121.36 228.04,121.36 228.18,121.5 228.94,121.5 229.09,121.36 229.71,121.36 230.1,121.75 v1(230.31,121.75)
WWAN_EN: length 6.6
  TOP w0.119: D11.1 37.51,96.03 v1(37.06,96.48) ; v1(33.57,95.69) 33.57,95.42 33.87,95.12 U32.5
  IN1 w0.089: v1(37.06,96.48) 35.66,96.48 34.87,95.69 v1(33.57,95.69)
WWAN_OFF#: length 172.2
  TOP w0.119: v1(15.91,95.72) 15.91,94.43 16.12,94.22 16.69,94.22 16.81,94.33 Q86.1
  IN1 w0.06: v1(133.67,105.11) 133.67,105.13 133.94,105.4 133.94,105.82 134.32,106.2 135.3,106.2 135.39,106.11 138.02,106.11 v8(138.13,106)
  IN1 w0.089: v1(15.91,95.72) 16.4,95.72 16.65,95.46 20.12,95.46 20.42,95.75 24.73,95.75 25.71,94.78 26.32,94.78 28.8,97.25 29.14,97.25 31.41,99.52 34.3,99.52 34.75,99.07 39.23,99.07 40.59,100.43 43.6,100.43 46.34,103.17 46.34,105.06 47.83,106.56 47.83,110.79 50.2,113.16 50.75,113.16 51.21,113.62 51.21,114.25 51.48,114.52 51.85,114.52 52.17,114.84 52.17,116.87 54.42,119.12 59.15,119.12 59.52,118.75 60.33,118.75 63.68,122.11 63.68,122.79 65.6,124.71 65.94,124.71 68.02,126.79 70.07,126.79 71.05,127.76 74.8,127.76 75.23,128.2 75.23,128.53 79.26,132.55 81.97,132.55 82.2,132.32 82.43,132.32 v3(82.72,132.02)
  GND1 w0.119: v8(138.13,106) 138.13,106.23 v4(138.56,106.66)
  IN2 w0.084: v3(82.72,132.02) 82.96,132.26 v4(82.96,132.34)
  GND3 w0.119: v4(136.63,115.34) 134.75,115.34 134.22,114.8 122.09,114.8 117.47,119.42 114.7,119.42 113.76,120.36 113.61,120.5 112.81,120.5 111.67,121.64 105.35,121.64 104.72,122.27 101.87,122.27 96.4,127.74 95.15,127.74 94.49,128.39 88.51,128.39 86.65,130.26 85.24,130.26 83.56,131.94 83.37,131.94 v4(82.96,132.34)
  IN3 w0.084: v4(138.56,106.66) 138.59,106.69 138.89,106.69 139.47,107.26 139.47,107.78 139.27,107.98 138.18,107.98 137.86,108.3 137.86,108.6 138.11,108.85 138.11,109.56 137.5,110.17 137.5,110.83 137.8,111.13 137.8,112.38 137.21,112.97 137.21,113.41 136.5,114.12 136.5,115.2 v4(136.63,115.34)
  GND4 w0.119: v6(138.66,106.23) 138.56,106.33 v4(138.56,106.66)
WWAN_OFF#_R: length 24.5
  TOP w0.119: Q86.6 15.19,94.33 14.88,94.64 14.88,95.14 14.55,95.47 R46.2 v7(14.48,94.95)
  BOTTOM w0.119: JNGFF1.8 31.05,101.31 27.39,97.65 22.51,97.65 20.52,95.66 15.32,95.66 14.61,94.95 v7(14.48,94.95)
WWAN_PWR_OFF#: length 141.4
  IN1 w0.089: v5(70.44,125.56) 70.42,125.59 68.44,125.59 66.11,123.26 66.11,122.39 64.62,120.9 64.18,120.9 61.34,118.06 61.34,117.43 61.23,117.32 61.23,112.73 59.21,110.71 59.21,103.28 58.38,102.45 49.71,102.45 47.49,100.23 45.18,100.23 44.21,99.26 41.34,99.26 39.5,97.43 35.47,97.43 v1(35.41,97.48)
  GND1 w0.119: v5(70.44,125.56) 70.47,125.59 70.77,125.59 v4(70.82,125.53)
  IN2 w0.06: v2(132.93,106.72) 132.93,106.71 133.15,106.48 133.15,106.48 v4(133.16,106.48)
  IN3 w0.084: v4(70.82,125.53) 70.82,123.4 71.24,122.98 73.43,122.98 75.29,124.85 78,124.85 79.97,126.81 85,126.81 85.43,126.38 88.37,126.38 89.29,125.46 95.26,125.46 96.5,126.7 101.43,126.7 103.05,128.32 108.21,128.32 110.19,126.35 110.62,126.35 111.87,125.1 120.25,125.1 120.53,124.82 120.53,123.61 119.23,122.31 119.23,120.71 118.3,119.78 118.3,118.63 122.03,114.9 128.57,114.9 132.62,110.85 132.62,107.95 133.05,107.51 133.05,106.59 v4(133.16,106.48)
WWAN_PWR_OFF#_R: length 9.9
  TOP w0.089: C82.1 34.12,98.1 R48.2 34.69,98.07 R50.1
  TOP w0.119: v7(33.79,98.72) 33.89,98.62 C82.1
  BOTTOM w0.076: 31.69,103.91 31.55,104.05 JNGFF1.6
  BOTTOM w0.119: 31.69,103.91 31.98,103.61 31.98,101.07 33.79,99.27 v7(33.79,98.72)
WWAN_RST#: length 155.9
  TOP w0.119: v1(28.99,95.96) 29.13,96.1 R56.1
  IN1 w0.06: v8(138.69,101.96) 138.47,102.18 137.62,102.18 136.84,102.96 136.42,102.96 136.1,103.28 134.84,103.28 134.72,103.39 134.58,103.39 134.47,103.28 134.35,103.28 134.17,103.46 134.17,103.53 133.88,103.82 v1(133.67,103.82)
  IN1 w0.089: v1(28.99,95.96) 28.99,95.99 30.41,97.42 31.87,97.42 32.42,97.98 34.36,97.98 34.67,98.29 39.53,98.29 40.88,99.65 43.89,99.65 47.1,102.85 47.1,104.74 48.6,106.24 48.6,110.47 50.5,112.37 51.08,112.37 52.93,114.22 52.93,116.55 54.73,118.36 58.82,118.36 59.24,117.94 60.68,117.94 64.46,121.72 64.46,122.49 65.78,123.81 66.12,123.81 68.34,126.02 71.13,126.02 71.56,126.45 72.2,126.45 72.34,126.6 75.24,126.6 80.36,131.71 80.88,131.71 v3(80.88,131.71)
  GND1 w0.119: v8(138.69,101.96) 138.51,102.15 v4(138.51,102.31)
  IN2 w0.084: v4(80.83,132.32) 80.88,132.27 v3(80.88,131.71)
  GND3 w0.119: v4(80.83,132.32) 80.83,131.86 83.62,129.07 84.63,129.07 86.35,127.35 87.6,127.35 91.13,123.81 95.43,123.81 101.7,117.55 111.75,117.55 117.05,112.25 135.52,112.25 135.64,112.38 136.07,112.38 136.23,112.23 v4(136.81,112.23)
  IN3 w0.084: v4(137.39,108.21) 137.39,108.47 137.83,108.9 137.83,109.48 136.81,110.5 v4(136.81,112.23) ; v6(137.5,107.82) 137.9,107.41 137.9,106.79 138.35,106.34 138.35,104.52 138.16,104.33 138.16,103.35 138.5,103.01 138.5,102.68 138.51,102.67 v4(138.51,102.31)
  GND4 w0.119: v4(137.39,108.21) 137.39,107.92 v6(137.5,107.82)
WWAN_RST#_Q: length 16.1
  TOP w0.119: v1(24.29,96.05) 24.31,96.02 Q89.1 ; JNGFF1.59 16.3,101.33 v1(16.33,101.3)
  IN1 w0.089: v1(24.29,96.05) 20.44,96.05 20.06,95.66 16.72,95.66 16.02,96.36 16.02,97.53 15.6,97.95 15.6,99.92 15.74,100.06 15.74,100.41 16.33,101 v1(16.33,101.3)
WWAN_WAKE#: length 8.5
  TOP w0.119: JNGFF1.15 27.3,101.7 27.64,101.35 28.86,101.35 v7(29.62,100.59) ; v7(33.23,98.71) 33.23,98.53 33.13,98.43 R49.2
  IN3 w0.084: v7(33.23,98.71) 32.59,99.35 30.87,99.35 v7(29.62,100.59)
XCLK_BIASREF: length 2.2
  TOP w0.089: UC1.P1 135.46,100.92 135.72,101.18 137.04,101.18 137.17,101.05 RH32.1
XDP_BPM#0: length 13.9
  TOP w0.152: RC68.1 110.93,93.43 111.22,93.72 111.84,93.72 112.07,93.49 v2(112.07,93.33)
  IN2 w0.06: v2(120.31,99.32) 120.31,99.16 120.43,99.04 120.43,98.99 120.51,98.91 120.51,98.74 120.38,98.6 120.38,98.16 119.42,97.2 119.42,96.59 119.13,96.3 118.53,96.3 117.96,95.73 117.61,95.73 116.54,94.66 116.54,94.29
  IN2 w0.084: v2(112.07,93.33) 112.45,93.71 114.08,93.71 114.25,93.87 116.14,93.87 116.55,94.29 116.54,94.29 116.54,94.29
XDP_BPM#1: length 14.3
  TOP w0.152: RC65.1 111.55,93.29 111.89,92.95 112.22,92.95 v2(112.48,93.2)
  IN2 w0.06: 116.74,94.14 116.74,94.7 117.61,95.56 118.88,95.56 120.26,96.93 120.66,96.93 120.78,97.06 120.78,97.42 120.66,97.54 120.66,98.54 120.84,98.72 120.84,99.15 120.75,99.24 120.75,99.29 120.63,99.41 v2(120.63,99.57)
  IN2 w0.084: 116.74,94.14 116.74,94 116.28,93.53 115.67,93.53 115.49,93.35 112.63,93.35 v2(112.48,93.2)
XDP_BPM#2_R: length 6.5
  IN2 w0.06: v4(116.8,95.52) 117.22,95.52 117.56,95.85 117.91,95.85 118.48,96.42 119.08,96.42 119.3,96.64 119.3,97.25 120.25,98.2 120.25,98.77 v2(120.31,98.83)
  GND4 w0.089: v9(116.62,95.13) 116.8,95.31 v4(116.8,95.52)
  BOTTOM w0.152: v9(116.62,95.13) 116.67,95.08 TC6.1
XDP_BPM#3_R: length 2.5
  IN2 w0.06: v4(120.45,97.32) 120.5,97.37 120.5,98.56 120.63,98.69 v2(120.63,99.07)
  GND4 w0.089: v9(119.92,97.7) 120.07,97.7 v4(120.45,97.32)
XDP_DBRESET#: length 2.1
  TOP w0.14: RC36.2 118.75,88.1 v10(118.92,87.93)
  GND1 w0.084: v4(119.21,87.42) 119.21,87.42 118.92,87.72 v10(118.92,87.93)
  GND4 w0.084: v4(119.21,87.42) 119.55,87.08 v9(119.55,86.88)
XDP_ITP_PMODE: length 6.5
  TOP w0.06: UC1.A60 117.71,97.51 116.82,96.63 116.82,96.62 116.69,96.49
  TOP w0.119: RC40.2 RC39.2 113.62,95.22 114.29,95.89 115.06,95.89 115.5,96.33 116.53,96.33 116.69,96.49
XDP_OBS0: length 11.3
  TOP w0.152: v10(111.69,92.12) 111.35,92.12 110.93,92.54 RC68.2
  GND1 w0.089: v4(112.22,92.21) 112.13,92.12 v10(111.69,92.12)
  IN3 w0.084: v4(112.22,92.21) 112.49,92.21 112.61,92.33 112.61,92.51 112.49,92.63 111.88,92.63 111.75,92.76 111.75,92.86 111.88,92.98 112.38,92.98 112.51,93.11 112.51,93.25 112.38,93.37 111.88,93.37 111.75,93.5 111.75,93.62 111.88,93.74 112.38,93.74 112.51,93.87 112.51,94 112.38,94.13 111.88,94.13 111.75,94.25 111.75,94.35 111.88,94.48 112.7,94.48 112.83,94.35 112.83,93.31 113.22,92.91 113.22,92.77 113.05,92.59 v6(113.05,92.44)
  BOTTOM w0.152: v6(113.05,92.44) JXDP2.21
XDP_OBS1: length 13
  TOP w0.152: v10(112.68,92.16) 112.65,92.19 112.53,92.19 112.19,92.53 111.65,92.53 111.49,92.69 RC65.2
  GND1 w0.089: v4(113.04,91.78) 113.04,91.8 v10(112.68,92.16)
  IN3 w0.084: v6(113.55,91.47) 113.55,91.13 113.67,91 114.25,91 114.37,90.87 114.37,90.7 114.25,90.58 113.53,90.58 113.4,90.45 113.4,90.26 113.53,90.13 114.25,90.13 114.37,90.01 114.37,89.74 114.25,89.61 113.16,89.61 113.04,89.74 113.04,90.44 112.91,90.56 112.26,90.56 112.13,90.69 112.13,90.87 112.26,90.99 112.91,90.99 113.04,91.12 113.04,91.27 112.91,91.39 112.24,91.39 112.13,91.51 112.13,91.67 112.24,91.78 v4(113.04,91.78)
  BOTTOM w0.152: v6(113.55,91.47) JXDP2.23
XDP_PRDY#: length 17
  IN1 w0.06: v1(120.31,98.34) 119.95,98.34 119.79,98.17 119.79,97.99 119.54,97.75 119.54,97.68 119.1,97.24 118.58,97.24 118.12,96.78 117.63,96.78 117.52,96.9 116.76,96.9
  IN1 w0.089: v7(114.68,97.69) 114.86,97.69 115.65,96.9 116.76,96.9
  BOTTOM w0.089: v7(114.68,97.69) 114.69,97.69 114.71,97.72 114.71,98.15 T15.1
  BOTTOM w0.119: JXDP2.5 109.05,92.84 109.33,93.12 109.69,93.12 110.87,94.31 111.34,94.31 111.53,94.49 113.12,94.49 113.82,95.2 113.82,96.83 v7(114.68,97.69)
XDP_PREQ#: length 17.2
  IN1 w0.06: 116.82,97.06 117.22,97.06 117.95,97.8 118.97,97.8 v1(119.02,97.84)
  IN1 w0.089: 116.82,97.06 115.93,97.06 115.61,97.38 115.53,97.38 114.81,98.1 114.44,98.1 v5(114.41,98.06)
  GND1 w0.119: v10(108.97,92.67) v4(108.97,91.93) ; v5(114.41,98.06) 114.13,97.79 v4(114.13,97.72)
  GND4 w0.119: v6(108.55,91.8) 108.68,91.93 v4(108.97,91.93) ; v4(114.13,97.72) 113.86,97.46 v9(113.86,97.4)
  BOTTOM w0.119: v9(113.86,97.4) 113.85,97.42 113.62,97.42 T16.1 113.6,96.99 113.6,95.28 113.03,94.72 111.44,94.72 111.25,94.53 110.78,94.53 109.6,93.35 108.99,93.35 108.55,92.9 v6(108.55,91.8)
XDP_PRSENT: length 20.3
  TOP w0.152: v7(131.58,88.04) 130.63,87.09 127.05,87.09 RC237.1 RC26.2
  IN3 w0.084: v6(122.55,86.07) 122.55,84.12 v6(122.31,83.88)
  BOTTOM w0.152: v6(122.31,83.88) 125.26,83.88 127.85,86.47 130.42,86.47 131.58,87.63 v7(131.58,88.04)
XDP_RST#: length 13
  TOP w0.152: v10(114.14,88.4) 113.99,88.25 RC28.2 ; v10(113.9,92.51) 113.9,93.47 RC39.1
  GND1 w0.089: v10(114.14,88.4) 114.55,88.81 v4(114.99,88.81) ; v4(114.15,91.98) 114.15,92.26 v10(113.9,92.51)
  IN3 w0.084: v6(119.05,86.07) 118.09,87.03 118.09,87.92 117.44,88.57 115.69,88.57 115.48,88.78 115.02,88.78 v4(114.99,88.81) 114.71,89.09 114.71,91.01 114.15,91.57 v4(114.15,91.98)
XDP_TCK: length 5
  TOP w0.102: 123.93,94.14 v2(124.14,94.34)
  TOP w0.119: v2(124.14,94.34) 124.14,94.37 124.15,94.38 RC27.2 ; 123.93,94.14 123.92,94.13 RC63.2
  GND1 w0.119: v2(124.14,94.34) 124.01,94.34 v4(123.62,93.95)
  IN3 w0.084: v6(123.25,94.12) 123.45,94.12 v4(123.62,93.95)
  BOTTOM w0.119: JXDP2.57 122.05,92.91 v6(123.25,94.12)
XDP_TCK1: length 2.7
  BOTTOM w0.152: JXDP2.55 121.55,94.46 RC22.2
XDP_TDI: length 19.6
  TOP w0.152: v10(127.49,89.88) 127.43,89.81 RC43.2 RC51.2
  GND1 w0.089: v4(127.83,90.41) 127.83,90.21 v10(127.49,89.88)
  GND4 w0.089: v9(127.83,89.97) v4(127.83,90.41)
  BOTTOM w0.152: JXDP2.56 121.55,84.81 122.07,84.29 124.42,84.29 127.36,87.23 127.36,87.77 127.06,88.07 124.52,88.07 124.26,88.33 124.26,89.65 124.58,89.97 v9(127.83,89.97)
XDP_TDO: length 5.5
  TOP w0.152: RC49.2 119.55,88.01 RC5.2 121.71,88.01 v10(121.8,87.92)
  GND1 w0.089: v10(121.8,87.92) 121.8,87.82 121.49,87.51 v4(121.39,87.51)
  GND4 w0.089: v6(121.27,87.92) 121.27,87.64 v4(121.39,87.51)
  BOTTOM w0.152: JXDP2.52 120.55,87.2 v6(121.27,87.92)
XDP_TMS: length 18.2
  TOP w0.152: RC52.2 130.16,93.45 130.16,93.12 129.97,92.93 RC44.2 129.97,92.27 v1(129.8,92.11)
  IN1 w0.089: v8(131.11,88.04) 131.11,89.12 130.54,89.7 130.54,90.86 129.8,91.6 v1(129.8,92.11)
  GND1 w0.089: v4(130.7,88.04) v8(131.11,88.04)
  IN3 w0.084: v4(130.7,88.04) 130.4,87.75 v4(127.17,87.75)
  GND4 w0.089: v4(127.17,87.75) 126.89,87.47 v9(126.89,87.42)
  BOTTOM w0.152: v9(126.89,87.42) 124.17,84.7 122.31,84.7 122.05,84.96 JXDP2.58
XDP_TRST#: length 12.7
  TOP w0.152: v10(114.62,90.4) 114.71,90.31 RC12.2 RC62.2
  GND1 w0.089: v4(115.07,90.46) 114.68,90.46 v10(114.62,90.4)
  IN3 w0.084: v4(115.07,90.46) 115.07,89.75 115.91,88.91 117.58,88.91 118.48,88 118.48,87.43 119.64,86.28 119.64,85.66 v6(120.86,84.44)
  BOTTOM w0.152: JXDP2.54 121.05,84.63 v6(120.86,84.44)
XTAL24_IN: length 11.5
  TOP w0.14: YH1.3 145.01,98.84 142.34,98.84 142.01,99.17 CH4.1 140.96,99.17 RH39.2 140.82,99.08 138.83,99.08 138.47,99.44 137.6,99.44 137.31,99.72 136.92,99.72 136.48,100.16 135.87,100.16 135.75,100.28 135.42,100.28 UC1.M1
XTAL24_OUT: length 9.8
  TOP w0.14: YH1.1 142.9,97.99 142.34,97.43 CH3.1 141.69,97.43 140.98,98.14 RH39.1 140.21,98.78 138.72,98.78 138.37,99.13 137.45,99.13 137.13,99.45 136.89,99.45 136.39,99.94 135.76,99.94 135.72,99.98 135.17,99.98 UC1.L2
N387666: length 4.8
  IN1 w0.06: 72.98,108.57 72.98,109 72.83,109.15 v1(72.82,109.15)
  IN1 w0.254: 72.98,108.57 73.18,108.36 73.69,108.36 73.97,108.09 73.97,106.33 74.78,105.52 v1(74.78,105.46)
N387808: length 5.4
  IN1 w0.06: 71.76,108.11 71.75,108.12 71.75,108.64 71.82,108.72 71.82,109.35 v1(72.02,109.55)
  IN1 w0.254: 71.76,108.11 71.82,108.05 71.82,108.04 71.88,107.98 71.88,107.63 71.5,107.26 71.5,107.26 71.01,106.76 69.29,106.76 v1(69.01,106.47)
N387812: length 5.2
  IN1 w0.06: 70.37,108.11 70.56,108.29 70.84,108.29 70.96,108.41 71.28,108.41 71.42,108.54 71.42,109.35 v1(71.62,109.55)
  IN1 w0.254: v1(68.17,106.42) 68.45,106.42 69.4,107.37 69.53,107.37 69.87,107.72 69.98,107.72 70.37,108.11
N388012: length 2.6
  TOP w0.254: PR1016.1 v1(70.69,107.3)
  IN1 w0.06: v1(71.62,109.15) 71.62,108.45 71.43,108.26 71.05,108.26 70.69,107.91 v1(70.69,107.3)
N388016: length 0.9
  TOP w0.254: PR1016.2 PR1025.1
N388144: length 4
  IN1 w0.06: v1(72.02,109.15) 72.27,108.9 72.27,108.11
  IN1 w0.254: v1(73.01,105.52) 72.35,106.18 72.35,107.66 72.27,107.73 72.27,108.11
N388398: length 3.6
  TOP w0.254: PR1018.1 v1(73.46,106.87)
  IN1 w0.06: 72.62,108.11 72.6,108.14 72.6,108.21 72.47,108.34 72.47,109.1 v1(72.42,109.15)
  IN1 w0.254: v1(73.46,106.87) 73.06,106.87 72.7,107.22 72.7,107.81 72.62,107.88 72.62,108.11
N388402: length 0.9
  TOP w0.254: PR1018.2 PR1027.1
N388550: length 7.2
  IN2 w0.203: v2(72.42,109.95) 72.42,109.3
  IN2 w0.254: 72.42,109.3 72.42,108.87 72.75,108.54 72.75,107.55 72.98,107.32 72.98,106.33 72.14,105.49 69.98,105.49 v2(69.96,105.52)
N389038: length 31.7
  TOP w0.254: PH1001.1 77.88,102.04 v7(77.88,102.67)
  IN1 w0.254: v7(77.88,102.67) 77.37,102.17 70.67,102.17 68.62,100.12 68.62,99.86 68.14,99.37 67.11,99.37 65.82,100.67 v2(65.39,100.67)
  IN2 w0.06: v2(72.02,110.35) 71.82,110.55 71.38,110.55 70.88,110.04 70.39,110.04
  IN2 w0.254: v2(65.39,100.67) 66.27,100.67 66.76,101.15 66.76,102.5 65.69,103.56 65.69,107.53 66.02,107.86 67.06,107.86 67.88,108.67 67.88,108.97 68.15,109.25 69.43,109.25 69.79,109.62 69.79,109.7 70.14,110.04 70.39,110.04
N389071: length 29
  TOP w0.254: v1(86.42,117.05) 86.9,116.57 PH1002.1
  IN1 w0.254: v1(86.42,117.05) 83.52,117.05 82.99,116.52 82.05,116.52 81.26,117.31 79.86,117.31 79.31,117.86 78.37,117.86 78.31,117.81 76.35,117.81 75.88,118.28 71.52,118.28 70.26,117.03 69.68,117.03 v2(67.11,114.46)
  IN2 w0.203: 70.58,111.37 70.8,111.15 v2(71.62,111.15)
  IN2 w0.254: 70.58,111.37 68.92,113.04 67.97,113.04 67.62,113.38 67.62,113.95 v2(67.11,114.46)
N389075: length 32.3
  IN1 w0.06: v2(72.82,111.15) 73.02,111.35 74.39,111.35 74.4,111.36
  IN1 w0.254: 74.4,111.36 75.52,111.36 75.93,111.77 v3(76.7,111.77) 78.67,111.77 79.76,112.86 79.76,114.38 77.2,116.95 75.97,116.95 v1(75.22,117.7)
  IN2 w0.254: v3(76.7,111.77) 76.9,111.56 76.9,110 76.43,109.53 76.43,107.83 78.21,106.05 80.59,106.05 82.04,104.61 87.19,104.61 87.65,105.06 v2(87.92,105.06)
N389103: length 39
  TOP w0.254: v2(75,119.38) 75.06,119.31 75.06,118.96 76.13,117.89 PR1022.1 ; v2(65.46,114.92) 65.82,114.56 65.82,114.46 PR1021.1
  IN1 w0.254: v3(66.94,108.29) 67.95,108.29 68.79,109.13 v1(69.02,109.13) 69.75,109.13 70.58,109.95 v1(70.82,109.95)
  IN2 w0.254: v2(75,119.38) 74.53,119.85 73.59,119.85 73.29,119.54 71.1,119.54 70.82,119.26 69.27,119.26 65.46,115.45 v2(65.46,114.92) 65.28,114.74 65.28,114.49 64.46,113.66 64.46,111.74 65.7,110.5 65.7,110.24 66.94,109.01 v3(66.94,108.29) 66.35,108.29 66.06,108.58 66.06,109.19 65.75,109.49 65.44,109.49 65.23,109.29 65.23,108.33 64.34,107.45 64.34,103.56 65.31,102.6 65.31,101.66 v2(65.39,101.58)
N389365: length 3.6
  IN2 w0.06: 70.87,108.11 71.39,108.63 71.39,109.12 72.02,109.75 v2(72.02,109.95)
  IN2 w0.254: 70.87,108.11 70.07,107.3 70.07,107.19 v2(70.06,107.2)
N389486: length 12.7
  TOP w0.254: PR1013.1 68.1,100.36 v2(68.1,101.06)
  IN2 w0.06: 70.59,108.64 71.47,109.53 71.52,109.53 71.82,109.82 71.82,110.16 71.63,110.35 v2(71.62,110.35)
  IN2 w0.254: v2(68.1,101.06) 68.1,101.4 67.37,102.14 67.37,104.58 67.76,104.97 67.76,106.01 68.92,107.17 69.39,107.17 70.59,108.38 70.59,108.64
N389491: length 2.9
  TOP w0.254: PR1014.1 69.53,102.01 69.86,101.68 69.86,101.06 69.07,100.27 PR1013.2
N390129: length 9.7
  TOP w0.254: v1(67.1,102.83) 66.24,102.83 PC1006.2
  IN1 w0.06: 69.78,108.16 70.13,108.52 70.9,108.52 71.02,108.64 71.02,108.95 v1(71.22,109.15)
  IN1 w0.254: 69.78,108.16 69.63,108.16 69.35,107.88 69.14,107.88 68.25,106.99 68,106.99 67.57,106.56 67.57,103.3 v1(67.1,102.83)
N390178: length 0.9
  TOP w0.254: PC1008.1 PR1010.2
N390245: length 12.2
  TOP w0.254: PR1010.1 67.94,102.9 PC1007.1 66.24,103.74 PR1011.1 v1(66.22,104.62) 67.09,104.62 PC1005.2
  IN1 w0.06: 69.79,108.77 70.01,109 70.01,109.05 70.34,109.38 71.05,109.38 v1(71.22,109.55)
  IN1 w0.254: 69.79,108.77 69.04,108.77 68.15,107.88 67.75,107.88 67.47,107.6 67.47,107.18 67.22,106.93 67.1,106.93 66.73,106.56 66.73,105.13 v1(66.22,104.62)
N390884: length 20
  TOP w0.254: v2(69.01,105.56) 69.01,104.69 PC1004.1 ; PR1003.1 79.42,94.76 PR1005.1 ; PR1003.1 79.42,95.63 v7(79.28,95.77) ; PR1003.1 79.43,94.78 PR1002.2
  IN2 w0.254: v7(79.28,95.77) 79.28,96.07 79.05,96.3 78.47,96.3 77.76,97.01 77.76,97.86 75.86,99.75 73.32,99.75 69.15,103.93 69.15,105.42 v2(69.01,105.56)
N11072790: length 6.9
  TOP w0.254: PL500.1 176.2,125.95 PC501.1 173.96,125.95 PC555.1 173.83,126.08 PC502.1 172.99,126.02 172.42,125.45 172.42,125.08 172.09,124.75 170.84,124.75 PU500.E14 PU500.E13
N11072808: length 0.9
  TOP w0.254: PR501.2 PC507.1
N11072906: length 3.9
  TOP w0.254: 166.86,129.57 166.86,129.5 166.58,129.22 166.58,127.13 167.19,126.52 PU500.A5 PU500.B5
N11072914: length 1.2
  TOP w0.508: PR511.2 164.62,129.12 PC524.1
N11087757: length 1.5
  TOP w0.254: PC605.1 171.75,117.93 PR600.2
N11640528: length 5.4
  TOP w0.089: v2(166.07,120.75) 165.97,120.64 165.51,120.64 165.18,120.31 164.33,120.31 TC77.1
  IN2 w0.084: v2(166.07,120.75) 166.07,121.6 166.78,122.31 166.78,122.51 167.13,122.86 167.93,122.86 v2(167.99,122.8)
N11870202: length 25.8
  TOP w0.254: PR703.1 172.45,109.02 v7(172.09,109.38)
  IN2 w0.06: v2(169.59,123.6) 169.95,123.96 170.57,123.96 170.69,124.09
  IN2 w0.084: v4(174.47,124.43) 174.47,124.57 174.06,124.98 171.28,124.98 170.95,124.65 170.95,124.34 170.69,124.09
  IN3 w0.084: v7(172.09,109.38) 172.49,109.77 172.49,111.86 175.24,114.61 176.79,114.61 177.3,115.12 177.3,116.95 175.62,118.63 175.62,121.83 174.71,122.74 174.71,123.45 174.47,123.69 v4(174.47,124.43)
N12938664: length 8.1
  TOP w0.119: v10(173.97,121.93) PC709.1
  GND1 w0.119: v4(174.68,122.26) 174.66,122.28 174.44,122.28 174.12,121.97 174.01,121.97 v10(173.97,121.93)
  IN2 w0.06: v2(170.39,123.6) 170.6,123.81
  IN2 w0.084: 170.6,123.81 170.74,123.81 170.98,124.05 171.56,124.05 172.16,124.65 173.44,124.65 v4(173.51,124.57)
  IN3 w0.084: v4(174.68,122.26) 174.43,122.51 174.43,123.3 173.51,124.21 v4(173.51,124.57)
N12987082: length 0.9
  TOP w0.254: PC608.2 170.59,128.81 PR601.1
N13642943: length 0.9
  TOP w0.508: PC506.1 PR500.1
N14326592: length 3.4
  TOP w0.254: PU800.J8 PU800.K8 70.08,109.55 69.7,109.18 69.7,108.92 PC800.1 PR816.2
N14365419: length 3
  TOP w0.508: PR510.1 PC523.1
N14384658: length 1.2
  TOP w0.254: PC542.1 177.3,118.96 PR516.1
N14401644: length 15.7
  TOP w0.254: PU800.G1 71.62,113.83 v10(71.67,113.88) ; PR817.2 79.8,113.74 79.48,113.42 v1(79.38,113.42)
  IN1 w0.254: v1(79.38,113.42) 79.2,113.6 79.2,114.26 77.1,116.37 74.96,116.37 74.07,117.26 v8(72.48,117.26)
  GND1 w0.254: v4(72.09,117.26) v8(72.48,117.26) ; v10(71.67,113.88) v4(71.23,113.88)
  GND4 w0.254: v9(72.09,116.87) v4(72.09,117.26) ; v4(71.23,113.88) v9(71.56,114.21)
  BOTTOM w0.254: v9(72.09,116.87) 72.09,116.14 71.56,115.61 v9(71.56,114.21)
N14435020: length 0.9
  TOP w0.508: PC620.1 PR605.1
N14435109: length 0.9
  TOP w0.254: PR609.1 PC637.1
N14444552: length 11.4
  TOP w0.119: v2(161.36,128.05) 161.55,128.24 161.55,129.73 PR608.1 161.45,130.64 PC630.1
  IN2 w0.06: 165.72,124.15 166.24,124.15 v2(166.39,124)
  IN2 w0.084: v2(161.36,128.05) 161.07,127.76 161.07,125.74 162.67,124.14 163.15,124.14 163.33,124.32 163.9,124.32 164.06,124.15 165.72,124.15
N14445031: length 6
  TOP w0.119: v1(166.53,118.03) 166.06,117.56 PR613.1 PC644.1
  IN1 w0.06: v1(167.19,122) 166.99,121.8 166.99,121.07 166.44,120.52 166.44,119.83 166.64,119.64 166.64,119.52
  IN1 w0.089: 166.64,119.52 166.64,118.14 v1(166.53,118.03)
N14455165: length 17
  TOP w0.254: PU801.2 84.44,103.47 v7(84.31,103.34)
  IN2 w0.203: v2(72.82,109.95) 73.17,109.95
  IN2 w0.254: 73.17,109.95 73.35,109.95 74.45,108.85 74.45,107.58 74.28,107.4 74.28,105.98 74.99,105.27 80.02,105.27 81.95,103.34 v7(84.31,103.34)
N14455169: length 17.2
  TOP w0.254: v7(84.94,103.28) PU801.3
  IN2 w0.254: v7(84.94,103.28) 84.94,103.62 84.36,104.2 81.95,104.2 80.45,105.7 78.06,105.7 76.05,107.7 76.05,110.04 75.7,110.4 74.2,110.4 73.82,110.78 73.25,110.78 v2(73.22,110.75)
N14457435: length 0.9
  TOP w0.254: PH1000.1 79.43,93.89 PR1003.2
N14458758: length 17.2
  TOP w0.254: PR810.2 76.52,112.03 PC807.1 77.9,112.03 v7(78.16,112.3) ; PR811.1 89.71,112.19 PR808.2 90.6,113.94 PR809.1 90.05,113.95 v7(89.97,114.03)
  IN2 w0.254: v7(78.16,112.3) 78.24,112.38 80.36,112.38 81.2,113.22 89.34,113.22 89.97,113.85 v7(89.97,114.03)
N14458814: length 0.9
  TOP w0.254: PR809.2 91.48,113.94 PH800.1
N15733786: length 11.2
  IN1 w0.06: 70.11,111.44 70.6,110.95 71.02,110.95 v1(71.22,110.75)
  IN1 w0.254: v2(67.11,110.02) 67.11,110.32 67.47,110.68 67.47,111.15 67.28,111.34 66.85,111.34 66.65,111.53 66.65,111.86 67.09,112.3 68.87,112.3 69.22,111.94 69.61,111.94 70.11,111.44
  IN2 w0.254: v2(67.11,110.02) 66.5,110.63 66.5,111 65.3,112.2 v2(65.3,112.47)
N15737096: length 9.7
  TOP w0.254: v1(78.78,113.88) 78.78,113.9 78.77,113.91 78.77,114.04 PR824.1 78,114.77 77.15,114.77 PC811.1 76.99,114.93 PC809.2 77.86,115.69 PR822.2 ; PU800.A3 74.29,111.55 v1(74.54,111.79)
  IN1 w0.254: v1(74.54,111.79) 74.79,111.79 75.5,112.5 76.16,112.5 77.45,113.8 78.71,113.8 v1(78.78,113.88)
N15739057: length 5.3
  TOP w0.203: PC810.2 76.23,113.6 76.05,113.42 75.19,113.42 74.94,113.17 74.94,111.69 74.4,111.16 74.03,111.16 PU800.A4
  TOP w0.254: PC810.2 PC811.2
N15739351: length 1
  TOP w0.254: PR823.2 78.91,115.53 PC812.1
N15740039: length 12.1
  TOP w0.254: v2(66.16,115.4) 66.95,115.4 PC813.1
  IN2 w0.06: v2(72.42,111.15) 72.22,110.95 70.81,110.95 70.76,110.9 70.49,110.9
  IN2 w0.254: 70.49,110.9 68.51,110.9 68.15,110.55 67.77,110.55 67.54,110.78 67.54,111.01 67.25,111.3 66.81,111.3 65.93,112.18 65.93,112.45 65.59,112.78 65.59,113.47 65.89,113.77 65.89,115.13 v2(66.16,115.4)
N15740054: length 6.3
  IN1 w0.06: v1(72.82,111.55) 72.62,111.75 72.62,112.3 72.57,112.35 72.57,112.68 72.74,112.85
  IN1 w0.254: 72.74,112.85 72.83,112.94 72.83,113.13 73.06,113.37 73.06,115 73.35,115.29 74.29,115.29 74.91,115.91 v1(75.23,115.91)
N15740815: length 0.9
  TOP w0.254: PR831.1 66.15,116.94 PR830.2
N15741283: length 9.8
  IN1 w0.254: v2(67.11,110.9) 66.49,110.28 66.49,109.43 65.31,108.25 v1(65.31,107.63)
  IN2 w0.203: 70.42,110.5 70.44,110.52 71.05,110.52 71.28,110.75 v2(71.62,110.75)
  IN2 w0.254: v2(67.11,110.9) 67.09,110.88 67.09,110.59 68.07,109.61 68.54,109.61 68.71,109.79 68.71,109.84 69.37,110.5 70.42,110.5
N15743484: length 30.9
  TOP w0.254: PR906.1 PR903.2 90.18,125.05 PR904.1 89.72,125.1 v7(89.49,124.87) ; PR905.2 70.78,115.65 v2(70.8,115.67)
  IN2 w0.254: v7(89.49,124.87) 89.49,124.72 89.08,124.32 87.33,124.32 86.9,124.75 84.78,124.75 84,125.53 81.27,125.53 79.86,124.13 79.86,119.76 78.42,118.32 72.2,118.32 70.54,116.66 70.54,115.92 v2(70.8,115.67)
N15743506: length 0.9
  TOP w0.254: PH900.1 PR904.2
N15743562: length 14
  TOP w0.254: PU800.H1 v2(71.22,112.73)
  IN2 w0.254: v2(83.79,115.22) 77.76,115.22 76.79,114.25 73.57,114.25 72.58,113.27 72.14,113.27 71.61,112.73 v2(71.22,112.73)
N15743566: length 14.8
  IN2 w0.254: v2(84.29,115.22) 84.29,114.93 83.94,114.58 78.06,114.58 77.09,113.61 73.86,113.61 72.24,112 71.67,112 v2(71.22,111.55)
N15744978: length 6.7
  TOP w0.254: v1(68.94,115.34) 68.08,115.34 PR917.1
  IN1 w0.06: 70.11,112.94 70.31,112.73 70.86,112.73 71.54,112.05 71.54,111.92 71.82,111.64 71.82,111.35 v1(72.02,111.16)
  IN1 w0.254: v1(68.94,115.34) 69.45,114.83 69.45,113.6 70.11,112.94
N15744990: length 5.2
  IN1 w0.06: 70.04,112 70.4,111.65 70.4,111.57 70.62,111.35 71.02,111.35 v1(71.22,111.15)
  IN1 w0.254: v1(67.11,113.57) 67.49,113.19 68.66,113.19 69.59,112.26 69.79,112.26 70.04,112
N15745096: length 0.9
  TOP w0.254: PR917.2 68.04,116.24 PR918.1
N15745290: length 11.6
  TOP w0.254: PR910.1 73.46,117.7 PR909.2 PR911.1 72.56,117.69 PC906.1 v10(73.45,116.82)
  GND1 w0.254: v10(71.62,111.55) v4(72,111.55) ; v10(73.45,116.82) 73.45,116.78 v4(73.08,116.42)
  IN3 w0.254: v4(73.08,116.42) 72.73,116.42 71.67,115.36 71.67,113.97 72.93,112.71 72.93,112.12 72.36,111.55 v4(72,111.55)
N15745420: length 4.8
  TOP w0.089: PC908.2 PC906.2 72.12,115.46 72.12,112.86 72.42,112.56 PU800.E1
N15745514: length 0.9
  TOP w0.254: PR910.2 PC907.1
N15746436: length 15.9
  TOP w0.254: v1(67.1,109.14) PR815.2 v2(65.59,109.14) ; v2(66.26,101.57) PR820.1
  IN1 w0.06: 69.32,110.4 69.45,110.4
  IN1 w0.089: 69.45,110.4 70.67,110.4 70.71,110.35 v1(71.22,110.35)
  IN1 w0.254: v1(67.1,109.14) 67.1,109.46 67.71,110.07 67.71,110.13 67.98,110.4 69.32,110.4
  IN2 w0.254: v2(66.26,101.57) 66.26,102.21 64.7,103.77 64.7,107.3 65.59,108.19 v2(65.59,109.14)
N15749836: length 2.3
  IN2 w0.254: v2(73.62,111.15) 74.7,111.15 v2(75.6,112.05)
N15749896: length 3.2
  IN2 w0.254: v2(75.6,112.94) 75.04,112.38 73.69,112.38 73.21,111.9 73.21,111.56 v2(73.22,111.55)
N15750253: length 3.3
  IN1 w0.06: v1(72.42,111.55) 72.22,111.75 72.22,112.96 72.12,113.06
  IN1 w0.254: v1(70.78,113.88) 70.78,113.86 71.12,113.52 71.66,113.52 72.12,113.06
N15750329: length 3.5
  IN1 w0.089: 70.52,113.24 70.73,113.03 71.28,113.03 71.55,112.75 71.55,112.29 71.76,112.08 71.76,111.91 72.02,111.65 v1(72.02,111.55)
  IN1 w0.254: 70.52,113.24 70.52,113.25 v1(69.89,113.87)
N15771454: length 3.6
  TOP w0.203: PU400.17 54.57,125.43 PC433.1 PR422.1
N15771478: length 4.3
  TOP w0.203: PC410.2 56.17,131.7 PU400.1
  TOP w0.254: PR402.2 58.17,132.77 58.11,132.77 PC411.1 PC410.2
N15771482: length 4.5
  TOP w0.203: PU400.2 55.77,132.21 PC410.1
  TOP w0.254: PR401.2 57.59,133.54 PC409.2 56.75,133.54 55.78,132.57 PC410.1
N15771644: length 4
  TOP w0.203: PR411.2 PR409.2 53.75,133.19 PR414.1 54.57,131.55 PU400.5
N15771658: length 5.1
  TOP w0.203: PU400.7 53.77,131.15 53.57,131.35 52.13,131.35 PC427.1 51.06,132.37 50.12,133.31 PR412.2
N15771662: length 3
  TOP w0.203: PU400.8 51.94,129.76 PC428.1 PR415.2
N15771682: length 2.8
  TOP w0.203: PU400.9 51.76,129.36 51.42,129.7 PR419.1 PR417.2
N15771750: length 2.2
  TOP w0.203: PU400.10 52.15,128.96 PR416.2
N15771766: length 6.5
  TOP w0.203: PU400.16 54.17,125.98 53.83,125.64 52.38,125.64 51.7,124.95 51.7,124.06 PR425.1 50.25,122.61 PR421.2
N15771786: length 4.2
  TOP w0.203: PR426.2 PR423.2 51.87,126.02 53.57,126.02 53.77,126.21 PU400.15
N15771812: length 2.2
  TOP w0.203: PU400.18 54.97,125.6
  TOP w0.381: PR420.1 54.97,124.44 54.97,125.6
N15773152: length 3.7
  TOP w0.203: PU400.21 56.17,126.01 56.42,125.76 PR418.1
N15773942: length 2.7
  TOP w0.203: PR407.2 51.16,127.03 51.61,127.48 51.61,127.86 52.3,128.56 PU400.11
N15773946: length 3.1
  TOP w0.203: PR408.2 51.99,127.02 51.99,127.73 52.41,128.16 PU400.12
N15915843: length 22.4
  TOP w0.229: v10(127.5,108.27) v1(127,108.27)
  TOP w0.254: RC167.2 112.29,109.32 CC61.1 112.66,110.45 113.42,111.21 v10(113.42,112.12)
  IN1 w0.254: v1(127,108.27) v10(127.5,108.27)
  GND1 w0.119: v4(127.14,108.23) 127.19,108.27 v10(127.5,108.27)
  GND1 w0.254: v10(113.42,112.12) 113.47,112.17 v4(113.98,112.17)
  GND3 w0.254: v4(127.14,108.23) 127.32,108.23 127.82,108.72 127.82,109.74 127.31,110.24 115.53,110.24 114.56,111.21 114.56,111.59 v4(113.98,112.17)
  vias: v9(127.9,108.06) v16(127.5,108.43)
N15989959: length 40.2
  TOP w0.119: PU207.7 78.64,126.37 80.12,127.85 PR209.2 80.02,128.28 79.61,128.68 79.61,129.85 79.33,130.13 74.76,130.13 v2(74.68,130.06)
  TOP w0.254: PR210.2 62.22,148.56 PR214.1 62.53,147.7 62.73,147.49 62.73,146.22 62.39,145.88 v2(62.16,145.88)
  IN2 w0.084: v2(62.16,145.88) 62.16,145.79 63.12,144.83 66.62,144.83 66.93,145.14 67.74,145.14 68.02,144.86 71.65,144.86 75.49,141.02 75.49,130.86 v2(74.68,130.06)
N15989983: length 5
  TOP w0.254: PC219.1 76.45,128.3 PR217.1 ; PC219.1 77.31,126.3 77.89,125.72 PU207.6 ; PC219.1 PR213.2
N15989995: length 14.6
  TOP w0.254: PU207.5 78.91,125.07 79.41,125.56 79.41,126.61 81.01,128.21 PC206.2 81.01,128.3 PR209.1 80.12,130.01 v2(80.17,130.06) ; v2(74.5,129.29) PR212.2
  IN2 w0.254: v2(80.17,130.06) 78.74,130.06 76.91,128.23 75.57,128.23 v2(74.5,129.29)
N15991505: length 2.4
  TOP w0.457: PR207.2 61.73,140.71 61.1,141.34 60.45,141.34 60.13,141.02 PQ205.3
N15991509: length 3
  TOP w0.254: PU203.1 60.77,145.22 61.33,145.79 PC208.1 PR214.2
N16014765: length 2.9
  TOP w0.508: PR503.2 157.5,119.2 158.1,119.79 PC517.1
N16017101: length 2
  TOP w0.508: PR514.2 179.42,128 178.14,129.28 PC538.1
N16020352: length 2.6
  TOP w0.508: PC548.1 188.66,116.33 PR519.2
N16021716: length 1.6
  TOP w0.508: PR504.2 179.05,126.53 PC516.1
N16026836: length 1.5
  TOP w0.508: PC537.1 164.55,136.56 PR513.2
N16031507: length 1.7
  TOP w0.508: PC606.1 171.3,132.42 PR602.2
N16041502: length 2
  TOP w0.508: PR603.2 171.32,114.65 172.32,113.65 PC616.1
N16044927: length 1
  TOP w0.508: PC804.1 PR805.2
N16069065: length 1
  TOP w0.508: PR900.2 82.45,114.71 PC901.1
N16073129: length 0.9
  TOP w0.254: PR911.2 71.66,116.84 PC908.1
N16073217: length 0.9
  TOP w0.254: PR908.2 74.35,116.84 PR909.1
N16074745: length 0.9
  TOP w0.254: PR1008.2 PR1009.1
N16074829: length 0.9
  TOP w0.254: PR1011.2 PC1006.1
N16132066: length 16
  TOP w0.254: v1(44.75,124.8) 44.58,124.97 PQ104.3 ; v1(45.22,115.5) 44.98,115.26 44.98,110.43 PR102.2
  IN1 w0.254: v1(44.75,124.8) 45.09,124.46 45.09,118.56 45.31,118.35 45.31,115.59 v1(45.22,115.5)
N16153353: length 20.4
  TOP w0.119: PR704.2 PR735.2 175.14,109.72 v1(175.14,109.91)
  IN1 w0.06: 165.61,120.02 165.61,120.68 165.89,120.96 166.45,120.96 166.65,121.17 166.65,121.37 166.55,121.47 166.55,121.66 166.79,121.9 v1(166.79,122)
  IN1 w0.089: v1(175.14,109.91) 174.58,109.91 173.21,111.29 172.74,111.29 172.24,111.78 172.24,112.28 171.53,112.99 171.15,112.99 170.61,113.53 169.19,113.53 168.41,114.32 168.41,114.38 167.82,114.97 167.11,114.97 166.45,115.63 166.45,116.14 166.57,116.26 166.57,116.76 166.41,116.93 166.41,117.71 166.25,117.86 166.25,118.14 166.45,118.34 166.45,118.83 166,119.27 166,119.56 165.61,119.95 165.61,120.02
N16156058: length 10.8
  TOP w0.119: PR712.2 164.08,113.46 164.08,113.88 v10(164.1,113.9)
  IN1 w0.06: v1(166.79,121.6) 166.79,121.07 166.17,120.45 166.17,119.69 166.26,119.61 v10(166.25,119.61)
  GND1 w0.119: v4(164.5,113.83) 164.43,113.9 v10(164.1,113.9) ; v4(166.25,120.05) 166.26,120.04 166.26,119.61 v10(166.25,119.61)
  IN3 w0.076: v4(166.25,120.05) 165.94,119.74 165.94,118.68 164.4,117.14 164.4,113.93 v4(164.5,113.83)
N16156133: length 9.4
  TOP w0.076: PU500.P4 166.79,120.95 166.46,120.62 166.46,120.46
  TOP w0.254: v1(165.54,115.86) 164.98,115.3 164.98,113.83 PR713.2 ; 166.46,120.46 166.05,120.05 165.59,120.05 165.08,119.54 PR709.1
  IN1 w0.076: v1(165.17,119.2) 165.17,116.28 165.54,115.91 v1(165.54,115.86)
N16156573: length 9.3
  TOP w0.119: PC714.2 172.6,117.83 v10(173.06,118.28) 173.15,118.19 PR717.1
  GND1 w0.119: v10(173.06,118.28) 173.06,117.99 v4(172.8,117.74)
  IN2 w0.06: v2(168.39,122.4) 168.39,122.12 168.87,121.65 169.35,121.65 169.68,121.32
  IN2 w0.084: 169.68,121.32 170.96,120.04 171.42,120.04 v4(171.51,119.94)
  IN3 w0.076: 171.83,119.62 v4(171.51,119.94)
  IN3 w0.084: 171.83,119.62 172.8,118.65 v4(172.8,117.74)
N16156843: length 10.7
  TOP w0.119: v1(174.45,117.63) 174.82,118.01 PC717.2
  IN1 w0.089: v3(172.79,119.9) 172.79,119.78 174.52,118.04 174.52,117.71 v1(174.45,117.63)
  IN2 w0.06: 169.4,121.32 169.32,121.39 168.94,121.39 168.19,122.14 168.19,122.49 168.32,122.61 168.61,122.61 168.79,122.44 v2(168.79,122.4)
  IN2 w0.084: 169.4,121.32 171.33,119.39 172.28,119.39 v3(172.79,119.9)
N16160539: length 15
  TOP w0.119: v10(177.82,120) 177.9,119.93 179.06,119.93 179.23,120.1 PC701.1 179.23,121.27 PR700.2
  GND1 w0.119: v10(177.82,120) 177.81,120.02 177.81,120.45 v4(177.83,120.48)
  IN2 w0.06: 170.67,124.34 170.49,124.16 169.75,124.16 v2(169.59,124)
  IN2 w0.084: v4(174.83,124.8) 174.47,125.16 171.2,125.16 170.75,124.71 170.75,124.43 170.67,124.34
  IN3 w0.084: v4(177.83,120.48) 177.83,120.49 177.43,120.9 176.99,120.9 176.01,121.87 176.01,123.62 v4(174.83,124.8)
N16160582: length 5.6
  TOP w0.089: v2(165.91,120.38) 165.53,120.38 165.15,120 164.52,120 TC72.1
  IN2 w0.084: v2(167.59,122.4) 167.32,122.67 167.14,122.67 166.94,122.46 166.94,120.68 166.66,120.4 165.93,120.4 v2(165.91,120.38)
N16160613: length 4.5
  IN2 w0.06: 170.49,121.78 170.35,121.92 170.33,121.92 169.91,122.33 169.56,122.33 169.31,122.59 169,122.59 v2(168.39,123.2)
  IN2 w0.084: v2(171.94,120.96) 171.85,120.88 171.39,120.88 170.49,121.78
N16160642: length 5.8
  IN1 w0.06: 164.06,124.62 165.11,124.62 165.53,124.2 166.09,124.2 166.19,124.1 166.19,123.89 166.28,123.8 167.07,123.8 167.47,123.4 167.85,123.4 167.99,123.26 v1(167.99,123.2)
  IN1 w0.089: 164.06,124.62 163.3,124.62 v1(163.05,124.87)
N16160671: length 4.9
  TOP w0.06: v1(169.39,120.82) 169.41,120.82 170.06,120.18
  TOP w0.089: TC79.1 171.18,120.18 170.06,120.18
  IN1 w0.06: v1(168.79,122.8) 168.99,122.6 168.99,121.11 169.27,120.82 v1(169.39,120.82)
N16161077: length 2.1
  TOP w0.06: TC75.1 v1(171.52,122.39)
  IN1 w0.06: v1(169.99,122.4) 170.11,122.4 170.31,122.2 170.33,122.2 170.96,122.2 171.17,122.41 171.5,122.41 v1(171.52,122.39)
N16167521: length 8.7
  TOP w0.089: PR717.2 173.36,119.34 172.27,119.34 v2(171.94,119.67)
  IN2 w0.06: v2(169.19,122.8) 169.27,122.8 169.49,122.57 169.86,122.57 170.29,122.14 170.67,122.14
  IN2 w0.084: 170.67,122.14 170.96,122.14 171.34,122.52 171.88,122.52 172.09,122.31 172.32,122.31 172.73,121.9 172.73,120.45 v2(171.94,119.67)
N16313034: length 2.4
  IN1 w0.06: v1(72.42,109.55) 72.62,109.35 72.62,108.48 72.99,108.11
  IN1 w0.254: 72.99,108.11 73.11,108 73.11,107.48 v1(73.16,107.42)
N16313116: length 20.9
  TOP w0.254: PR715.1 PR714.1 184.78,120.56 v1(184.78,121.31)
  IN1 w0.06: v1(169.59,125.2) 169.79,125.4 170.65,125.4 171.42,126.17 171.61,126.17
  IN1 w0.254: 171.61,126.17 172.62,126.17 172.83,126.38 173.35,126.38 173.78,125.95 173.78,125.61 175.81,123.59 175.81,122.9 176.29,122.42 176.29,122.17 176.94,121.52 177.75,121.52 178.34,120.93 183.8,120.93 184.18,121.31 v1(184.78,121.31)
N16424198: length 7.1
  IN2 w0.06: v2(167.99,123.6) 168.03,123.55 168.73,123.55 168.99,123.29 168.99,123.1 169.09,123 169.61,123 169.74,123.13 170.68,123.13 170.9,123.35
  IN2 w0.084: v2(174.03,124.49) 173.76,124.21 173.11,124.21 172.98,124.34 172.12,124.34 171.64,123.86 171.41,123.86 170.9,123.35
N16424234: length 5
  TOP w0.06: TC71.1 165.74,127.67
  TOP w0.089: 165.74,127.67 v1(165.41,128)
  IN1 w0.06: 165.94,127.03 166.15,126.83 166.4,126.83 166.85,126.39 166.85,126.15 166.99,126.01 166.99,125.47 167.06,125.4 167.79,125.4 v1(167.99,125.2)
  IN1 w0.089: v1(165.41,128) 165.41,127.57 165.94,127.03
N16454224: length 4.1
  IN1 w0.254: v1(74.78,107.3) 75.09,107.6 75.09,108.97 74.11,109.95 v1(73.22,109.95)
N16458110: length 5.6
  IN1 w0.06: v1(72.82,110.75) 72.83,110.75 73.03,110.55 73.78,110.55 73.78,110.55
  IN1 w0.254: v1(75.67,107.3) 75.93,107.55 75.93,109 75.57,109.36 75.42,109.36 74.23,110.55 73.78,110.55
N16458114: length 6.1
  IN1 w0.06: v1(73.22,111.15) 73.52,110.85 74.4,110.85
  IN1 w0.254: v1(76.55,107.3) 76.53,107.32 76.53,109.36 75.67,110.22 75.37,110.22 74.73,110.85 74.4,110.85
N16458329: length 3.9
  IN1 w0.06: v1(71.22,111.95) 71.02,112.15 70.2,112.15 69.75,112.6
  IN1 w0.254: v1(69.02,114.46) 69.02,113.34 69.75,112.6
N16458484: length 5.5
  IN1 w0.089: v1(72.42,111.95) 72.42,113.33 72.37,113.39
  IN1 w0.254: v1(70.78,116.67) 71.23,116.23 71.23,114.69 71.53,114.38 71.71,114.38 72.17,113.92 72.17,113.59 72.37,113.39
N16458488: length 5.9
  IN1 w0.089: v1(72.02,111.95) 72.02,112.04 71.79,112.28 71.79,112.91 71.48,113.22 70.97,113.22 70.44,113.75 70.44,114
  IN1 w0.254: v1(69.89,116.67) 70.44,116.12 70.44,114
N16784816: length 3.3
  TOP w0.119: R54.2 27.39,97.33 R56.2 28.21,96.29 27.95,96.02 Q89.6
N16784922: length 3.8
  TOP w0.254: CA20.1 21.05,17.43 CA21.1 R33.1 21.01,18.55 RA18.2 RA21.2
N16823076: length 28.4
  TOP w0.203: UT1.R13 v7(26.88,36.31)
  IN1 w0.381: v3(23.75,25.21) 23.75,25.17 22.46,23.87 21.32,23.87 19.46,22.02 v1(18.87,22.02)
  IN2 w0.381: v3(23.75,25.21) 25.29,26.74 27.48,26.74 27.98,27.25 28.63,27.25 29.78,28.39 v4(30.61,28.39)
  IN3 w0.356: 28.94,37.49 27.98,37.49 26.88,36.38 v7(26.88,36.31)
  IN3 w0.381: v4(30.61,28.39) 30.61,36.57 29.7,37.49 28.94,37.49
  BOTTOM w0.381: v7(26.88,36.31) 26.83,36.27 C1286.1
N17205976: length 2.9
  TOP w0.119: v13(213.39,144.31) 212.93,144.31 R192.2 212.34,145.27 211.73,145.88 JDEG1.1
N17240183: length 1.9
  TOP w0.089: U34.10 192.02,105.64 C237.1
N17242618: length 4
  TOP w0.119: U41.10 v1(140.13,124.77)
  IN1 w0.089: v1(143,126.03) 142.94,125.98 141.74,125.98 141.22,125.46 140.82,125.46 v1(140.13,124.77)
N17243850: length 1.7
  TOP w0.119: C247.1 34.67,90.97 U32.12
N17302212: length 1.6
  TOP w0.119: C239.1 101.19,84.43 U33.12
N17303797: length 1.6
  TOP w0.119: C1238.1 33.87,90.88 U32.10
N17362824: length 15.6
  TOP w0.119: JVOL1.1 v1(4.45,98.59) ; v1(12.76,91.75) 13.04,92.03 13.04,93.15 13.51,93.62 14.17,93.62 14.52,93.98 R1071.2
  IN1 w0.089: v1(4.45,98.59) 4.45,97.93 10.62,91.75 v1(12.76,91.75)
N17364218: length 8.9
  TOP w0.119: JVOL1.2 4.95,97.93 7.09,95.79 9.66,95.79 10.31,95.14 R1072.2
N17376212: length 16.6
  TOP w0.119: v1(172.17,111.49) 172.17,110.93 172.68,110.42 PR733.2 PR734.2
  IN1 w0.089: v5(169.3,113.26) 170.61,113.26 171.07,112.8 171.45,112.8 171.95,112.3 171.95,111.7 v1(172.17,111.49)
  GND1 w0.119: v4(169.3,113.93) v5(169.3,113.26)
  IN2 w0.084: v4(168.74,119.19) 168.39,119.54 167.87,119.54 167.44,119.97 167.44,120.66 167.16,120.94 167.16,122.37 v2(167.19,122.4)
  IN3 w0.084: v4(168.74,119.19) 168.74,118.88 168.56,118.7 168.56,114.31 168.94,113.93 v4(169.3,113.93)
N17378835: length 20.5
  TOP w0.119: v1(175.61,109.94) 175.62,109.93 176.84,109.93 177.65,109.11 PR737.2
  IN1 w0.06: v1(168.39,122.8) 168.19,122.6 168.19,121.36 168.57,120.97 168.57,120.52 168.65,120.44
  IN1 w0.089: 168.65,120.44 168.65,120.28 169.63,119.3 170.57,119.3 171.46,118.41 171.98,118.41 173.04,117.35 173.04,116.3 172.82,116.07 172.82,112.63 174.06,111.39 175.37,111.39 175.64,111.12 175.64,109.97 v1(175.61,109.94)
N17426516: length 4.1
  IN1 w0.203: v1(70.82,110.75) 70.82,110.75 70.3,110.75 70.04,111.02
  IN1 w0.254: v1(67.11,111.79) 67.44,111.79 67.81,111.43 69.62,111.43 70.04,111.02
N17436424: length 23.1
  TOP w0.254: v10(185.62,118.59) 185.82,118.38 PR746.1 PR747.1
  GND1 w0.254: v10(185.62,118.59) v4(185.24,118.59)
  IN2 w0.254: v2(168.79,124) 168.83,124.04 168.83,124.34 v4(168.88,124.39)
  IN3 w0.254: v4(185.24,118.59) 184.99,118.83 184.99,118.91 184.38,119.52 179.56,119.52 177.91,121.17 177.1,121.17 176.28,121.98 176.28,124.01 174.86,125.43 173.54,125.43 172.61,124.51 172.23,124.51 171.72,124 169.27,124 v4(168.88,124.39)
N17544228: length 2.3
  TOP w0.119: CA104.1 199.68,120.91 200.11,120.91 200.57,121.37 UA2.19
N17544867: length 2.6
  TOP w0.119: UA2.2 206.38,124.97 CA99.1
N17545095: length 2.4
  TOP w0.119: UA2.28 203.58,116.2 CA90.1
N17545649: length 2.6
  TOP w0.119: RA67.2 204.38,116.08 UA2.30
N17587353: length 95.3
  TOP w0.203: UA2.24 201.6,117.76 CA111.1
  TOP w0.254: CA111.1 200.97,117.24 v7(200.49,116.76)
  BOTTOM w0.254: v7(240.1,134.55) 239.83,134.29 235.57,134.29 234.94,134.92 232.95,134.92 232.04,135.82 230.85,135.82 230.08,135.05 226.89,135.05 225.3,133.46 223.87,133.46 217.43,127.02 217.43,124.93 216.64,124.14 213.47,124.14 213.19,123.86 213.19,122.55 212.51,121.88 211.21,121.88 207.07,117.74 204.74,117.74 202.96,115.96 201.29,115.96 v7(200.49,116.76)
  BOTTOM w0.762: 212.48,126.32 213.51,126.32 222.83,135.64 224.36,135.64 226.02,137.3 229.18,137.3 229.89,138.01 233.15,138.01 233.98,138.83 235.68,138.83 235.91,138.6 242.03,138.6 243.71,136.93 243.71,135.64 242.6,134.54 241.45,134.54
  vias: v7(211.77,125.67) v7(211.79,125.1) v7(240.68,134.55)
N17587375: length 503.6
  TOP w0.203: v10(199.57,119.92) 200.18,120.53 201.06,120.53 201.1,120.57 UA2.21
  GND1 w0.254: v10(199.57,119.92) v4(199.57,120.45)
  GND3 w0.254: v4(199.57,120.45) 199.57,120.8 197.94,122.44 195.57,122.44 191.12,126.89 191.12,136.27 188.72,138.67 186.95,138.67 186.44,138.16 182.85,138.16 182.54,137.85 180.36,137.85 180.12,138.1 175.04,138.1 174.64,137.7 v4(174.64,137.5)
  GND3 w0.762: 204.14,117.36 202.84,118.66 196.5,118.66 193.07,122.1 189.76,125.41 189.76,134.62 187.02,137.36 183.23,137.36 182.82,136.95 180.31,136.95 178.74,135.39 172.57,135.39 170.43,137.54 162.34,137.54 162.23,137.65 159.36,137.65 158.88,138.13 154.84,138.13 154.74,138.03 145.2,138.03 139.49,132.32 131.62,132.32 130.94,133 130.94,134.97 127.93,137.98 96.53,137.98 96.35,137.8 78.81,137.8 77.87,138.75 77.87,143.81 72.69,148.99 56.62,148.99 50.85,143.23 46.74,143.23 43.44,139.92 43.44,124.63 42.55,123.74 42.55,111.19 40.67,109.31 40.67,107.2
  IN3 w0.254: v6(96.73,137.4) 96.65,137.47 80.02,137.47 79.57,137.92 v6(71.82,137.92) ; v6(56.58,134.32) 55.57,133.31 52.3,133.31 48.13,129.13 48.13,128.43 48.74,127.82 48.74,124.74 45.55,121.55 45.55,120.46 47.15,118.85 47.15,108.34 47.91,107.58 47.91,106.63 47.32,106.04 44.4,106.04 44.09,105.74 42.6,105.74 41.81,104.95 41.81,103.88 v6(42.16,103.54) ; v4(174.64,137.5) 174.55,137.59 162.3,137.59 162.19,137.49 159.38,137.49 158.81,138.06 151.4,138.06 150.73,137.38 148.51,137.38 148.11,137.78 144.38,137.78 142.19,135.58 141.88,135.58 v6(141.31,135.01)
  BOTTOM w0.254: v6(96.73,137.4) 96.88,137.55 99.22,137.55 99.29,137.47 127.87,137.47 129.56,135.78 129.56,133.22 130.85,131.93 139.72,131.93 141.31,133.51 v6(141.31,135.01) ; v6(56.58,134.32) 56.58,135.05 59.43,137.89 66.51,137.89 68.21,136.19 70.62,136.19 71.82,137.39 v6(71.82,137.92) ; v7(28.48,93.14) 29.6,93.14 32.52,96.06 36.19,96.06 36.65,95.6 36.65,93.56 37.77,92.44 41.7,92.44 43.55,94.3 43.55,102.03 42.16,103.43 v6(42.16,103.54)
  BOTTOM w0.762: 29.17,92.27 29.88,92.27 30.38,91.77 32.84,91.77 33.62,92.55 36.78,92.55 37.56,91.77 42.1,91.77 44.22,93.89 44.22,102.29 43.5,103 43.5,105.39 42.73,106.17 41.59,106.17
  vias: v7(28.48,92.55) v7(40.68,106.5) v7(40.68,105.91) v7(204.84,117.15) v7(204.84,116.57)
N17587387: length 2.7
  TOP w0.762: LA22.1 207.14,117.47 208.67,119
N17587389: length 4.8
  TOP w0.762: LA23.1 208.32,115.73 209.3,116.71 209.3,118.35 209.56,118.6 209.56,118.88
N17744387: length 1.3
  TOP w0.254: U711.8 185.84,103.89 R30.1
N17744537: length 3.4
  TOP w0.254: R1014.1 185.99,105.04 186.8,104.22 U711.7
N17744638: length 1.2
  TOP w0.254: U711.1 186.3,101.39 186.16,101.25 C1224.1
N17750417: length 2.1
  TOP w0.203: RR9.2 27.78,75.83 27.58,76.03 UR1.28
N17794811: length 213.3
  TOP w0.119: v2(172.18,110.31) 173.16,109.33 PR250.1 173.59,108.89 PQ212.1 ; PU208.4 69.48,121.93 PC222.1 ; PU208.4 68.58,122.26 68.3,122.53 66.9,122.53 v2(66.87,122.5) 66.8,122.58 65.97,122.58 PR243.1 ; PU208.4 68.58,121.3 68.61,121.27 68.61,120.73 68.58,120.7 PU208.3 ; v2(70.11,125.26) 70.21,125.26 v2(70.91,124.56) 71.23,124.88 PU206.2
  IN1 w0.089: v3(102.86,137.25) 103.93,138.31 130.2,138.31 130.67,137.84 v3(130.8,137.84)
  IN2 w0.084: v4(192.45,120.43) 192.45,119.84 187.25,114.64 187.25,111.2 186.09,110.05 172.44,110.05 v2(172.18,110.31) ; v2(70.91,124.56) 70.91,124.29 70.36,123.74 68.11,123.74 v2(66.87,122.5) ; v3(102.86,137.25) 102.34,136.73 102.34,135.22 101.65,134.53 98.66,134.53 97.55,135.64 90.05,135.64 89.12,134.71 87.84,134.71 87.45,135.1 85.08,135.1 84.81,135.38 83.51,135.38 83.19,135.06 82.33,135.06 81.49,134.23 79.9,134.23 78.49,132.81 78.49,132.72 77.07,131.3 77.07,128.88 76.82,128.62 76.44,128.62 75.34,129.73 74.53,129.73 74.2,129.4 74.2,129.12 74.38,128.94 74.38,125.57 73.85,125.05 73.41,125.05 73.03,124.67 71.76,124.67 71.38,125.05 70.32,125.05 v2(70.11,125.26) ; v4(192.6,139.12) 192.6,138.39 189.36,135.15 186.82,135.15 186.31,134.64 184.44,134.64 183.55,133.75 172.9,133.75 172.54,134.11 170.55,134.11 170.37,133.93 162.41,133.93 161.89,133.42 160.26,133.42 159.72,132.88 158.41,132.88 158.1,132.56 158.1,131.16 157.75,130.81 155.35,130.81 155.11,131.05 154.76,131.4 154.76,131.4 154.11,132.05 147.02,132.05 146.91,131.94 141.79,131.94 141.45,131.6 132.06,131.6 130.56,133.1 130.56,133.66 129.4,134.82 129.4,135.1 130.18,135.88 130.18,137.22 v3(130.8,137.84)
  IN3 w0.084: v4(192.6,139.12) 192.6,137.28 191.15,135.83 191.15,132.71 190.61,132.18 190.61,125.61 191.42,124.79 191.42,121.46 v4(192.45,120.43)
N17980670: length 3.4
  TOP w0.119: U21.16 68.9,144.78 68.64,144.51 v1(68.57,144.51)
  IN1 w0.089: v1(66.14,144.79) 68.29,144.79 v1(68.57,144.51)
N17980673: length 5.2
  TOP w0.119: U21.17 69.3,144.5 v1(69.21,144.41)
  IN1 w0.089: v1(69.21,144.41) 68.68,143.87 68.36,143.87 68.14,144.09 66.03,144.09 65.55,144.57 v1(65.55,144.79)
N18114885: length 6.1
  TOP w0.254: U713.2 87.4,127.61 87.34,127.55 85.67,127.55 85.19,128.04 R1076.1 84.55,127.48 R1075.2 C1246.2
N18123962: length 1
  TOP w0.305: R74.2 195.42,137.79 C118.2
N18538645: length 2.6
  TOP w0.119: RC31.2 RC48.2 106.94,92.27 107.13,92.08 v7(107.47,92.08)
  BOTTOM w0.119: v7(107.47,92.08) 107.76,91.8 JXDP2.1
N18719906: length 12.1
  TOP w0.229: U20.7 223.1,106.32 222.98,106.21 218.12,106.21 217.99,106.08 R91.2 218.09,105.88 223.4,105.88 223.53,106 U20.8
N18720946: length 8.2
  TOP w0.119: C1249.1 223.48,112.05 224.39,111.13 U20.21
N18800960: length 5.8
  TOP w0.119: RA51.1 24.4,23.92 24.58,23.92 25.1,23.4 28.2,23.4 28.51,23.09 UA1.10
N18895517: length 6.9
  TOP w0.381: PU206.5 66.94,126.18 66.36,126.75 65.35,126.75 65.11,126.51 65.11,124.35 PR243.2 65.77,124.15 66.34,123.58 PR229.1
N19065415: length 5.4
  TOP w0.119: U20.24 223.1,109.85 223.02,109.93 218.54,109.93 C1250.1
N19349133: length 2
  TOP w0.102: L21.2 71.99,147.52 U21.5
N19378285: length 2.3
  GND1 w0.119: v4(18.37,101.91) 18.3,101.99 v10(18.3,102.36)
  GND4 w0.119: v4(18.37,101.91) v9(18.78,101.51)
  BOTTOM w0.119: T38.1 18.93,102.52 18.93,101.66 v9(18.78,101.51)
N19378292: length 1
  GND1 w0.119: v10(17.8,102.36) 17.8,101.92 v4(17.76,101.89)
  GND4 w0.119: v4(17.76,101.89) 18.01,101.63 v9(18.01,101.51)
N19378299: length 2.1
  GND1 w0.119: v4(17.25,101.94) 17.25,102.32 v10(17.3,102.36)
  GND4 w0.119: v4(17.25,101.94) 17.13,101.81 v9(17.13,101.51)
  BOTTOM w0.119: T40.1 17.18,101.56 v9(17.13,101.51)
N19378306: length 1.1
  GND1 w0.119: v4(16.52,101.84) 16.52,102.08 v10(16.8,102.36)
  GND4 w0.119: v4(16.52,101.84) 16.24,101.56 v9(16.24,101.51)
N19388147: length 19.9
  TOP w0.119: RH76.1 145.35,117.69 145.78,117.25 v2(145.78,116.67)
  IN2 w0.06: 138.78,112.78 137.29,112.78 137.24,112.83 136.66,112.83 136.28,112.45 135.63,112.45 134.44,111.26 133.77,111.26 132.96,110.45 132.59,110.45 132.44,110.29 132.44,110.09 132.24,109.89 132.17,109.89 132.01,109.74 132.01,109.53 v2(131.9,109.42)
  IN2 w0.084: 138.78,112.78 139.88,113.89 140.84,113.89 140.95,114 141.72,114 142.04,114.32 142.75,114.32 142.82,114.38 143.72,114.38 143.82,114.28 143.82,114.28 144.02,114.09 145.06,114.09 145.68,114.71 145.68,115.63 145.78,115.73 v2(145.78,116.67)
N19442506: length 5.2
  TOP w0.102: JANT1.1 76.05,148.46 73.77,148.46 L21.1
  TOP w0.119: D95.1 L21.1
N19442543: length 4.5
  TOP w0.102: JANT1.2 JANT1.4 77.46,146.27 77.39,146.2
  TOP w0.119: 77.39,146.2 77.23,146.04 v1(76.5,146.04) ; U21.1 v1(71.99,145.92)
N19518245: length 2.2
  TOP w0.119: C54.1 C53.1 242.27,130.5 242,130.78 U715.1
N19518277: length 1.6
  TOP w0.119: C1248.1 242.85,131.78 U715.3
N19518297: length 4.6
  TOP w0.119: R218.2 R182.2 238.58,131.53 238.83,131.28 238.83,130.68 238.72,130.56 238.7,130.56 C55.1 239.1,130.35 239.52,130.78 U715.6
N19643415: length 1.6
  TOP w0.254: C234.1 37.95,85.25 37.44,85.76 U38.6
N19655746: length 8.7
  TOP w0.254: v1(50.43,116.02) 50.25,116.2 47.69,116.2 47.4,115.91 PQ108.4 ; PR108.1 PR141.2 50.65,113.3 PC124.2 50.64,113.31 v1(50.15,113.81)
  IN1 w0.254: v1(50.15,113.81) 50.15,114.26 50.63,114.74 50.63,115.82 v1(50.43,116.02)
N19659677: length 2
  TOP w0.254: PQ112.2 42.42,120.23 PR131.2 PR132.1
N19725601: length 15.3
  TOP w0.254: PQ103.1 47.26,120.66 46.59,121.33 44.08,121.33 43.47,121.94 41,121.94 40.81,121.75 40.81,119.21 PR107.1 41.15,118.7 40.8,118.35 40.8,117.46 PC122.2 PR139.2 42.2,116.57 41.93,116.3 PQ101.4
N19726626: length 45.5
  TOP w0.254: PQ105.1 43.9,96.99 45.09,98.18 v7(45.65,98.18) ; v2(45.65,115.44) 45.65,115.4 45.33,115.08 45.33,111.02 46.09,110.26 PC121.2 45.54,109.62 PR102.1 PR104.2 44.74,108.44 44.25,107.96 v10(43.92,107.96) ; v1(45.73,121.69) 44.3,121.69 43.58,122.41 PQ111.3
  IN1 w0.254: v2(45.65,115.44) 45.66,115.45 45.66,118.49 45.45,118.71 45.45,121.41 v1(45.73,121.69)
  GND1 w0.254: v10(43.92,107.96) 43.86,108.02 v4(43.86,108.33)
  IN2 w0.254: v2(45.65,115.44) 46.21,114.88 48.87,114.88 51.03,112.72 51.03,110.08 51.57,109.55 v2(51.57,109.52)
  GND4 w0.254: v9(44.33,108.39) 44.27,108.33 v4(43.86,108.33)
  BOTTOM w0.254: v9(44.33,108.39) 44.68,108.03 44.68,107.02 44.47,106.8 44.47,103.4 45.19,102.68 45.19,98.64 v7(45.65,98.18)
