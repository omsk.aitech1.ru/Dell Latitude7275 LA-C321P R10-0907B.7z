# Allegro board LAC321PR10-0907B.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RC144  100_0201_1%  [R_0201]  115.77 92.62 0 top
RC145  0_0402_5%~D  [R0402_0OHM]  117.46 94.27 270 top
RC146  0_0402_5%~D  [R0402_0OHM]  115.4 94.29 270 top
RC147  100_0201_1%  [R_0201]  125.04 99.22 0 bottom
RC148  100_0201_1%  [R_0201]  126.35 98.55 90 bottom
RC149  100_0201_1%  [R_0201]  127.13 98.88 90 bottom
RC150  100_0201_1%  [R_0201]  127.69 98.88 90 bottom
RC151  49.9_0402_1%  [R_0402]  118.34 94.22 270 top
RC152  1K_0402_1%  [R_0402]  114.51 93.37 90 top
RC153  0_0402_5%~D  [R0402_0OHM]  143.67 114.46 0 top
RC154  0_0402_5%  [R_0402]  116.4 88.7 270 top
RC156  0_0603_5%  [R0603_0OHM]  139.11 108.54 180 top
RC157  0.01_0603_1%  [R_0603]  142.35 93.95 90 top
RC158  0_0603_5%  [R0603_0OHM]  139.11 107.32 180 top
RC159  0.01_0603_1%  [R_0603]  146.32 92.87 180 top
RC160  0.01_0603_1%  [R_0603]  151.81 103.28 180 top
RC162  0.01_0603_1%  [R_0603]  151.81 101 180 top
RC163  0.01_0603_1%  [R_0603]  142.54 92.87 180 top
RC164  BLM18EG221SN1D_2P~D  [MURAT_BLM18EG221SN1D_2P]  140.1 109.76 0 top
RC165  0_0402_5%  [R_0402]  140.61 107.72 90 top
RC166  0.01_0603_1%  [R_0603]  139.05 102.21 90 top
RC167  0_0402_5%~D  [R0402_0OHM]  111.39 109.3 0 top
RC199  BLM18EG221SN1D_2P~D  [MURAT_BLM18EG221SN1D_2P]  146.26 94.14 180 top
RC200  49.9K_0201_1%  [R_0201]  143.49 99.18 90 bottom
RC201  49.9K_0201_1%  [R_0201]  141.59 99.18 90 bottom
RC202  10K_0201_5%  [R_0201]  142.22 99.18 90 bottom
RC203  49.9K_0201_1%  [R_0201]  142.86 99.18 90 bottom
RC235  0_0402_5%  [R_0402]  163.93 104.2 270 top
RC237  0_0402_5%  [R_0402]  126.39 86.43 0 top
RC238  1K_0201_5%  [R_0201]  185.16 100.47 0 top
RC239  1K_0201_5%  [R_0201]  185.16 99.45 0 top
RC240  2.2K_0201_5%  [R_0201]  182.43 96.36 90 top
RC241  2.2K_0201_5%  [R_0201]  181.87 96.36 90 top
RC242  100K_0201_5%  [R_0201]  136.79 99.67 180 bottom
RH1  100K_0201_5%  [R_0201]  139.59 93.89 180 top
RH11  22_0201_5%  [R_0201]  139.39 112.81 0 bottom
RH12  22_0201_5%  [R_0201]  140.91 110.26 90 bottom
RH13  8.2K_0201_5%  [R_0201]  145.94 115.48 180 top
RH14  10K_0201_5%  [R_0201]  140.91 114.97 0 top
RH15  8.2K_0201_5%  [R_0201]  145.94 114.84 180 top
RH24  10K_0201_5%  [R_0201]  139.88 107.27 90 top
RH25  10K_0201_5%  [R_0201]  138.66 106.23 0 bottom
RH26  1K_0201_5%  [R_0201]  143.71 124.01 180 top
RH27  10K_0201_5%  [R_0201]  140.82 97.35 270 bottom
RH28  10K_0201_5%  [R_0201]  138.66 109.72 90 bottom
RH29  10K_0201_5%  [R_0201]  163.57 101.79 180 top
RH30  10K_0201_5%  [R_0201]  141.24 114.33 180 top
RH32  2.7K_0201_1%  [R_0201]  137.48 101.05 0 top
RH33  10K_0201_5%  [R_0201]  144.96 109.88 0 bottom
RH35  10K_0201_5%  [R_0201]  144.96 110.51 0 bottom
RH37  10K_0201_5%  [R_0201]  139.97 109.76 180 bottom
RH39  1M_0402_5%  [R_0402]  140.85 98.14 90 top
RH40  0_0201_5%  [R_0201]  145.36 108.03 0 top
RH41  47K_0201_5%  [R_0201]  146.51 108.4 270 top
RH42  20K_0201_5%  [R_0201]  141.5 115.6 180 top
RH44  100K_0201_5%  [R_0201]  139.47 114.97 180 top
RH45  20K_0201_5%  [R_0201]  143.62 117.98 90 top
RH46  100K_0201_5%  [R_0201]  146.51 110.89 270 top
RH47  10K_0201_5%  [R_0201]  146.51 109.67 270 top
RH48  10M_0402_5%  [R_0402]  138.13 119.79 270 top
RH49  10K_0201_5%  [R_0201]  144.6 116.24 0 top
RH50  100K_0201_5%  [R_0201]  145.82 121.57 180 top
RH51  0_0402_5%~D  [R0402_0OHM]  143.67 113.57 0 top
RH52  0_0402_5%~D  [R0402_0OHM]  139.63 96.3 180 top
RH53  0_0402_5%~D  [R0402_0OHM]  144.58 115.35 180 top
RH54  10K_0201_5%  [R_0201]  115.84 96.93 180 bottom
RH55  0_0402_5%~D  [R0402_0OHM]  138.59 113.95 0 top
RH56  0_0402_5%~D  [R0402_0OHM]  146.23 122.33 180 top
RH57  0_0201_5%  [R0201_0OHM]  144.63 120.26 90 top
RH58  0_0201_5%  [R0201_0OHM]  141.55 111.03 0 bottom
RH59  0_0402_5%~D  [R0402_0OHM]  144.13 112.56 180 top
RH60  0_0402_5%~D  [R0402_0OHM]  144.13 111.54 180 top
RH61  0_0402_5%~D  [R0402_0OHM]  112.12 106.28 270 top
RH62  0_0402_5%  [R_0402]  142.35 112.38 270 top
RH63  0_0402_5%~D  [R0402_0OHM]  139.5 113.06 180 top
RH64  1M_0402_5%  [R_0402]  141.79 116.49 180 top
RH66  1K_0201_5%  [R_0201]  111.23 95.58 270 top
RH67  0_0402_5%  [R_0402]  146.28 117.81 90 top
RH68  2.2K_0201_5%  [R_0201]  144.04 120.3 180 top
RH70  2.2K_0201_5%  [R_0201]  136.89 106.12 270 bottom
RH71  2.2K_0201_5%  [R_0201]  137.52 106.12 270 bottom
RH72  2.2K_0201_5%  [R_0201]  139.34 107.6 180 bottom
RH73  2.2K_0201_5%  [R_0201]  139.34 106.97 180 bottom
RH74  1K_0201_5%  [R_0201]  139.81 102.69 270 bottom
RH75  1K_0201_5%  [R_0201]  137.79 102.83 0 bottom
RH76  0_0402_5%~D  [R0402_0OHM]  145.35 117.89 180 top
RH77  0_0402_5%~D  [R0402_0OHM]  142.63 122.51 270 top
RH78  2.2K_0201_5%  [R_0201]  190.37 145.24 90 top
RH79  2.2K_0201_5%  [R_0201]  189.74 145.24 90 top
RH80  2.2K_0201_5%  [R_0201]  115.27 127.88 90 top
RH81  2.2K_0201_5%  [R_0201]  114.64 127.88 90 top
RH82  1K_0201_5%  [R_0201]  144.04 120.94 180 top
RH89  33_0201_1%  [R_0201]  213.06 128.54 270 top
RH90  1K_0201_5%  [R_0201]  210.17 135 90 top
RH91  1K_0201_5%  [R_0201]  211.18 135 90 top
RH92  1K_0201_5%  [R_0201]  137.74 100.24 0 bottom
RH93  1K_0201_5%  [R_0201]  140.4 100.36 0 top
RH94  1K_0201_5%  [R_0201]  141.57 100.53 270 top
RH95  1K_0201_5%  [R_0201]  142.13 100.53 270 top
RH96  1K_0201_5%  [R_0201]  137.74 102.14 0 bottom
RH97  1K_0201_5%  [R_0201]  137.74 101.51 0 bottom
RH98  10K_0201_5%  [R_0201]  139.5 101.51 180 bottom
RH99  1K_0201_5%  [R_0201]  139.59 100.87 180 bottom
RH100  1K_0201_5%  [R_0201]  139.05 102.69 270 bottom
RH101  2.2K_0201_5%  [R_0201]  140.4 96.3 0 top
RH102  150K_0402_5%  [R_0402]  137.45 109 0 bottom
RH105  33_0201_1%  [R_0201]  205.57 131.29 180 top
RH106  33_0201_1%  [R_0201]  205.57 130.72 180 top
RH107  33_0201_1%  [R_0201]  212.48 128.54 270 top
RH108  33_0201_1%  [R_0201]  213.79 135.01 180 top
RH109  33_0201_1%  [R_0201]  139.52 121.47 180 top
RH110  33_0201_1%  [R_0201]  138.25 129.17 0 top
RH111  33_0201_1%  [R_0201]  140.37 122.07 270 top
RH112  33_0201_1%  [R_0201]  143.71 124.6 180 top
RH113  10K_0201_5%  [R_0201]  139.16 97.86 180 top
RH114  10K_0201_5%  [R_0201]  142.25 113.28 0 top
RH115  10K_0201_5%  [R_0201]  142.73 110.36 90 bottom
RH116  10K_0201_5%  [R_0201]  142.77 114.97 180 top
RH117  10K_0201_5%  [R_0201]  144.04 121.57 180 top
RH118  10K_0201_5%  [R_0201]  139.93 107.31 90 bottom
RH119  10K_0201_5%  [R_0201]  139.55 100.24 180 bottom
RH120  10K_0201_5%  [R_0201]  140.4 99.79 0 top
RH122  10K_0201_5%  [R_0201]  138.92 96.08 270 bottom
RH123  10K_0201_5%  [R_0201]  137.52 94.62 270 top
RH124  10K_0201_5%  [R_0201]  136.89 94.62 270 top
RH125  10K_0201_5%  [R_0201]  137.65 96.08 270 bottom
RH126  10K_0201_5%  [R_0201]  139.81 97.35 270 bottom
RH127  100K_0201_5%  [R_0201]  136.85 97.23 270 bottom
RH128  100K_0201_5%  [R_0201]  137.48 107.86 0 bottom
RH129  10K_0402_5%  [R_0402]  229.22 119.07 270 top
RH130  1K_0201_5%  [R_0201]  139.59 98.33 180 bottom
RH131  1K_0201_5%  [R_0201]  139.59 98.94 180 bottom
RH132  10K_0201_5%  [R_0201]  139.16 97.28 180 top
RH133  0_0402_5%~D  [R0402_0OHM]  241.75 107.87 90 top
RH134  10K_0201_5%  [R_0201]  32.23 73.34 90 top
RH136  0_0402_5%~D  [R0402_0OHM]  242.77 107.87 90 top
RH137  0_0402_5%~D  [R0402_0OHM]  243.22 111.84 180 top
RH138  0_0402_5%~D  [R0402_0OHM]  243.22 110.83 180 top
RH139  10K_0402_5%  [R_0402]  159.32 101.51 180 top
RH140  100K_0402_5%  [R_0402]  160.18 102.52 0 top
RH141  100K_0402_5%  [R_0402]  160.18 99.6 0 top
RH142  100K_0402_5%  [R_0402]  158.4 102.52 0 top
RH143  100K_0402_5%  [R_0402]  158.4 99.6 0 top
RH144  10K_0402_5%  [R_0402]  154.46 100.49 0 top
RH145  10K_0402_5%  [R_0402]  159.32 100.49 180 top
RH146  100K_0402_5%  [R_0402]  157.28 101.38 180 top
RH147  100K_0402_5%  [R_0402]  154.46 101.38 0 top
RH148  10K_0201_5%  [R_0201]  162.99 93.98 90 top
RH149  10K_0402_5%  [R_0402]  160.18 100.49 0 top
RH150  10K_0402_5%  [R_0402]  160.18 101.51 0 top
RH151  10K_0201_5%  [R_0201]  163.56 93.98 90 top
RH177  100K_0402_5%  [R_0402]  156.29 99.98 0 top
RH178  100K_0402_5%  [R_0402]  154.46 99.6 0 top
RH179  0_0201_5%  [R_0201]  197 91.47 180 bottom
RH180  0_0201_5%  [R_0201]  197 90.84 180 bottom
RH181  150K_0402_5%  [R_0402]  145.41 113.57 0 top
RH182  100K_0201_5%  [R_0201]  148.19 106.75 270 bottom
RH183  100_0402_5%  [R_0402]  206.78 136.43 0 top
RH184  10K_0402_5%  [R_0402]  142.36 108.15 180 top
RH185  10K_0402_5%  [R_0402]  139.55 106.31 270 top
RH186  0_0201_5%  [R0201_0OHM]  138.09 94.56 270 top
RR1  10K_0201_5%  [R_0201]  29.31 75.55 270 top
RR6  6.2K_0402_1%  [R_0402]  30.7 84.6 270 top
RR9  10K_0201_5%  [R_0201]  27.78 74.96 90 top
RR10  0_0201_5%  [R0201_0OHM]  25.62 83.85 90 top
RR11  0_0201_5%  [R0201_0OHM]  24.35 83.85 90 top
RR12  0_0201_5%  [R0201_0OHM]  24.01 81.23 180 top
RR13  0_0201_5%  [R0201_0OHM]  24.01 79.96 180 top
RR14  0_0201_5%  [R0201_0OHM]  24.01 78.69 180 top
RR15  0_0201_5%  [R0201_0OHM]  24.01 77.42 180 top
RR16  0_0402_5%~D  [R0402_0OHM]  31.19 77.74 90 top
RR17  0_0402_5%~D  [R0402_0OHM]  32.33 77.74 90 top
RT1  0_0402_5%~D  [R0402_0OHM]  25.28 28.41 270 top
RT2  3.01K_0402_1%  [R_0402]  25.74 42.31 90 top
RT3  14K_0402_1%  [R_0402]  26.16 28.41 270 top
RT4  0_0201_5%  [R0201_0OHM]  28.95 27.47 270 top
RT5  0_0201_5%  [R0201_0OHM]  29.53 27.47 270 top
RT6  0_0201_5%  [R0201_0OHM]  22.76 32.44 0 bottom
RT7  0_0201_5%  [R0201_0OHM]  22.97 27.01 270 bottom
RT8  0_0201_5%  [R0201_0OHM]  22.47 27 270 top
RT9  0_0201_5%  [R0201_0OHM]  20.28 30.79 270 bottom
RT10  0_0201_5%  [R0201_0OHM]  21.77 27 270 top
RT11  100_0201_1%  [R_0201]  21.19 26.41 90 top
RT12  100_0201_1%  [R_0201]  32.82 30.54 180 top
RT13  14K_0402_1%  [R_0402]  27.59 44.03 90 top
SW1  TS-A52-3-P1-S017_4P  [SW_TS-A52-3-P1-S017_4P]  202.96 107.9 90 top
T6  PAD~D  [TPC12]  145.28 116.9 0 top
T8  PAD~D  [TPC12]  131.79 109.09 270 bottom
T9  PAD~D  [TPC12]  137.83 117.99 270 top
T10  PAD~D  [TPC12]  144.61 116.9 0 top
T15  PAD~D  [TPC12]  114.66 98.2 90 bottom
T16  PAD~D  [TPC12]  113.39 97.19 90 bottom
T17  PAD~D  [TPC12]  20.45 101.58 90 bottom
T18  PAD~D  [TPC12]  198.86 97.95 90 bottom
T22  PAD~D  [TPC12]  22.05 101.61 180 bottom
T23  PAD~D  [TPC12]  113.65 96.05 0 top
T24  PAD~D  [TPC12]  146.54 111.41 0 top
T25  PAD~D  [TPC12]  140.32 96.81 0 top
T26  PAD~D  [TPC12]  140.54 89.7 0 top
T27  PAD~D  [TPC12]  145.78 116.24 0 top
T28  PAD~D  [TPC12]  144.76 112.56 0 top
T29  PAD~D  [TPC12]  139.02 115.96 0 top
T30  PAD~D  [TPC12]  144.76 111.67 0 top
T31  PAD~D  [TPC12]  146.28 119.41 0 top
T32  PAD~D  [TPC12]  139.55 112.3 0 top
T33  PAD~D  [TPC12]  140.06 114.71 0 top
T34  PAD~D  [TPC12]  143.62 119.41 0 top
T36  PAD~D  [TPC12]  145.14 120.18 0 top
T37  PAD~D  [TPC12]  143.36 111.03 180 bottom
T38  PAD~D  [TPC12]  18.83 102.62 180 bottom
T39  PAD~D  [TPC12]  18.01 101.51 180 bottom
T40  PAD~D  [TPC12]  17.18 102.65 180 bottom
T41  PAD~D  [TPC12]  16.24 101.51 180 bottom
TC3  PAD~D  [TPC12]  139.69 97.52 0 top
TC4  PAD~D  [TPC12]  139.69 97.06 0 top
TC5  PAD~D  [TPC12]  121.19 97.47 180 bottom
TC6  PAD~D  [TPC12]  116.67 94.7 180 bottom
TC7  PAD~D  [TPC12]  119.92 97.7 180 bottom
TC16  PAD~D  [TPC12]  130.28 114.71 0 top
TC17  PAD~D  [TPC12]  124.75 95.92 0 top
TC19  PAD~D  [TPC12]  202.29 126.46 0 top
TC23  PAD~D  [TPC12]  135.87 106.21 180 bottom
TC24  PAD~D  [TPC12]  8.67 46.12 0 top
TC25  PAD~D  [TPC12]  23.13 57.63 0 top
TC26  PAD~D  [TPC12]  135.03 105.16 180 bottom
TC27  PAD~D  [TPC12]  138.87 105.23 90 top
TC28  PAD~D  [TPC12]  9.09 46.12 0 top
TC29  PAD~D  [TPC12]  19.49 49.92 0 top
TC30  PAD~D  [TPC12]  136.33 108.36 180 bottom
TC31  PAD~D  [TPC12]  136 108.8 180 bottom
TC32  PAD~D  [TPC12]  135.59 107.63 180 bottom
TC33  PAD~D  [TPC12]  146.48 107.26 90 top
TC34  PAD~D  [TPC12]  31.67 51.37 0 top
TC35  PAD~D  [TPC12]  22.79 58.4 0 top
TC36  PAD~D  [TPC12]  31.67 50.85 0 top
TC37  PAD~D  [TPC12]  31.1 50.23 0 top
TC38  PAD~D  [TPC12]  31.57 50.22 0 top
TC39  PAD~D  [TPC12]  19.48 50.86 0 top
TC40  PAD~D  [TPC12]  7.83 54.31 0 top
TC41  PAD~D  [TPC12]  19.48 51.34 0 top
TC42  PAD~D  [TPC12]  18.1 51.32 0 top
TC43  PAD~D  [TPC12]  18.1 51.96 0 top
TC62  PAD~D  [TPC12]  138.55 111.35 90 top
TC63  PAD~D  [TPC12]  142.6 110.52 90 top
TC67  PAD~D  [TPC12]  116.01 98.15 180 bottom
TC69  PAD~D  [TPC12]  140.32 100.11 90 bottom
TC70  PAD~D  [TPC12]  142.09 110.52 90 top
TC71  PAD~D  [TPC12]  165.84 127.67 0 top
TC72  PAD~D  [TPC12]  164.32 119.79 0 top
TC73  PAD~D  [TPC12]  163.05 124.87 0 top
TC74  PAD~D  [TPC12]  171.94 120.96 0 top
TC75  PAD~D  [TPC12]  171.94 122.39 0 top
TC77  PAD~D  [TPC12]  164.32 120.3 90 top
TC79  PAD~D  [TPC12]  171.56 119.79 0 top
TC81  PAD~D  [TPC12]  143.49 100.31 180 bottom
TC83  PAD~D  [TPC12]  141.59 100.36 180 bottom
TC87  PAD~D  [TPC12]  142.86 100.31 180 bottom
TC88  PAD~D  [TPC12]  137.27 101.13 180 bottom
TC95  PAD~D  [TPC12]  140.32 112.43 0 top
TC106  PAD~D  [TPC12]  137.27 110.27 0 bottom
TC111  PAD~D  [TPC12]  114.15 111.67 90 top
TC119  PAD~D  [TPC12]  135.9 101.05 90 bottom
TC120  PAD~D  [TPC12]  138.51 98.64 90 bottom
TC121  PAD~D  [TPC12]  136.05 95.31 90 bottom
TC122  PAD~D  [TPC12]  135.95 96.86 90 bottom
TC123  PAD~D  [TPC12]  135.36 98.23 90 bottom
TC124  PAD~D  [TPC12]  134.14 99.22 90 bottom
TC126  PAD~D  [TPC12]  136.19 93.95 90 top
TC128  PAD~D  [TPC12]  137.92 92.82 90 top
TC129  PAD~D  [TPC12]  139.17 95.03 90 top
TC130  PAD~D  [TPC12]  139.06 112.17 90 top
TC131  PAD~D  [TPC12]  139.68 95.03 90 top
TC132  PAD~D  [TPC12]  138.54 112.3 90 top
TC133  PAD~D  [TPC12]  135.41 99.8 90 bottom
TC135  PAD~D  [TPC12]  139.17 95.66 0 top
TC136  PAD~D  [TPC12]  130.85 94.05 180 bottom
TC137  PAD~D  [TPC12]  124.95 100.24 180 bottom
TC138  PAD~D  [TPC12]  138.54 111.79 90 top
TC140  PAD~D  [TPC12]  130.36 109 180 bottom
TC148  PAD~D  [TPC12]  118.55 94.55 180 bottom
TC149  PAD~D  [TPC12]  129.96 100.31 180 bottom
TC150  PAD~D  [TPC12]  126.17 95.84 0 top
TC152  PAD~D  [TPC12]  128.05 100.36 180 bottom
TC153  PAD~D  [TPC12]  130.79 100.62 180 bottom
TC155  PAD~D  [TPC12]  126.6 95.84 0 top
TC163  PAD~D  [TPC12]  140.39 107.08 90 top
TC167  PAD~D  [TPC12]  139.68 95.54 90 top
U3  EDFA164A2MA-GD-F_FBGA253  [EDFA164A1MA-GD-F_FBGA_253P]  111.14 113.45 180 top
U4  EDFA164A2MA-GD-F_FBGA253  [EDFA164A1MA-GD-F_FBGA_253P]  126.24 119.92 90 top
U7  -  [APL3512ABI-TRG_SOT23-5]  171.81 101.71 90 top
U13  -  [SN74AHC1G08DCKR_SC70-5]  241.44 125.91 0 top
U15  -  [NPCT650JAAYX_QFN32_5X5]  196.83 134.87 0 top
U16  TPS68470YFFR_DSBGA56  [TPS68470YFFR_DSBGA_56P]  195.77 141.3 180 top
U18  -  [W25Q128FVPIQ_WSON8]  207.8 133.74 270 top
U20  DE9DS1TR_LGA24_3P5X3  [LSM9DS1TR_LGA24_3P5X3]  222.67 109.41 0 top
U21  -  [SX9306IULTRT_QFN20_3X3]  71.25 145.92 180 top
U23  -  [PS8338BQFN60GTR-A0_QFN60_5X9]  58.23 93.87 180 top
U24  -  [APX9136QFI-TRG_VTDFN6_1P6X1P6]  81.54 137.04 180 top
U27  MEC1641-PZV_TFBGA144  [MEC1641-PZV_TFBGA_144P]  235.81 126.75 270 top
U30  -  [EM5209VF_DFN14_3X2]  234.77 136.56 270 top
U31  -  [APE8937GN2_DFN8_2X2]  193.27 129.07 0 top
U32  -  [EM5209VF_DFN14_3X2]  35.47 94.48 180 top
U33  -  [EM5209VF_DFN14_3X2]  101.99 87.69 180 top
U34  -  [EM5209VF_DFN14_3X2]  190.42 101.9 0 top
U36  -  [EM5209VF_DFN14_3X2]  24.52 66.91 270 top
U37  -  [EM5209VF_DFN14_3X2]  197.58 127.5 180 top
U38  -  [APE8937GN2_DFN8_2X2]  34.82 86.76 270 top
U40  -  [EM5209VF_DFN14_3X2]  155.43 93.37 90 top
U41  -  [EM5209VF_DFN14_3X2]  141.73 127.39 180 top
U709  -  [TPS22961DNYR_WSON8]  100.99 95.04 270 top
U710  -  [TPS22961DNYR_WSON8]  138.82 84.95 0 top
U711  -  [AP22850SH8-7_W-DFN2020-8]  186.3 101.68 0 top
U712  -  [SN74AHC1G08DCKR_SC70-5]  195.96 104.43 180 top
U713  -  [TPS79801QDGNRQ1_MSOP8]  88.61 128.26 270 top
U715  G677L308A31U_ADFN6_1P5x1P5  [G677L308A31U_ADFN6_1P5X1P5]  241.35 130.78 90 top
U716  -  [W25Q80DVZPIG_WSON8]  34.78 30.1 0 top
U717  TPS65982_BGA96  [TPS65982_BGA_96P]  9.42 54.73 0 top
U718  -  [W25Q80DVZPIG_WSON8]  17.72 46.1 180 top
U719  TPS65982_BGA96  [TPS65982_BGA_96P]  22.75 54.48 0 top
U721  -  [APE8937GN2_DFN8_2X2]  92.65 101.95 180 top
UA1  -  [ALC3266-CG_QFN56_7X7]  32.11 22.38 270 top
UA2  ALC1006-CG  [ALC269Q-VC3-GR_QFN48_6X6]  206.78 124.55 180 top
UC1  SKL-Y-REV1P2_BGA1515  [SKL-Y-REV1P2_BGA_1515P-T]  135.42 97.57 180 top
UH1  -  [SN74AHC1G08DCKR_SC70-5]  145.53 108.98 90 top
UH2  -  [SN74AHC1G08DCKR_SC70-5]  100.36 98.75 270 top
UR1  -  [RTS5242-GR_QFN32_4X4]  29.83 78.17 180 top
UT1  AR-4C_BGA337  [AR-4C_BGA_337P-T]  20.19 30.28 270 top
Y1  20MHZ_12PF_7V20000015  [Y_X3G024000DC1H_4P]  199.21 141.66 270 top
Y3  32.768KHZ_9.0PF_9H03200033  [Y_9H03200031_2P]  239.5 126.53 90 top
Y4  25MHZ_20PF_7M25000016  [Y_7M25000016_4P]  19.84 43.57 0 top
YH1  24MHZ_12PF_7V24000020  [Y_X3G024000DC1H_4P]  143.66 97.99 0 top
YH2  32.768KHZ_9.0PF_9H03280012  [Y_9H03220008_2P]  140.72 120.48 270 top

## Library data of the parts
C1 C22 C23 C35 C36 C51 C57 C58 C67 C93 C107 C108 C113-C118 C121 C126 C139 C149 C162 C171 C189-C195 C197-C200 C204 C208 C209 C211-C215 C217 C220 C221 C224 C225 C227 C228 C230 C234 C236 C237 C239 C241 C242 C244 C245 C247 C249 C251 C255 C263 C268 C269 C273 C288-C291 C377 C415 C715 C1224 C1228 C1230 C1231 C1233 C1238 C1246 C1248-C1250 C1259 C1260 C1288-C1291 C1319 C1320 C1328 C1330 C1335 C1336 C1343 C1344 C1346 C1351 C1352 C1358 C1389 C1395 C1396 C1419-C1424 CA31 CA32 CA37 CA43 CA90 CA99 CA102 CA104 CA105 CA111-CA113 CA116 CA117 CC37 CH3-CH8 CR2 CR6 CR11 CR14 CR17 CT3 CT4 MC1 MC2 PC100 PC102 PC103 PC110 PC112 PC114-PC132 PC134 PC203 PC211-PC215 PC217-PC220 PC222-PC227 PC230-PC233 PC300 PC401 PC402 PC410 PC411 PC422 PC427-PC431 PC500 PC502 PC504-PC507 PC518 PC520 PC522-PC524 PC539 PC541 PC542 PC549 PC552-PC556 PC601 PC603-PC605 PC607 PC608 PC617 PC619 PC620 PC630 PC633 PC634 PC636 PC637 PC644-PC646 PC648 PC649 PC701-PC707 PC709 PC711 PC714-PC718 PC800-PC804 PC807-PC813 PC822 PC823 PC900 PC901 PC904-PC911 PC1000 PC1002 PC1004-PC1010 PC1013 PC1014 PC1156-PC1164 PC1250-PC1252 = C_0402
C2 = C_0402: room: EMMC
C3-C11 = C_0402: room: HDMI
C12-C18 = C_0402: room: WIFI
C19-C21 C24 C25 = C_0402: room: NGFF_SSD
C26-C32 = C_0402: room: EC
C33 C34 C100 = C_0402: room: TPM
C37-C40 C42-C46 = C_0201: room: HDD
C41 C47 C50 = C_0603: room: HDD
C48 C49 = C_0402: room: HDD
C52 C65 C90 C104-C106 C110 C148 C153 C179 C196 C1331-C1334 C1337-C1341 C1347-C1350 C1353-C1355 C1387 C1401-C1405 C1431 C1432 CA29 CA33 CA34 CA50 CA51 CA106 CA109 CC21 CT1 CT2 PC111 PC113 PC133 PC135 PC204 PC409 PC414 PC415 PC418 PC419 PC421 PC423 PC424 PC432 PC433 PC436-PC441 PC501 PC508-PC517 PC519 PC528-PC538 PC543-PC548 PC557-PC566 PC600 PC602 PC606 PC609-PC616 PC621-PC629 PC631 PC632 PC638-PC643 PC708 PC710 PC806 PC814 PC903 PC912 PC1003 PC1015 PC1155 PC1166-PC1188 PC1194-PC1203 PC1205-PC1209 PC1245 PC1253 PC1254 = C_0603
C53-C56 C59 C66 C74 C91 C95-C97 C102 C103 C109 C111 C112 C119 C120 C122-C125 C127-C138 C140-C147 C150-C152 C154-C161 C165 C169 C170 C176-C178 C180-C188 C202 C203 C205-C207 C210 C216 C218 C219 C222 C223 C229 C231-C233 C235 C238 C240 C243 C246 C248 C250 C252-C254 C256-C262 C264-C267 C274-C280 C283 C284 C410-C413 C1164 C1222 C1223 C1227 C1229 C1232 C1234-C1237 C1242-C1245 C1251-C1258 C1261-C1287 C1292-C1309 C1315 C1323-C1327 C1329 C1342 C1345 C1359-C1366 C1386 C1388 C1390-C1394 C1397-C1400 C1406-C1418 C1425-C1430 CA6 CA12 CA13 CA30 CA35 CA36 CA38-CA42 CA44-CA49 CA52 CA103 CA107 CA108 CA110 CA114 CA115 CA138 CC28 CC30 CC32-CC36 CC38 CC161-CC164 CH11-CH14 CH16 CH17 CH19-CH28 CH32 CH35 CH36 CH39-CH50 CR1 CR3-CR5 CR15 CR16 CR18-CR23 PC221 PC228 PC229 PC567 PC712 PC713 PC1100-PC1148 PC1151 PC1152 PC1165 PC1189-PC1193 PC1204 PC1210-PC1244 PC1246-PC1249 = C_0201
C68 C73 PC200 = C_0603: room: ETY-ROOM
C69 C71 C72 = C_0201: room: CAM
C70 = C_0402: room: CAM
C75 = C_0603: room: CAM_5M
C76 = C_0402: room: CAM_5M
C77 C78 = C_0201: room: CAM_5M
C79-C81 C83-C85 = C_0402: room: DC1
C82 C92 = C_0201: room: DC1
C87-C89 = C_0201: room: GCLK
C94 = C_0603: room: DC1
C98 = C_0603: room: TP
C99 = C_0402: room: TP
C101 = C_0201: room: TPM
C1384 C1385 = C_A
CA1 CA3 CA5 = C_0603: room: AUDIO
CA2 CA4 CA9 CA15 CA20 CA23 CA26 CA28 = C_0201: room: AUDIO
CA10 CA11 CA16-CA19 CA21 CA22 CA24 CA25 CA27 = C_0402: room: AUDIO
CC9 CC16-CC19 CC23-CC26 CC31 CC43 CC44 CC48 CC52 CC53 CC59 CC60 CC62-CC116 CC119-CC132 CC134 CC135 CC158 = C_0201: room: CPU
CC20 CC22 CC51 CC61 CC118 CC133 = C_0603: room: CPU
CC42 CC54 CC117 = C_0402: room: CPU
CLRP3 CLRP4 R181 = SHORTPADS: User Part Number: PART#
CR7 = C_0201: room: CARD READER
CR8 = C_0402: room: CARD READER
D1 = BAT54CW-7-F_SOT323-3: room: HDMI
D2 D3 = BAT54CW-7-F_SOT323-3: room: USB3_P1
D4 = PJSOT24CW_SOT323-3: room: PBTN
D5 DA7 = PJSOT24CW_SOT323-3
D6 = AOZ8904CIL_SOT23-6
D8 = BAT54A-7-F_SOT23-3
D10 D11 = BAT54CW-7-F_SOT323-3
D17 DI6 DI7 = PESD24VS2UT_SOT23-3
D22 D23 D100 D101 = SDMK0340L-7-F_SOD323-2
D74 = TPD2EUSB30DRTR_SOT3
D75-D90 D407-D423 = ESD101-B1-02ELS_TSSLP-2-4-2
D95 = L06ESDU5V0CE2_SOD-882-2
D406 PD102-PD108 PD201 PD202 PD204 PD205 PD301 PD302 PD400-PD403 = RB520SM-30T2R_EMD2-2
D424 D425 = ESD3V3S1B-02LS_PG-TSSLP-2-1-2
DA1 = ESD207-B1-02EL_TSLP-2-19-2: room: AUDIO
DA2-DA4 DA8 = ESD207-B1-02EL_TSLP-2-19-2
DA5 DA6 DI4 DI5 PD100 PD101 = TVNST52302AB0_SOT523-3
DH5 DH6 = RB751S40T1G_SOD523-2
FD1-FD4 = FIDUCIAL_C40M80: room: ETY-ROOM
H1 H2 H4-H7 = H_4P6: room: ETY-ROOM
H8 H9 = H_1P2: room: ETY-ROOM
H10 = H_1P3X2P3
H11 = H_1P3
H13-H22 H25-H34 = H_2P0X0P4N
H23 = H_4P6
H24 = H_5P2
J3 = HRS_DF40C-24DS-0P4V-51_24P-T
JANT1 = BELLW_10093-1021_4P
JAPS2 JSER = ACES_50506-01841-P01_18P
JAR1 = ACES_50281-00601-001_6P
JBAT100 = ACES_50278-01001-001_10P
JCAM2 = STARC_111D10-000000-G4-R_10P
JCR1 = T-SOL_158-1000902614_23P-T
JDEBUG1 JDEG1 JHP1 JITOUCH JLPDE1 = ACES_50521-01041-P01_10P
JDMIC1 = HRS_DF40B-12DS-0P4V-51_12P-T
JLVDS1 = ACES_50398-05071-001_50P-T
JNGFF1 = LOTES_APCI0133-P001A_67P-T
JNGFF2 = LOTES_APCI0170-P001A_75P-T
JNGFF3 = LOTES_APCI0114-P001A_67P
JP1 = HRS_DF37NC-30DS-0P4V-51_30P-T
JPA1-JPA3 R134 R135 R160 R164 R166 R176 R179 R184 R219 R228 R231 R924 R1025 R1028 R1035 R1036 R1038 R1039 R1095 R1096 R1104 R1107 R1410 R1417 R1430-R1432 R1435-R1438 R1457 R1458 R5669 R5682 R5712 R5713 RA49-RA57 RA60 RA61 RA63 RA65 RA66 RC71 RC72 RC140 RC167 RH51-RH53 RH55 RH56 RH59-RH61 RH63 RH76 RH77 RH133 RH136-RH138 RR16 RR17 RT1 = R0402_0OHM
JPA4 PH800 PH900 PH1000-PH1003 PR104-PR106 PR111 PR115 PR118 PR119 PR124-PR153 PR155 PR157-PR162 PR200-PR232 PR237 PR240-PR251 PR254-PR259 PR300-PR304 PR401 PR402 PR404 PR405 PR407-PR409 PR411 PR412 PR414-PR421 PR423-PR428 PR500-PR502 PR506 PR508-PR512 PR515-PR518 PR520 PR600 PR601 PR605 PR606 PR608-PR610 PR613 PR700 PR709-PR711 PR714 PR715 PR717 PR719 PR741 PR745 PR800-PR806 PR808-PR838 PR900 PR901 PR903-PR911 PR913-PR915 PR917-PR921 PR1000 PR1002-PR1022 PR1024-PR1029 R9 R18 R19 R21 R22 R63 R67 R68 R78-R80 R82 R92 R100-R102 R105-R107 R119 R120 R133 R136 R138 R142 R143 R157 R165 R180 R182 R192 R218 R716 R1012 R1013 R1027 R1029 R1030 R1043 R1069 R1075 R1076 R1091-R1094 R1097-R1101 R1106 R1109 R1115 R1116 R1118 R1121 R1127 R1128 R1132-R1135 R1217 R1377 R1378 R1387 R1434 R1439 R1440 R1445 R1449 R1450 R1454 R1459-R1464 R1468 R1473-R1485 R5588 R5674 R5675 R5683 R5702 R5714-R5716 R5739 R5742 R5743 R5745 R5746 R5758 R5761 R5762 RA6 RA30-RA33 RA72 RA78 RA79 RC18-RC20 RC23-RC26 RC28 RC29 RC31 RC34-RC42 RC48 RC53-RC55 RC61 RC73 RC75-RC77 RC80 RC89 RC165 RC235 RC237 RH39 RH48 RH62 RH64 RH67 RH102 RH129 RH139-RH147 RH149 RH150 RH177 RH178 RH181 RH183-RH185 RT2 RT3 RT13 = R_0402
JPB1 = ACES_50506-00641-P01_6P
JPOGO = PANAS_AXT580124_80P-T
JRTC1 = ACES_50278-00201-001_2P
JSIM1 = JAE_SF56S006V4A_6P-T
JSPI1 = ACES_50696-0200M-P01_20P
JSPK1 JSPK2 JVB1 = ACES_50208-00201-P03_2P
JUSBC1 JUSBC2 = JAE_DX07B024XJ1_24P-T
JVOL1 = ACES_50521-00541-P01_5P
JXDP2 = SAMTE_BSH-030-01-L-D-A-TR_60P-S
L1 L2 = MURAT_BLM15AX100SN1D_2P: room: HDMI
L3 L4 = MURAT_BLM15PX330SN1D_2P: room: HDMI
L17 = TOKO_1269AS-H-1R0M-P2_2P
L19 = KC_FBMA-L11-160808-800LMT_2P
L21 = MURAT_LQG15HS10NJ02D_2P
L23-L26 L28-L33 ML1 ML2 ML9 = MURAT_DLW21HN900HQ2L_4P
L27 = CHILI_CMMI21T-900Y-N_4P
L57-L61 = TAIYO_MCF12102G900-T_4P
L62 LR1 = KC_WCM-2012HS-900T_4P
L63 = MAG_MND-04ABIR60M-XGL_2P
L64 LA18 LA19 PR406 PR422 R75 R115-R118 R200-R202 R204-R206 R211 R212 R216 R221 R222 R224 R227 R229 R234 R327 R514 R515 R1070 R1422 R1423 R1427 R1428 R5673 R5705 R5717 R5718 R5729 RC157 RC159 RC160 RC162 RC163 RC166 = R_0603
LA1 = MURAT_BLM21PG600SN1D_2P: room: AUDIO
LA2-LA4 RA27 = R_0603: room: AUDIO
LA20-LA23 RC156 RC158 = R0603_0OHM
LT1 LT2 LT105 LT106 PL100 PL101 PL400 PL500 PL501 PL504 PL505 PL508 PL600 PL601 PL604 = TAI-T_HCB2012KF-121T50_2P
MD1 = TVWDF1004AD0_DFN9
MD4 MD6 = RCLAMP0524PATCT_SLP2510P8-10-9
ML3 ML4 ML11-ML13 ML15 = MURAT_DLW21SN670HQ2L_4P
ML5-ML7 = INPAQ_MCM1012B900F06BP_4P
ML14 = SW_WCM2012F2S_4P
PC101 PC105-PC109 PC201 PC202 PC205-PC209 = C_0402: room: ETY-ROOM
PC400 PC403-PC408 PC425 PC426 PC434 PC503 PC521 PC525-PC527 PC540 PC550 PC551 PC618 PC635 PC700 PC817 PC820 PC1017 PC1018 = C_0805
PC442-PC444 PC818 PC821 PC824 = C_B3
PD203 = PD3S230L-7_POWERDI323-2
PJP500 PJP602 PJP603 = JUMP_43X79
PJP501 PJP503 PJP600 PJP601 = JUMP_43X39
PJP502 PJP504 = JUMP_43X118
PL401 = CYNTE_PCME061E-1R0MS_2P
PL502 = CYNTE_PCMB041B-1R0MS_2P
PL503 = TOKO_1239AS-H-1R0M-P2_2P
PL506 = MAG_MMD-04AE-R47M-M1L_2P
PL507 PL602 PL603 = TOKO_1239AS-H-2R2N-P2_2P
PL509 = MAG_MMD-05ABHR47M-T1L_2P
PL605 PL607 = MAG_MMD-04AB-R47M-V2_2P
PL802 PL902 = CYNTE_PIME051E-R22MS3R805_2P
PL1001 = MAG_MMD-05ABHR47MET1L_2P
PQ100 PQ101 PQ107 PQ108 PQ202 PQ203 PQ207 PQ208 PQ401 = AON7405_DFN8-5
PQ103 PQ105 = SI2303CDS-T1-GE3_SOT23-3
PQ104 PQ109 PQ110 PQ115 PQ120 PQ204-PQ206 PQ214 PQ402 Q86 Q89 Q345-Q349 QA1 = DMN66D0LDW-7_SOT363-6
PQ111 PQ112 = DCX124EU-7-F_SOT363-6
PQ113 PQ114 PQ209 PQ211 = AO3413_SOT23-3
PQ210 Q25 Q43 Q68 Q340 Q343 QR1 = SSM3K7002FU_SC70-3
PQ212 = SI2336DS-T1-GE3_SOT23-3
PQ300 = DMN65D8LW-7_SOT323-3
PQ400 PQ500-PQ502 PQ600 PQ601 PQ800 PQ900 PQ1000 = AON7934_DFN3X3A8-10
PR102 PR103 PR107 PR108 PR116 PR117 PR120-PR123 = R_0402: room: ETY-ROOM
PR109 PR110 PR112 PR113 PR156 PR233-PR236 PR238 PR239 PR252 PR253 PR305-PR307 PR505 PR507 PR703 PR704 PR712 PR713 PR718 PR733-PR740 PR742 PR746 PR747 R1-R8 R10-R12 R61 R62 R64 R74 R83-R85 R103 R104 R108-R112 R126 R127 R129 R137 R161 R162 R167-R175 R177 R178 R183 R185-R191 R193-R199 R203 R207-R210 R213-R215 R217 R220 R223 R225 R232 R238 R389 R391 R392 R395 R396 R398 R1014 R1032-R1034 R1037 R1040 R1041 R1044-R1050 R1053 R1055-R1057 R1059-R1068 R1071 R1072 R1074 R1079-R1083 R1087 R1136 R1138 R1224 R1225 R1379-R1386 R1388-R1409 R1411-R1416 R1418-R1421 R5670 R5671 R5676 R5677 R5684-R5696 R5698-R5701 R5703 R5704 R5706-R5709 R5711 R5719 R5722 R5723 R5726-R5728 R5730-R5732 R5734 R5736 R5738 R5750-R5752 R5754-R5757 R5759 R5760 RA25 RA62 RA64 RA67 RA70 RA71 RA77 RC6 RC7 RC16 RC22 RC27 RC32 RC33 RC43 RC44 RC49-RC52 RC62 RC63 RC65-RC70 RC86 RC88 RC91 RC136 RC141 RC142 RC147 RC148 RC150 RC200-RC203 RC238-RC242 RH1 RH11-RH15 RH24-RH30 RH32 RH33 RH35 RH37 RH40-RH42 RH44-RH47 RH49 RH50 RH54 RH66 RH68 RH70-RH75 RH78-RH82 RH89-RH101 RH105-RH120 RH122-RH128 RH130-RH132 RH134 RH148 RH151 RH179 RH180 RH182 RT11 RT12 = R_0201
PR165-PR167 PR503 PR504 PR513 PR514 PR519 PR602 PR603 PR607 PR611 PR807 PR839-PR841 PR902 PR1001 RA68 RA69 = R_0805
PR400 PR410 = R_1206_4P-D
PR403 PR413 R1424 = R_1206
PR604 PR612 R34 R36 R38 R39 R57 R399 R400 R1015-R1017 R1443 R1444 R1466 R1467 R5720 R5721 R5724 R5725 R5741 R5753 RH57 RH58 RH186 RR10-RR15 RT4-RT10 = R0201_0OHM
PU100 = TLV1702AIDGKR_VSSOP8
PU101 PU204 U712 UH1 UH2 = SN74AHC1G08DCKR_SC70-5
PU102 PU200 PU202 = RT9069-33GB_SOT23-5
PU201 PU203 PU205 PU209 = P_SN74LVC1G02DCKR_SC70_5P
PU206 PU207 = LM393DMR2G_MICRO8
PU208 = OPA376AIDCKR_SC70-5
PU300 = SN74LVC1G123DCUR_VSSOP8
PU400 = BQ24777RUYR_WQFN28_4X4
PU500 = BD99992GW-E2_UCSP55M5C195
PU800 = BD99991GW-E2_UCSP55M4C99
PU801 PU901 = BD9515NUX-E2_VSON008X2020-8
Q10 = DMN2400UV-7_SOT-563-6
Q27-Q31 = MMBT3904WH_SOT323-3
Q330 Q344 = DMP3099L-7_SOT23-3
Q341 Q342 QT19-QT21 = PMDXB600UNE_DFN1010B-6
QT18 = DMN2400UFB4-7_DFN1006H4-3
R13 = R_0201: room: EMMC
R14-R17 R25 = R_0201: room: HDMI
R24 = R_0603: room: HDMI
R29 R31 R32 = R_0201: room: WIFI
R30 = R_0603: room: WIFI
R33 = R_0402: room: WIFI
R35 R37 R44 R45 R48 = R_0402: room: NGFF_SSD
R40 = R0402_0OHM: room: NGFF_SSD
R41-R43 R46 R47 = R_0201: room: NGFF_SSD
R49 R51 R54 R59 = R_0402: room: EC
R50 R55 R58 = R0201_0OHM: room: EC
R52 R60 = R_0201: room: EC
R53 R56 = R0402_0OHM: room: EC
R65 = R_0402: room: SENSOR
R66 = R0402_0OHM: room: HDD
R69 R73 = R_0201: room: HDD
R70 R71 = MURAT_BLM15HG601SN1D_2P
R72 = R_0402: room: HDD
R76 R77 R81 = R_0603: room: HDD
R86 R87 R90 = R_0402: room: USB3_P1
R88 R89 = R0402_0OHM: room: USB3_P1
R91 = R_0201: room: USB3_P1
R93-R95 R121 R124 R125 = R_0402: signal model: R_0402_0_0402_5%~D
R130 = R_0201: room: DC1
R155 = R_0402: room: NFC
R156 = R0402_0OHM: room: NFC
R5678-R5681 = R0402_0OHM: signal model: R_0402_0_0402_5%
RA1-RA5 RA7 RA18 RA21 = R_0402: room: AUDIO
RA13-RA15 RA17 RA19 RA23 RA24 RA26 RA28 = R_0201: room: AUDIO
RA73-RA76 = MURAT_BLM15PX181SN1D_2P
RC2 RC3 RC5 RC10 RC12 RC14 RC15 RC45-RC47 RC64 RC81-RC83 RC90 RC97 RC98 RC139 RC144 RC149 = R_0201: room: CPU
RC4 RC8 RC9 RC11 RC13 RC56-RC60 RC79 RC84 RC85 RC87 RC102 RC143 RC151 RC152 RC154 = R_0402: room: CPU
RC106 RC145 RC146 RC153 = R0402_0OHM: room: CPU
RC128 = R_0603: room: CPU
RC164 RC199 = MURAT_BLM18EG221SN1D_2P
RR1 RR9 = R_0201: room: CARD READER
RR6 = R_0402: room: CARD READER
SW1 = SW_TS-A52-3-P1-S017_4P: room: PBTN
T6 = TPC12: room: WIFI
T8 T9 = TPC12: room: NGFF_SSD
T10 = TPC12: room: EC
T15-T18 T22-T34 T36-T41 TC17 TC19 TC24 TC25 TC27-TC29 TC34-TC43 TC62 TC63 TC67 TC69-TC75 TC77 TC95 TC106 TC111 TC119-TC124 TC126 TC128-TC133 TC138 TC140 TC163 TC167 = TPC12
TC3-TC7 TC16 TC23 TC26 TC30-TC33 TC79 TC81 TC83 TC87 TC88 TC135-TC137 TC148-TC150 TC152 TC153 TC155 = TPC12: room: CPU
U3 = EDFA164A1MA-GD-F_FBGA_253P: room: HDMI
U4 = EDFA164A1MA-GD-F_FBGA_253P: room: WIFI
U7 = APL3512ABI-TRG_SOT23-5: room: USB3_P1
U13 = SN74AHC1G08DCKR_SC70-5: room: GCLK
U15 = NPCT650JAAYX_QFN32_5X5
U16 = TPS68470YFFR_DSBGA_56P
U18 = W25Q128FVPIQ_WSON8
U20 = LSM9DS1TR_LGA24_3P5X3
U21 = SX9306IULTRT_QFN20_3X3
U23 = PS8338BQFN60GTR-A0_QFN60_5X9
U24 = APX9136QFI-TRG_VTDFN6_1P6X1P6
U27 = MEC1641-PZV_TFBGA_144P
U30 U32-U34 U36 U37 U40 U41 = EM5209VF_DFN14_3X2
U31 U38 U721 = APE8937GN2_DFN8_2X2
U709 U710 = TPS22961DNYR_WSON8
U711 = AP22850SH8-7_W-DFN2020-8
U713 = TPS79801QDGNRQ1_MSOP8
U715 = G677L308A31U_ADFN6_1P5X1P5
U716 U718 = W25Q80DVZPIG_WSON8
U717 U719 = TPS65982_BGA_96P
UA1 = ALC3266-CG_QFN56_7X7: room: AUDIO
UA2 = ALC269Q-VC3-GR_QFN48_6X6
UC1 = SKL-Y-REV1P2_BGA_1515P-T
UR1 = RTS5242-GR_QFN32_4X4: room: CARD READER
UT1 = AR-4C_BGA_337P-T
Y1 = Y_X3G024000DC1H_4P: room: GCLK
Y3 = Y_9H03200031_2P
Y4 = Y_7M25000016_4P
YH1 = Y_X3G024000DC1H_4P
YH2 = Y_9H03220008_2P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
ACES_50208-00201-P03_2P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0)
  rect 1.194x1.702 smd: 3(-1.3,-1.95) 4(2.1,-1.95)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50278-01001-001_10P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0)
  rect 1.295x3.353 smd: 11(-2.85,-4.925) 12(14.1,-4.925)
ACES_50281-00601-001_6P
  oval 0.787x2.007 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0)
  rect 2.007x2.489 smd: 7(-2.2,-4.05) 8(8.45,-4.05)
ACES_50398-05071-001_50P-T
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0) 41(20,0) 42(20.5,0) 43(21,0) 44(21.5,0) 45(22,0) 46(22.5,0) 47(23,0) 48(23.5,0) 49(24,0) 50(24.5,0)
  rect 1.194x3.2 smd: 51(-2.4,1.95) 55(26.9,1.95)
  rect 2.311x1.295 smd: 52(0.85,3.9) 53(12.25,3.9) 54(23.65,3.9)
ACES_50506-00641-P01_6P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.991x2.007 smd: 7(-2.1,-3.05) 8(4.6,-3.05)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-00541-P01_5P
  oval 0.305x0.787 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0)
  rect 0.406x0.787 smd: 6(1,-2.5) 7(-3,-2.5)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50696-0200M-P01_20P
  oval 0.305x0.787 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.406x0.787 smd: 21(1,-2.5) 22(-10.5,-2.5)
ALC269Q-VC3-GR_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 4.394x4.394 smd: 49(2.2,2.975)
ALC3266-CG_QFN56_7X7
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
AO3413_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ8904CIL_SOT23-6
  oval 0.635x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0.95,2.4) 6(0,2.4)
AP22850SH8-7_W-DFN2020-8
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.21) 6(1,2.21) 7(0.5,2.21) 8(0,2.21)
  rect 1.6x0.889 smd: 9(0.75,1.105)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
APL3512ABI-TRG_SOT23-5
  oval 0.61x1.041 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.7) 5(0,2.7)
APX9136QFI-TRG_VTDFN6_1P6X1P6
  oval 0.254x0.737 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.86) 5(0.5,1.86) 6(0,1.86)
  rect 0.991x0.61 smd: 7(0.5,0.93)
AR-4C_BGA_337P-T
  round 0.254 smd: A1(0,0) A23(-10.12,0) AA2(-0.46,9.2) AA22(-9.66,9.2) AB2(-0.46,9.66) AB3(-0.92,9.66) AB4(-1.38,9.66) AB5(-1.84,9.66) AB6(-2.3,9.66) AB7(-2.76,9.66) AB8(-3.22,9.66) AB9(-3.68,9.66) AB10(-4.14,9.66) AB11(-4.6,9.66) AB12(-5.06,9.66) AB13(-5.52,9.66) AB14(-5.98,9.66) AB15(-6.44,9.66) AB16(-6.9,9.66) AB17(-7.36,9.66) AB18(-7.82,9.66) AB19(-8.28,9.66) AB20(-8.74,9.66) AB21(-9.2,9.66) AB22(-9.66,9.66) AC1(0,10.12) AC23(-10.12,10.12) B2(-0.46,0.46) B3(-0.92,0.46) B4(-1.38,0.46) B5(-1.84,0.46) B6(-2.3,0.46) B7(-2.76,0.46) B8(-3.22,0.46) B9(-3.68,0.46) B10(-4.14,0.46) B11(-4.6,0.46) B12(-5.06,0.46) B13(-5.52,0.46) B14(-5.98,0.46) B15(-6.44,0.46) B16(-6.9,0.46) B17(-7.36,0.46) B18(-7.82,0.46) B19(-8.28,0.46) B20(-8.74,0.46) B21(-9.2,0.46) B22(-9.66,0.46) C2(-0.46,0.92) C22(-9.66,0.92) D2(-0.46,1.38) D4(-1.16,1.16) D5(-1.81,1.16) D6(-2.46,1.16) D8(-3.11,1.16) D9(-3.76,1.16) D11(-4.41,1.16) D12(-5.06,1.16) D13(-5.71,1.16) D15(-6.36,1.16) D16(-7.01,1.16) D18(-7.66,1.16) D19(-8.31,1.16) D20(-8.96,1.16) D22(-9.66,1.38) E2(-0.46,1.84) E4(-1.16,1.81) E5(-1.81,1.81) E6(-2.46,1.81) E8(-3.11,1.81) E9(-3.76,1.81) E11(-4.41,1.81) E12(-5.06,1.81) E13(-5.71,1.81) E15(-6.36,1.81) E16(-7.01,1.81) E18(-7.66,1.81) E19(-8.31,1.81) E20(-8.96,1.81) E22(-9.66,1.84) F2(-0.46,2.3) F4(-1.16,2.46) F5(-1.81,2.46) F6(-2.46,2.46) F8(-3.11,2.46) F9(-3.76,2.46) F11(-4.41,2.46) F12(-5.06,2.46) F13(-5.71,2.46) F15(-6.36,2.46) F16(-7.01,2.46) F18(-7.66,2.46) F19(-8.31,2.46) F20(-8.96,2.46) F22(-9.66,2.3) G2(-0.46,2.76) G22(-9.66,2.76) H2(-0.46,3.22) H4(-1.16,3.11) H5(-1.81,3.11) H6(-2.46,3.11) H8(-3.11,3.11) H9(-3.76,3.11) H11(-4.41,3.11) H12(-5.06,3.11) H13(-5.71,3.11) H15(-6.36,3.11) H16(-7.01,3.11) H18(-7.66,3.11) H19(-8.31,3.11) H20(-8.96,3.11) H22(-9.66,3.22) J2(-0.46,3.68) J4(-1.16,3.76) J5(-1.81,3.76) J6(-2.46,3.76) J8(-3.11,3.76) J9(-3.76,3.76) J11(-4.41,3.76) J12(-5.06,3.76) J13(-5.71,3.76) J15(-6.36,3.76) J16(-7.01,3.76) J18(-7.66,3.76) J19(-8.31,3.76) J20(-8.96,3.76) J22(-9.66,3.68) K2(-0.46,4.14) K22(-9.66,4.14) L2(-0.46,4.6) L4(-1.16,4.41) L5(-1.81,4.41) L6(-2.46,4.41) L8(-3.11,4.41) L9(-3.76,4.41) L11(-4.41,4.41) L12(-5.06,4.41) L13(-5.71,4.41) L15(-6.36,4.41) L16(-7.01,4.41) L18(-7.66,4.41) L19(-8.31,4.41) L20(-8.96,4.41) L22(-9.66,4.6) M2(-0.46,5.06) M4(-1.16,5.06) M5(-1.81,5.06) M6(-2.46,5.06) M8(-3.11,5.06) M9(-3.76,5.06) M11(-4.41,5.06) M12(-5.06,5.06) M13(-5.71,5.06) M15(-6.36,5.06) M16(-7.01,5.06) M18(-7.66,5.06) M19(-8.31,5.06) M20(-8.96,5.06) M22(-9.66,5.06) N2(-0.46,5.52) N4(-1.16,5.71) N5(-1.81,5.71) N6(-2.46,5.71) N8(-3.11,5.71) N9(-3.76,5.71) N11(-4.41,5.71) N12(-5.06,5.71) N13(-5.71,5.71) N15(-6.36,5.71) N16(-7.01,5.71) N18(-7.66,5.71) N19(-8.31,5.71) N20(-8.96,5.71) N22(-9.66,5.52) P2(-0.46,5.98) P22(-9.66,5.98) R2(-0.46,6.44) R4(-1.16,6.36) R5(-1.81,6.36) R6(-2.46,6.36) R8(-3.11,6.36) R9(-3.76,6.36) R11(-4.41,6.36) R12(-5.06,6.36) R13(-5.71,6.36) R15(-6.36,6.36) R16(-7.01,6.36) R18(-7.66,6.36) R19(-8.31,6.36) R20(-8.96,6.36) R22(-9.66,6.44) T2(-0.46,6.9) T4(-1.16,7.01) T5(-1.81,7.01) T6(-2.46,7.01) T8(-3.11,7.01) T9(-3.76,7.01) T11(-4.41,7.01) T12(-5.06,7.01) T13(-5.71,7.01) T15(-6.36,7.01) T16(-7.01,7.01) T18(-7.66,7.01) T19(-8.31,7.01) T20(-8.96,7.01) T22(-9.66,6.9) U2(-0.46,7.36) U22(-9.66,7.36) V2(-0.46,7.82) V4(-1.16,7.66) V5(-1.81,7.66) V6(-2.46,7.66) V8(-3.11,7.66) V9(-3.76,7.66) V11(-4.41,7.66) V12(-5.06,7.66) V13(-5.71,7.66) V15(-6.36,7.66) V16(-7.01,7.66) V18(-7.66,7.66) V19(-8.31,7.66) V20(-8.96,7.66) V22(-9.66,7.82) W2(-0.46,8.28) W4(-1.16,8.31) W5(-1.81,8.31) W6(-2.46,8.31) W8(-3.11,8.31) W9(-3.76,8.31) W11(-4.41,8.31) W12(-5.06,8.31) W13(-5.71,8.31) W15(-6.36,8.31) W16(-7.01,8.31) W18(-7.66,8.31) W19(-8.31,8.31) W20(-8.96,8.31) W22(-9.66,8.28) Y2(-0.46,8.74) Y4(-1.16,8.96) Y5(-1.81,8.96) Y6(-2.46,8.96) Y8(-3.11,8.96) Y9(-3.76,8.96) Y11(-4.41,8.96) Y12(-5.06,8.96) Y13(-5.71,8.96) Y15(-6.36,8.96) Y16(-7.01,8.96) Y18(-7.66,8.96) Y19(-8.31,8.96) Y20(-8.96,8.96) Y22(-9.66,8.74)
  oval 0.178x0.33 smd: A2(-0.46,0) A3(-0.92,0) A4(-1.38,0) A5(-1.84,0) A6(-2.3,0) A7(-2.76,0) A8(-3.22,0) A9(-3.68,0) A10(-4.14,0) A11(-4.6,0) A12(-5.06,0) A13(-5.52,0) A14(-5.98,0) A15(-6.44,0) A16(-6.9,0) A17(-7.36,0) A18(-7.82,0) A19(-8.28,0) A20(-8.74,0) A21(-9.2,0) A22(-9.66,0) AC2(-0.46,10.12) AC3(-0.92,10.12) AC4(-1.38,10.12) AC5(-1.84,10.12) AC6(-2.3,10.12) AC7(-2.76,10.12) AC8(-3.22,10.12) AC9(-3.68,10.12) AC10(-4.14,10.12) AC11(-4.6,10.12) AC12(-5.06,10.12) AC13(-5.52,10.12) AC14(-5.98,10.12) AC15(-6.44,10.12) AC16(-6.9,10.12) AC17(-7.36,10.12) AC18(-7.82,10.12) AC19(-8.28,10.12) AC20(-8.74,10.12) AC21(-9.2,10.12) AC22(-9.66,10.12)
  oval 0.33x0.178 smd: AA1(0,9.2) AA23(-10.12,9.2) AB1(0,9.66) AB23(-10.12,9.66) B1(0,0.46) B23(-10.12,0.46) C1(0,0.92) C23(-10.12,0.92) D1(0,1.38) D23(-10.12,1.38) E1(0,1.84) E23(-10.12,1.84) F1(0,2.3) F23(-10.12,2.3) G1(0,2.76) G23(-10.12,2.76) H1(0,3.22) H23(-10.12,3.22) J1(0,3.68) J23(-10.12,3.68) K1(0,4.14) K23(-10.12,4.14) L1(0,4.6) L23(-10.12,4.6) M1(0,5.06) M23(-10.12,5.06) N1(0,5.52) N23(-10.12,5.52) P1(0,5.98) P23(-10.12,5.98) R1(0,6.44) R23(-10.12,6.44) T1(0,6.9) T23(-10.12,6.9) U1(0,7.36) U23(-10.12,7.36) V1(0,7.82) V23(-10.12,7.82) W1(0,8.28) W23(-10.12,8.28) Y1(0,8.74) Y23(-10.12,8.74)
BAT54A-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BD9515NUX-E2_VSON008X2020-8
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.787 smd: 9(0.75,1.1)
BD99991GW-E2_UCSP55M4C99
  round 0.271 smd: A1(0,0) A2(0.4,0) A3(0.8,0) A4(1.2,0) A5(1.6,0) A6(2,0) A7(2.4,0) A8(2.8,0) A9(3.2,0) A10(3.6,0) B1(0,-0.4) B2(0.4,-0.4) B3(0.8,-0.4) B4(1.2,-0.4) B5(1.6,-0.4) B6(2,-0.4) B7(2.4,-0.4) B8(2.8,-0.4) B9(3.2,-0.4) B10(3.6,-0.4) C1(0,-0.8) C2(0.4,-0.8) C3(0.8,-0.8) C4(1.2,-0.8) C5(1.6,-0.8) C6(2,-0.8) C7(2.4,-0.8) C8(2.8,-0.8) C9(3.2,-0.8) C10(3.6,-0.8) D1(0,-1.2) D2(0.4,-1.2) D3(0.8,-1.2) D4(1.2,-1.2) D5(1.6,-1.2) D6(2,-1.2) D7(2.4,-1.2) D8(2.8,-1.2) D9(3.2,-1.2) D10(3.6,-1.2) E1(0,-1.6) E2(0.4,-1.6) E3(0.8,-1.6) E4(1.2,-1.6) E6(2,-1.6) E7(2.4,-1.6) E8(2.8,-1.6) E9(3.2,-1.6) E10(3.6,-1.6) F1(0,-2) F2(0.4,-2) F3(0.8,-2) F4(1.2,-2) F5(1.6,-2) F6(2,-2) F7(2.4,-2) F8(2.8,-2) F9(3.2,-2) F10(3.6,-2) G1(0,-2.4) G2(0.4,-2.4) G3(0.8,-2.4) G4(1.2,-2.4) G5(1.6,-2.4) G6(2,-2.4) G7(2.4,-2.4) G8(2.8,-2.4) G9(3.2,-2.4) G10(3.6,-2.4) H1(0,-2.8) H2(0.4,-2.8) H3(0.8,-2.8) H4(1.2,-2.8) H5(1.6,-2.8) H6(2,-2.8) H7(2.4,-2.8) H8(2.8,-2.8) H9(3.2,-2.8) H10(3.6,-2.8) J1(0,-3.2) J2(0.4,-3.2) J3(0.8,-3.2) J4(1.2,-3.2) J5(1.6,-3.2) J6(2,-3.2) J7(2.4,-3.2) J8(2.8,-3.2) J9(3.2,-3.2) J10(3.6,-3.2) K1(0,-3.6) K2(0.4,-3.6) K3(0.8,-3.6) K4(1.2,-3.6) K5(1.6,-3.6) K6(2,-3.6) K7(2.4,-3.6) K8(2.8,-3.6) K9(3.2,-3.6) K10(3.6,-3.6)
BD99992GW-E2_UCSP55M5C195
  round 0.271 smd: A1(0,0) A2(0.4,0) A3(0.8,0) A4(1.2,0) A5(1.6,0) A6(2,0) A7(2.4,0) A8(2.8,0) A9(3.2,0) A10(3.6,0) A11(4,0) A12(4.401,0) A13(4.801,0) A14(5.201,0) B1(0,-0.4) B2(0.4,-0.4) B3(0.8,-0.4) B4(1.2,-0.4) B5(1.6,-0.4) B6(2,-0.4) B7(2.4,-0.4) B8(2.8,-0.4) B9(3.2,-0.4) B10(3.6,-0.4) B11(4,-0.4) B12(4.401,-0.4) B13(4.801,-0.4) B14(5.201,-0.4) C1(0,-0.8) C2(0.4,-0.8) C3(0.8,-0.8) C4(1.2,-0.8) C5(1.6,-0.8) C6(2,-0.8) C7(2.4,-0.8) C8(2.8,-0.8) C9(3.2,-0.8) C10(3.6,-0.8) C11(4,-0.8) C12(4.401,-0.8) C13(4.801,-0.8) C14(5.201,-0.8) D1(0,-1.2) D2(0.4,-1.2) D3(0.8,-1.2) D5(1.6,-1.2) D6(2,-1.2) D7(2.4,-1.2) D8(2.8,-1.2) D9(3.2,-1.2) D10(3.6,-1.2) D11(4,-1.2) D12(4.401,-1.2) D13(4.801,-1.2) D14(5.201,-1.2) E1(0,-1.6) E2(0.4,-1.6) E3(0.8,-1.6) E4(1.2,-1.6) E5(1.6,-1.6) E6(2,-1.6) E7(2.4,-1.6) E8(2.8,-1.6) E9(3.2,-1.6) E10(3.6,-1.6) E11(4,-1.6) E12(4.401,-1.6) E13(4.801,-1.6) E14(5.201,-1.6) F1(0,-2) F2(0.4,-2) F3(0.8,-2) F4(1.2,-2) F5(1.6,-2) F6(2,-2) F7(2.4,-2) F8(2.8,-2) F9(3.2,-2) F10(3.6,-2) F11(4,-2) F12(4.401,-2) F13(4.801,-2) F14(5.201,-2) G1(0,-2.4) G2(0.4,-2.4) G3(0.8,-2.4) G4(1.2,-2.4) G5(1.6,-2.4) G6(2,-2.4) G7(2.4,-2.4) G8(2.8,-2.4) G9(3.2,-2.4) G10(3.6,-2.4) G11(4,-2.4) G12(4.401,-2.4) G13(4.801,-2.4) G14(5.201,-2.4) H1(0,-2.8) H2(0.4,-2.8) H3(0.8,-2.8) H4(1.2,-2.8) H5(1.6,-2.8) H6(2,-2.8) H7(2.4,-2.8) H8(2.8,-2.8) H9(3.2,-2.8) H10(3.6,-2.8) H11(4,-2.8) H12(4.401,-2.8) H13(4.801,-2.8) H14(5.201,-2.8) J1(0,-3.2) J2(0.4,-3.2) J3(0.8,-3.2) J4(1.2,-3.2) J5(1.6,-3.2) J6(2,-3.2) J7(2.4,-3.2) J8(2.8,-3.2) J9(3.2,-3.2) J10(3.6,-3.2) J11(4,-3.2) J12(4.401,-3.2) J13(4.801,-3.2) J14(5.201,-3.2) K1(0,-3.6) K2(0.4,-3.6) K3(0.8,-3.6) K4(1.2,-3.6) K5(1.6,-3.6) K6(2,-3.6) K7(2.4,-3.6) K8(2.8,-3.6) K9(3.2,-3.6) K10(3.6,-3.6) K11(4,-3.6) K12(4.401,-3.6) K13(4.801,-3.6) K14(5.201,-3.6) L1(0,-4) L2(0.4,-4) L3(0.8,-4) L4(1.2,-4) L5(1.6,-4) L6(2,-4) L7(2.4,-4) L8(2.8,-4) L9(3.2,-4) L10(3.6,-4) L11(4,-4) L12(4.401,-4) L13(4.801,-4) L14(5.201,-4) M1(0,-4.401) M2(0.4,-4.401) M3(0.8,-4.401) M4(1.2,-4.401) M5(1.6,-4.401) M6(2,-4.401) M7(2.4,-4.401) M8(2.8,-4.401) M9(3.2,-4.401) M10(3.6,-4.401) M11(4,-4.401) M12(4.401,-4.401) M13(4.801,-4.401) M14(5.201,-4.401) N1(0,-4.801) N2(0.4,-4.801) N3(0.8,-4.801) N4(1.2,-4.801) N5(1.6,-4.801) N6(2,-4.801) N7(2.4,-4.801) N8(2.8,-4.801) N9(3.2,-4.801) N10(3.6,-4.801) N11(4,-4.801) N12(4.401,-4.801) N13(4.801,-4.801) N14(5.201,-4.801) P1(0,-5.201) P2(0.4,-5.201) P3(0.8,-5.201) P4(1.2,-5.201) P5(1.6,-5.201) P6(2,-5.201) P7(2.4,-5.201) P8(2.8,-5.201) P9(3.2,-5.201) P10(3.6,-5.201) P11(4,-5.201) P12(4.401,-5.201) P13(4.801,-5.201) P14(5.201,-5.201)
BELLW_10093-1021_4P
  rect 0.61x0.559 smd: 1(0,0)
  custom 0.145x0.145 smd: 2(0.96,0.975) 4(-0.96,0.975)
  rect 0.508x0.508 smd: 3(0,1.975)
BQ24777RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_A
  rect 1.626x1.829 smd: 1(0.389,0) 2(2.989,0)
C_B3
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
CHILI_CMMI21T-900Y-N_4P
  rect 0.356x0.889 smd: 1(0,0) 2(0,1.7) 3(0.85,1.7) 4(0.85,0)
CYNTE_PCMB041B-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCME061E-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PIME051E-R22MS3R805_2P
  rect 1.905x2.489 smd: 1(0,0) 2(4.095,0)
DCX124EU-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN2400UFB4-7_DFN1006H4-3
  rect 0.406x0.711 smd: 1(0,0)
  rect 0.406x0.254 smd: 2(0.7,-0.225) 3(0.7,0.225)
DMN2400UV-7_SOT-563-6
  oval 0.305x0.508 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.7) 5(0.5,1.7) 6(0,1.7)
DMP3099L-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
EDFA164A1MA-GD-F_FBGA_253P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) A14(6.502,0) A15(7.002,0) A16(7.502,0) A17(8.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) B14(6.502,-0.5) B15(7.002,-0.5) B16(7.502,-0.5) B17(8.002,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) C5(2.001,-1) C6(2.501,-1) C7(3.001,-1) C8(3.501,-1) C9(4.001,-1) C10(4.501,-1) C11(5.001,-1) C12(5.501,-1) C13(6.002,-1) C14(6.502,-1) C15(7.002,-1) C16(7.502,-1) C17(8.002,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) D14(6.502,-1.5) D15(7.002,-1.5) D16(7.502,-1.5) D17(8.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E3(1,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E9(4.001,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) E14(6.502,-2.001) E15(7.002,-2.001) E16(7.502,-2.001) E17(8.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F3(1,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) F14(6.502,-2.501) F15(7.002,-2.501) F16(7.502,-2.501) F17(8.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G3(1,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) G14(6.502,-3.001) G15(7.002,-3.001) G16(7.502,-3.001) G17(8.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H3(1,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) H14(6.502,-3.501) H15(7.002,-3.501) H16(7.502,-3.501) H17(8.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J3(1,-4.001) J4(1.5,-4.001) J5(2.001,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) J14(6.502,-4.001) J15(7.002,-4.001) J16(7.502,-4.001) J17(8.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) K14(6.502,-4.501) K15(7.002,-4.501) K16(7.502,-4.501) K17(8.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) L14(6.502,-5.001) L15(7.002,-5.001) L16(7.502,-5.001) L17(8.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) M14(6.502,-5.501) M15(7.002,-5.501) M16(7.502,-5.501) M17(8.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002) N14(6.502,-6.002) N15(7.002,-6.002) N16(7.502,-6.002) N17(8.002,-6.002) P1(0,-6.502) P2(0.5,-6.502) P3(1,-6.502) P4(1.5,-6.502) P5(2.001,-6.502) P6(2.501,-6.502) P7(3.001,-6.502) P8(3.501,-6.502) P9(4.001,-6.502) P10(4.501,-6.502) P11(5.001,-6.502) P12(5.501,-6.502) P13(6.002,-6.502) P14(6.502,-6.502) P15(7.002,-6.502) P16(7.502,-6.502) P17(8.002,-6.502) R1(0,-7.002) R2(0.5,-7.002) R3(1,-7.002) R4(1.5,-7.002) R5(2.001,-7.002) R6(2.501,-7.002) R7(3.001,-7.002) R8(3.501,-7.002) R9(4.001,-7.002) R10(4.501,-7.002) R11(5.001,-7.002) R12(5.501,-7.002) R13(6.002,-7.002) R14(6.502,-7.002) R15(7.002,-7.002) R16(7.502,-7.002) R17(8.002,-7.002) T1(0,-7.502) T2(0.5,-7.502) T3(1,-7.502) T4(1.5,-7.502) T5(2.001,-7.502) T6(2.501,-7.502) T7(3.001,-7.502) T8(3.501,-7.502) T9(4.001,-7.502) T10(4.501,-7.502) T11(5.001,-7.502) T12(5.501,-7.502) T13(6.002,-7.502) T14(6.502,-7.502) T15(7.002,-7.502) T16(7.502,-7.502) T17(8.002,-7.502) U1(0,-8.002) U2(0.5,-8.002) U3(1,-8.002) U4(1.5,-8.002) U5(2.001,-8.002) U6(2.501,-8.002) U7(3.001,-8.002) U8(3.501,-8.002) U9(4.001,-8.002) U10(4.501,-8.002) U11(5.001,-8.002) U12(5.501,-8.002) U13(6.002,-8.002) U14(6.502,-8.002) U15(7.002,-8.002) U16(7.502,-8.002) U17(8.002,-8.002)
